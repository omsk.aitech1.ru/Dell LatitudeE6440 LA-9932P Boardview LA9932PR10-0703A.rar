# Allegro board LA9932PR10-0703A.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3.3V_ALW on TOP (solid shape): 221.8,126.8 222.19,126.8 222.38,126.61 222.38,125.32 222.25,125.19 221.7,125.19 221.7,125.18 221.5,125.18 221.37,125.05 221.37,124.53 221.31,124.48 220.81,124.48 220.78,124.51 220.78,125.09 220.27,125.6 220.27,126.92 220.33,126.98 221.62,126.98
+3.3V_ALW on TOP (solid shape): 228.18,114.42 230.4,114.42 231.12,113.7 232.91,113.7 233.09,113.51 233.09,113 232.91,112.82 229.6,112.82 229.59,112.83 228.21,112.83 227.61,113.43 226.32,113.43 226.24,113.51 226.24,114.49 226.32,114.56 228.04,114.56
+3.3V_ALW on TOP (solid shape): 234.81,139.04 234.99,139.04 235.04,139.03 235.08,139.03 235.17,139.03 235.27,138.93 235.27,138.67 234.98,138.39 234.98,138.08 234.88,137.99 233.31,137.99 233.17,138.13 233.17,138.34 232.94,138.57 232.94,139.46 233.07,139.58 234.27,139.58
+3.3V_ALW on TOP (solid shape): 189.12,83.35 189.12,80.53 189,80.42 188.11,80.42 188.09,80.44 184.98,80.44 184.12,79.59 180.63,79.59 180.34,79.3 180.34,77.14 180.53,76.95 180.98,76.95 181.04,76.89 181.04,76.31 180.98,76.24 179.33,76.24 179.22,76.36 179.22,79.62 180.22,80.63 181.67,80.63 182.92,81.87 184.98,83.94 188.53,83.94
+3.3V_ALW on TOP (solid shape): 182.09,120.38 182.09,119.45 181.65,119.01 179.79,119.01 179.62,118.84 179.62,118.2 179.61,118.17 179.57,118.15 178.08,118.15 177.91,118.32 177.91,119.19 178.05,119.33 178.05,119.92 178.13,120 180.71,120 181.19,120.48 182,120.48
+3.3V_ALW on TOP (solid shape): 223.84,53.84 223.84,51.36 223.52,51.04 222.82,51.04 222.82,51.56 222.12,51.56 222.12,51.04 221.62,51.04 221.62,51.56 220.92,51.56 220.92,51.04 219.1,51.04 218.54,51.6 217.9,51.6 217.87,51.57 217.87,51.08 217.83,51.05 217.64,51.05 217.64,51.58 217.61,51.62 217.12,51.62 217.08,51.57 217.08,51.09 217.04,51.05 216.85,51.05 216.84,51.07 216.84,51.43 216.83,51.43 216.83,51.58 216.8,51.62 216.73,51.62 216.19,51.62 216.09,51.71 216.09,52.31 218.25,54.47 223.2,54.47
+3.3V_ALW on TOP (solid shape): 193.96,133.86 193.96,132.49 193.94,132.46 193.92,132.46 193.64,132.11 193.92,131.76 193.94,131.76 193.96,131.73 193.96,125.99 193.92,125.94 193.9,125.94 193.71,125.8 193.64,125.57 193.64,125.55 193.62,125.53 192.35,124.26 186.43,124.26 185.99,124.7 185.99,125.17 185.05,126.11 182.89,126.11 182.53,126.47 182.53,127.48 182.62,127.56 183.55,127.56 183.6,127.51 183.6,126.81 183.74,126.67 188.03,126.67 188.16,126.79 188.61,126.79 188.85,126.7 189.1,126.79 190.66,126.79 190.85,126.99 190.85,133.62 191.66,134.43 193.39,134.43
+3.3V_ALW on BOTTOM (solid shape): 83.94,150.97 83.94,149.47 83.8,149.32 82.83,149.32 82.6,149.56 82.6,150.95 82.78,151.12 83.79,151.12
+3.3V_ALW on BOTTOM (solid shape): 103.17,129.14 103.68,129.14 103.68,129.67 103.97,129.67 103.97,129.14 104.48,129.14 104.48,129.67 106.29,129.67 106.77,129.19 106.77,127.98 107,127.75 107.32,127.75 107.55,127.52 108.56,127.52 108.78,127.3 108.78,126.61 108.6,126.43 108.05,126.43 108.03,126.43 108.03,125.9 107.78,125.9 107.78,126.43 107.25,126.43 107.23,126.43 107.23,125.9 106.98,125.9 106.98,126.43 106.1,126.43 105.28,127.24 103.06,127.24 102.26,128.04 102.26,129.49 102.45,129.67 103.17,129.67
+3.3V_ALW on BOTTOM (solid shape): 193.79,170.68 193.87,170.64 193.89,170.56 194.24,170.12 194.58,170.56 194.6,170.64 194.68,170.68 196.21,170.68 196.46,170.43 196.46,169.29 196.23,169.06 191.14,169.06 190.35,168.27 190.35,167.27 190.25,167.18 189,167.18 188.8,167.38 188.8,170.29 189.19,170.68
+3.3V_ALW on IN1 (solid shape): 222.89,94.99 222.89,93.72 222.7,93.53 220.41,93.53 220.16,93.78 220.16,95.05 220.41,95.3 222.57,95.3
+3.3V_ALW on IN1 (solid shape): 201.25,100.01 201.25,99.11 202.16,98.2 202.16,97.85 201.41,97.1 200.87,97.1 199.4,98.57 199.4,100.01 199.64,100.26 201,100.26
+3.3V_ALW on IN1 (solid shape): outline of 280 points within 180.08,55.67 192,59.52
+3.3V_ALW on IN3 (solid shape): 105.85,130.34 105.85,126.92 105.6,126.67 101.03,126.67 100.27,127.43 100.27,129.97 100.97,130.67 105.51,130.67
+3.3V_ALW on IN3 (solid shape): outline of 617 points within 106.17,146.93 131.32,152.58
+3.3V_ALW on IN3 (solid shape): outline of 771 points within 192.5,125.3 222.44,132.98
+3.3V_ALW on IN3 (solid shape): outline of 1008 points within 145.9,99.52 172.84,111.52
+3.3V_ALW on IN3 (solid shape): outline of 1263 points within 176.91,82 210.5,96.57
+3.3V_ALW on IN4 (solid shape): outline of 124 points within 176.9,58.77 180.66,63.92
+3.3V_ALW on IN4 (solid shape): outline of 233 points within 233.05,137.65 248.41,148.9
+3.3V_ALW on VCC: 189.17,18.47 189.17,42.94 191.52,45.29 191.52,59.83 194.63,62.94 194.63,78.56 207.84,91.77 207.84,92.66 208.07,92.89 209.21,92.89 209.81,93.48 209.81,106.25 210.29,106.73 216.01,106.73 219.39,110.12 219.39,143.01 224.22,147.84 224.22,158.02 222.44,159.8 222.44,172.23 234.59,172.23 235.66,172.67 236.11,173.73 239.09,173.73 241.93,174.91 243.11,177.75 243.11,184.52 256.01,184.52 258.07,186.57 258.07,201.94 259.57,203.44 264.77,203.44 264.87,203.44 283.42,203.44 287.34,199.53 287.34,197.41 276.88,197.41 274.07,194.6 274.07,175.92 274.06,175.92 274.06,175.64 272.35,173.93 268.63,173.93 254.15,159.44 247.93,159.44 241.94,153.45 241.94,139.73 235.4,133.19 235.4,73.63 230.08,68.32 222.65,68.32 216.35,62.01 216.35,56.34 218.02,54.66 220.24,54.66 220.92,53.99 220.92,30.58 208.81,18.47
+3.3V_ALW_5048 on TOP (solid shape): 183.21,79.43 183.21,78.89 183.22,78.88 183.67,78.88 183.7,78.9 183.7,79.41 183.74,79.44 184.13,79.44 184.95,78.62 184.95,77.22 185.19,76.98 185.19,75.86 185.08,75.75 184.64,75.75 184.53,75.86 184.53,76.39 184.22,76.7 183.74,76.7 183.61,76.83 183.61,77.6 182.78,78.43 182.78,79.37 182.87,79.46 183.18,79.46
+3.3V_ALW_PCH on TOP (solid shape): 219.03,126.89 219.03,126.08 218.4,125.46 216.48,125.46 216.39,125.54 216.39,126.42 216.47,126.49 217.73,126.49 218.23,126.99 218.92,126.99
+3.3V_ALW_PCH on TOP (solid shape): 171.9,129.28 171.9,128.83 171.83,128.77 170.63,128.77 170.19,128.33 170.12,128.33 169.74,127.94 167.13,127.94 167.07,128.01 167.07,128.52 167.33,128.77 169.8,128.77 170.1,129.06 170.1,129.19 170.25,129.34 171.83,129.34
+3.3V_ALW_PCH on TOP (solid shape): 188.48,131.25 188.48,127.58 187.74,126.84 183.9,126.84 183.82,126.92 183.82,127.5 183.96,127.64 184.72,127.64 185.18,128.09 186.32,128.09 186.94,128.72 186.94,131.3 187.07,131.43 188.3,131.43
+3.3V_ALW_PCH on BOTTOM (solid shape): 189.61,130.42 189.61,129.66 189.42,129.47 187.9,129.47 187.71,129.66 187.71,130.36 187.96,130.61 189.42,130.61
+3.3V_ALW_PCH on BOTTOM (solid shape): 206.19,126.71 206.19,126.49 205.54,125.85 205.32,125.85 204.04,127.13 204.04,127.66 204.36,127.98 204.92,127.98
+3.3V_ALW_PCH on BOTTOM (solid shape): 218.44,126.16 218.44,125.59 218.19,125.34 215.84,125.34 215.71,125.47 215.71,126.23 215.9,126.42 218.19,126.42
+3.3V_ALW_PCH on BOTTOM (solid shape): 169.53,137.29 169.53,137.11 169.79,136.86 169.79,135.92 169.66,135.8 169.59,135.8 169.21,136.17 169.21,136.6 169.24,136.63 169.24,136.9 169,137.14 169,137.25 169.19,137.45 169.37,137.45
+3.3V_ALW_PCH on BOTTOM (solid shape): 166.46,122.59 166.46,121.66 166.37,121.57 166.37,118.45 166.3,118.38 166.3,116.66 166.19,116.55 165.39,116.55 165.26,116.68 165.26,119.84 165.29,119.86 165.5,120.18 165.29,120.51 165.26,120.52 165.26,122.57 165.42,122.73 166.33,122.73
+3.3V_ALW_PCH on BOTTOM (solid shape): 169.79,139.3 169.79,139.19 169.55,138.96 169.55,138.71 170,138.26 170,137.72 169.82,137.54 169.75,137.51 169.69,137.46 169.62,137.43 169.55,137.46 169.05,137.95 168.87,137.95 168.68,137.77 168.55,137.77 168.38,137.93 168.38,138.11 169.01,138.74 169.01,138.92 169.19,139.1 169.26,139.1 169.56,139.39 169.69,139.39
+3.3V_ALW_PCH on IN2 (solid shape): outline of 3053 points within 164.44,116.56 189.73,140.19
+3.3V_ALW_VTR on TOP (solid shape): 212.66,71.3 212.66,70.48 212.6,70.41 211.52,70.41 211.39,70.54 211.39,70.98 211.27,71.11 211.27,71.36 211.33,71.43 212.54,71.43
+3.3V_ALW_VTR on TOP (solid shape): 219.5,70.53 219.5,69.7 220.06,69.14 220.06,68.66 220.61,68.66 220.61,68.48 220.06,68.48 220.06,67.68 219.65,67.28 218.45,67.28 218.38,67.35 218.38,70.56 218.51,70.7 219.33,70.7
+3.3V_CARD on TOP (solid shape): 234.04,67.1 234.04,66.3 233.77,66.03 233.77,65.98 233.71,65.78 233.77,65.57 233.77,64.59 233.72,64.54 232.35,64.54 232.03,64.86 232.03,67.01 232.24,67.22 233.92,67.22
+3.3V_CARD on TOP (solid shape): 224.03,36.64 224.03,36.5 224.23,36.3 225.33,36.3 225.44,36.19 225.44,35.61 225.34,35.51 224.31,35.51 224.13,35.33 224.13,34.86 224.13,34.79 224.04,34.69 223.76,34.69 223.01,35.43 223.01,36.97 223.07,37.03 223.64,37.03
+3.3V_CARD on IN2 (solid shape): 233.29,66.26 233.29,64.95 233.05,64.7 230.41,64.7 230.14,64.98 230.14,66.09 230.51,66.47 233.08,66.47
+3.3V_CARD on IN2 (solid shape): 224.78,38.6 224.78,34.87 224.57,34.66 222.77,34.66 222.43,35.01 222.43,37.42 223.52,37.42 223.52,37.36 223.53,37.31 223.55,37.26 223.57,37.21 223.6,37.17 223.63,37.13 223.68,37.1 223.72,37.07 223.77,37.05 223.82,37.04 223.88,37.04 223.93,37.04 223.98,37.05 224.03,37.07 224.08,37.1 224.12,37.13 224.16,37.17 224.19,37.21 224.21,37.26 224.22,37.31 224.23,37.36 224.23,37.42 224.22,37.47 224.21,37.52 224.19,37.57 224.16,37.61 224.12,37.65 224.08,37.69 224.03,37.71 223.98,37.73 223.93,37.74 223.88,37.75 223.82,37.74 223.77,37.73 223.72,37.71 223.68,37.69 223.63,37.65 223.6,37.61 223.57,37.57 223.55,37.52 223.53,37.47 223.52,37.42 222.43,37.42 222.43,38.73 222.62,38.93 224.45,38.93
+3.3V_LAN on TOP (solid shape): 248.15,159.84 248.15,158.94 248.06,158.85 245.72,158.85 245.63,158.94 245.63,160.3 245.73,160.4 247.59,160.4
+3.3V_LAN on TOP (solid shape): 249.34,152.74 249.34,150.93 249.03,150.62 247.26,150.62 247.2,150.68 247.2,151.34 247.47,151.61 247.47,152.8 247.68,153.02 249.07,153.02
+3.3V_LAN on TOP (solid shape): 247.58,206.73 247.58,206 247.13,205.55 246.53,205.55 245.87,206.21 244.32,206.21 244.15,206.04 243.59,206.04 243.54,206.09 243.54,206.95 243.8,207.22 247.09,207.22
+3.3V_LAN on BOTTOM (solid shape): 265.5,207.52 267.59,207.52 267.9,207.21 267.9,206.15 267.86,206.1 265.48,206.1 264.49,207.09 259.92,207.09 259.87,207.04 259.33,207.04 258.98,207.39 258.98,208.01 259.36,208.4 264.62,208.4
+3.3V_LAN on IN2 (solid shape): outline of 405 points within 246.19,151.59 254.5,171.81
+3.3V_LAN on IN3 (solid shape): outline of 606 points within 243.59,169.26 261.84,183.95
+3.3V_LAN_OUT on TOP (solid shape): 244.1,163.19 244.22,163.19 244.29,163.12 244.29,162.87 244.16,162.74 242.7,162.74 242.64,162.8 242.64,163.31 242.7,163.38 243.91,163.38
+3.3V_LAN_OUT on TOP (solid shape): 249.79,160.77 249.79,159.13 249.55,158.9 248.87,158.9 248.79,158.98 248.79,159.76 248.42,160.13 248.11,160.13 247.7,160.54 247.18,160.54 247.07,160.66 247.07,161.51 247.18,161.62 248.93,161.62
+3.3V_LAN_OUT on BOTTOM (solid shape): outline of 144 points within 236.06,160.48 248.15,168.85
+3.3V_M on TOP (solid shape): 225.99,70.31 225.99,68.96 225.33,68.29 223.7,68.29 223.55,68.44 223.55,69.96 223.7,70.11 224.8,70.11 225.04,70.35 225.44,70.35 225.44,70.35 225.95,70.35
+3.3V_M on TOP (solid shape): 166.82,130.17 166.82,129.91 167.13,129.59 167.13,128.83 166.82,128.51 166.82,127.63 166.88,127.56 166.88,127.19 166.77,127.08 166.31,127.08 166.24,127.14 166.24,127.45 165.93,127.76 165.79,127.76 165.6,127.95 165.6,129.3 166.16,129.3 166.16,129.24 166.17,129.19 166.18,129.14 166.21,129.1 166.24,129.05 166.27,129.02 166.32,128.99 166.36,128.96 166.41,128.95 166.46,128.94 166.52,128.94 166.57,128.95 166.62,128.96 166.66,128.99 166.7,129.02 166.74,129.05 166.77,129.1 166.8,129.14 166.81,129.19 166.82,129.24 166.82,129.3 166.81,129.35 166.8,129.4 166.77,129.44 166.74,129.48 166.7,129.52 166.66,129.55 166.62,129.58 166.57,129.59 166.52,129.6 166.46,129.6 166.41,129.59 166.36,129.58 166.32,129.55 166.27,129.52 166.24,129.48 166.21,129.44 166.18,129.4 166.17,129.35 166.16,129.3 165.6,129.3 165.6,129.59 166.24,130.23 166.75,130.23
+3.3V_M on BOTTOM (solid shape): 224.98,69.88 224.98,68.44 224.86,68.32 223.97,68.32 223.65,68.63 223.65,70.35 223.71,70.41 224.45,70.41
+3.3V_PCIE_FLASH on TOP (solid shape): 268.1,179.67 268.1,177.72 267.72,177.34 266,177.34 265.93,177.41 265.93,178.06 266.66,178.79 266.66,179.52 267.01,179.87 267.89,179.87
+3.3V_PCIE_FLASH on TOP (solid shape): 279.27,164.07 279.27,162.61 279.08,162.42 277.81,162.42 277.69,162.55 277.69,164.33 277.81,164.46 278.89,164.46
+3.3V_PCIE_FLASH on TOP (solid shape): 285.74,166.17 286.46,166.17 286.56,166.06 286.56,165.57 286.51,165.52 283.39,165.52 283.13,165.78 283.13,166.49 283.36,166.72 285.19,166.72
+3.3V_PCIE_FLASH on TOP (solid shape): 277.41,186.37 277.69,186.37 277.69,186.18 277.76,186.11 277.75,186.04 277.74,185.98 277.74,185.08 277.73,185.04 277.69,185.03 277.18,185.03 277.05,185.16 277.05,185.79 276.93,185.92 276.51,185.92 276.29,186.14 276.29,186.36 276.42,186.49 277.3,186.49
+3.3V_PCIE_FLASH on BOTTOM (solid shape): 278.7,186.3 278.7,185.22 278.51,185.03 276.73,185.03 276.29,185.47 276.29,186.24 276.48,186.43 278.58,186.43
+3.3V_PCIE_FLASH on BOTTOM (solid shape): 276.75,173.68 278.38,173.68 278.6,173.46 278.6,173.21 278.41,173.01 276,173.01 275.84,172.85 275.51,172.85 275.32,173.04 275.32,173.56 275.48,173.71 276.71,173.71
+3.3V_PCIE_FLASH on BOTTOM (solid shape): 286.78,167.49 286.78,166.32 286.7,166.23 284.75,166.23 284.28,165.77 284.27,165.77 283.72,165.22 280.48,165.22 280.04,164.77 280.04,162.26 279.58,161.81 276.74,161.81 276.57,161.98 276.57,162.31 276.75,162.49 278.58,162.49 278.77,162.67 278.77,166.04 279.4,166.68 282.83,166.68 283.19,167.03 283.19,167.04 283.81,167.67 286.61,167.67
+3.3V_PCIE_FLASH on IN3 (solid shape): outline of 781 points within 266.73,165.03 284.8,187
+3.3V_PCIE_WWAN on TOP (solid shape): 277.31,178.49 277.31,177.92 276.61,177.22 276.61,176.83 276.46,176.68 275.32,176.68 275.21,176.79 275.21,177.28 276.04,178.11 276.04,178.49 276.23,178.68 277.12,178.68
+3.3V_PCIE_WWAN on TOP (solid shape): 265.23,184.53 265.23,181.5 265.04,181.31 264.57,181.31 264.42,181.15 264.42,178.45 264.56,178.31 264.56,177.41 264.49,177.33 261.93,177.33 261.75,177.51 261.75,178.04 261.42,178.37 261.42,179.24 261.16,179.5 261.16,179.5 261.1,179.56 260.49,179.56 260.21,179.83 260.21,184.06 261.69,185.54 264.23,185.54
+3.3V_PCIE_WWAN on BOTTOM (solid shape): 282.76,194.79 282.76,191.7 282.37,191.31 281.34,191.31 281.24,191.41 281.24,195.01 281.42,195.19 282.37,195.19
+3.3V_PCIE_WWAN on BOTTOM (solid shape): 270.66,195.03 270.66,192.34 271.4,191.61 271.4,189.39 271.17,189.15 270.2,189.15 269.98,189.37 269.98,192.85 270.05,192.91 270.05,195.08 270.16,195.19 270.5,195.19
+3.3V_PCIE_WWAN on BOTTOM (solid shape): 277.53,204.7 277.53,203.61 277.46,203.54 277.46,199.08 277.05,198.68 275.21,198.68 274.9,198.99 274.9,200.9 275.02,201.02 275.71,201.02 276.05,201.36 276.05,203.87 275.89,204.04 275.89,204.71 275.99,204.8 277.42,204.8
+3.3V_PCIE_WWAN on BOTTOM (solid shape): 258.67,194.99 258.67,193.22 260.73,191.16 260.75,191.12 260.73,191.09 260.68,191.04 260.68,181.68 260.54,181.54 259.72,181.54 259.14,182.11 259.14,190.97 258.73,191.38 258.04,191.38 258.03,191.4 258.03,195.13 258.07,195.17 258.49,195.17
+3.3V_PCIE_WWAN on IN4 (solid shape): outline of 1373 points within 262.54,176.6 282.78,200.95
+3.3V_RUN on TOP (solid shape): 84.33,58.98 84.33,58.16 83.57,57.39 81.28,57.39 80.96,57.71 80.96,58.6 81.6,59.24 84.08,59.24
+3.3V_RUN on TOP (solid shape): 281.88,163.44 281.88,162.74 281.43,162.3 279.97,162.3 279.91,162.36 279.91,163.5 280.1,163.69 281.62,163.69
+3.3V_RUN on TOP (solid shape): 189.14,80.11 189.14,77.35 188.97,77.18 187.08,77.18 187.01,77.25 187.01,77.81 187.18,77.98 187.78,77.98 188.09,78.29 188.09,80.01 188.29,80.22 189.04,80.22
+3.3V_RUN on TOP (solid shape): 219,130.69 219,128.43 218.94,128.37 218.19,128.37 217.92,128.63 216.63,128.63 216.4,128.87 216.4,129.91 217.33,130.85 218.85,130.85
+3.3V_RUN on TOP (solid shape): 156.14,38.72 156.51,38.72 156.64,38.58 156.64,37.29 156.42,37.06 154.09,37.06 154.04,37.11 154.04,38.65 154.11,38.72 156.14,38.72
+3.3V_RUN on TOP (solid shape): 210.59,120.35 210.59,119.78 210.31,119.51 210.31,118.97 210.2,118.85 209.9,118.85 209.9,119.38 209.46,119.38 209.46,118.85 209.07,118.85 208.91,119.01 208.91,120.39 209.06,120.54 210.39,120.54
+3.3V_RUN on TOP (solid shape): 235.07,67.11 235.07,66.73 235.28,66.52 235.68,66.52 235.81,66.38 235.81,65.9 235.29,65.37 235.29,64.52 235.23,64.46 235.06,64.46 234.98,64.54 234.98,65.37 234.9,65.45 234.9,66.06 234.3,66.66 234.3,67.19 234.34,67.23 234.95,67.23
+3.3V_RUN on TOP (solid shape): 188.28,23.99 188.28,23.23 188.67,22.84 188.67,21.34 188.6,21.27 188.6,20.4 188.52,20.32 188.04,20.32 187.97,20.4 187.97,21.5 188.09,21.63 188.09,23.99 188.15,24.06 188.22,24.06
+3.3V_RUN on TOP (solid shape): 192.42,168.11 192.42,167.84 192.39,167.81 191.87,167.81 191.86,167.8 191.86,167.34 191.88,167.32 192.37,167.32 192.41,167.28 192.41,166.9 192.29,166.77 190.99,166.77 190.77,166.99 190.77,167 190.55,167.21 190.55,167.9 190.95,168.3 192.23,168.3
+3.3V_RUN on TOP (solid shape): 79.39,48.99 79.39,46.91 79.38,46.91 78.83,46.91 78.83,46.44 78.85,46.42 79.39,46.42 79.39,46.15 79.27,46.04 77.78,46.04 77.47,46.35 77.47,48.95 77.85,49.33 79.05,49.33
+3.3V_RUN on TOP (solid shape): 179.47,23.98 179.47,23.97 179.52,23.93 179.52,22.77 179.79,22.5 180.78,22.5 180.95,22.67 181.41,22.67 181.48,22.6 181.48,22.03 181.41,21.96 180.84,21.96 180.67,21.79 179.56,21.79 179.43,21.92 178.68,21.92 178.54,21.77 177.76,21.77 177.62,21.92 177.62,23.81 177.83,24.02 179.43,24.02
+3.3V_RUN on TOP (solid shape): 90.74,57.33 90.74,54.73 90.49,54.47 90.3,54.47 90.24,54.54 90.24,54.98 90.17,55.04 89.66,55.04 89.66,54.54 89.6,54.47 89.03,54.47 88.71,54.79 88.71,55.3 88.39,55.62 86.55,55.62 86.23,55.93 86.23,56.76 85.92,57.08 85.29,57.08 85.16,57.2 85.16,57.85 85.28,57.97 90.11,57.97
+3.3V_RUN on TOP (solid shape): outline of 121 points within 175.59,131.2 187.11,140.55
+3.3V_RUN on TOP (solid shape): outline of 160 points within 132.46,153.03 138.69,158.47
+3.3V_RUN on BOTTOM (solid shape): 4.13,180.71 4.13,180.14 4,180.01 1.27,180.01 1.27,180.9 3.94,180.9
+3.3V_RUN on BOTTOM (solid shape): 223.29,86.07 223.29,83.09 222.82,82.62 222.03,82.62 221.41,83.23 221.41,86.02 221.66,86.27 223.09,86.27
+3.3V_RUN on BOTTOM (solid shape): 152.78,128.36 152.78,126.95 152.67,126.84 151.59,126.84 151.5,126.93 151.5,128.32 151.66,128.49 152.66,128.49
+3.3V_RUN on BOTTOM (solid shape): 165.57,134.05 165.57,133.86 165.8,133.62 165.8,133.34 164.97,132.51 164.63,132.51 164.51,132.64 164.51,132.89 164.81,133.19 164.81,133.62 165.08,133.89 165.08,134.05 165.23,134.21 165.41,134.21
+3.3V_RUN on BOTTOM (solid shape): 233.76,170.06 233.76,169.56 234.11,169.21 235.16,169.21 235.29,169.09 235.29,168.75 235.17,168.63 234.03,168.63 233.62,168.22 232.35,168.22 232.17,168.41 232.17,170.09 232.36,170.27 233.54,170.27
+3.3V_RUN on BOTTOM (solid shape): 264.85,158.44 264.85,157.83 264.86,157.83 264.86,157.81 265.37,157.81 265.37,157.55 264.86,157.55 264.86,157.53 264.85,157.53 264.85,157.03 264.86,157.03 264.86,157.01 265.37,157.01 265.37,156.8 265.33,156.75 264.86,156.75 264.86,156.73 264.85,156.73 264.85,156.27 264.67,156.27 264.47,156.07 264.47,155.65 264.33,155.5 263.6,155.5 263.52,155.58 263.52,158.47 263.65,158.59 264.7,158.59
+3.3V_RUN on BOTTOM (solid shape): outline of 105 points within 169.74,154.83 176.46,159.65
+3.3V_RUN on BOTTOM (solid shape): outline of 306 points within 207.3,89.96 216.96,93.93
+3.3V_RUN on IN1 (solid shape): 10.16,184.08 10.16,183.06 10.03,182.93 9.27,182.93 9.15,183.06 9.15,184.08 9.27,184.2 10.03,184.2
+3.3V_RUN on IN1 (solid shape): 89.41,58.92 89.41,54.66 89.16,54.41 87.57,54.41 87.19,54.79 87.19,57.14 86.43,57.9 83.25,57.9 83,58.16 83,59.11 83.19,59.3 89.03,59.3
+3.3V_RUN on IN1 (solid shape): 4.09,181.15 4.15,181.14 4.21,181.15 4.25,181.16 4.67,181.16 4.7,181.15 4.76,181.14 4.82,181.15 4.86,181.16 5.34,181.16 5.91,180.58 5.91,180.52 4.76,179.38 4.07,179.38 3.62,179.82 3.24,179.82 3.11,179.95 3.11,180.29 4.22,180.29 4.22,180.24 4.23,180.19 4.24,180.14 4.26,180.09 4.29,180.04 4.33,180.01 4.37,179.97 4.42,179.95 4.47,179.93 4.52,179.91 4.57,179.91 4.63,179.91 4.68,179.93 4.73,179.95 4.77,179.97 4.82,180.01 4.85,180.04 4.88,180.09 4.91,180.14 4.92,180.19 4.93,180.24 4.93,180.29 4.92,180.35 4.91,180.4 4.88,180.44 4.85,180.49 4.82,180.53 4.77,180.56 4.73,180.59 4.68,180.61 4.63,180.62 4.57,180.62 4.52,180.62 4.47,180.61 4.42,180.59 4.37,180.56 4.33,180.53 4.29,180.49 4.26,180.44 4.24,180.4 4.23,180.35 4.22,180.29 3.11,180.29 3.11,180.84 3.43,181.16 4.06,181.16
+3.3V_RUN on IN1 (solid shape): outline of 212 points within 177.57,18.33 188.6,22.56
+3.3V_RUN on IN1 (solid shape): outline of 471 points within 154.61,116.03 163.51,122.93
+3.3V_RUN on IN2 (solid shape): 235.9,67.76 235.9,65.72 235.58,65.39 233.94,65.39 233.62,65.71 233.62,67.81 233.97,68.16 235.51,68.16
+3.3V_RUN on IN2 (solid shape): 224.21,84.23 224.21,82.14 224.09,82.02 222.53,82.02 222.46,82.09 222.45,82.1 222.45,82.12 222.45,84.48 222.55,84.58 223.86,84.58
+3.3V_RUN on IN2 (solid shape): 209.04,93.84 209.04,93.27 208.98,93.21 208.03,93.21 207.9,93.08 207.9,92.95 207.84,92.89 207.46,92.89 207.39,92.95 207.39,93.84 207.46,93.91 208.98,93.91
+3.3V_RUN on IN2 (solid shape): outline of 478 points within 217.24,128.83 264.23,156.9
+3.3V_RUN on IN3 (solid shape): 221.43,166.61 221.43,165.22 221.24,165.03 220.54,165.03 220.35,165.22 220.35,166.68 220.41,166.74 221.3,166.74
+3.3V_RUN on IN3 (solid shape): 233.25,169.73 233.25,166.38 232.82,165.94 232.18,165.94 231.69,166.43 231.69,169.74 232.02,170.07 232.91,170.07
+3.3V_RUN on IN3 (solid shape): 264.29,157.66 264.29,155.63 264.16,155.5 263.65,155.5 263.53,155.63 263.53,156.33 263.02,156.84 263.02,157.47 263.4,157.85 264.1,157.85
+3.3V_RUN on IN3 (solid shape): 281.88,164.71 281.88,163.25 281.75,163.12 280.61,163.12 279.97,163.76 278.77,163.76 278.39,164.14 278.39,164.65 278.58,164.84 281.75,164.84
+3.3V_RUN on IN3 (solid shape): outline of 158 points within 190.5,167 204.81,173.46
+3.3V_RUN on IN3 (solid shape): outline of 365 points within 146.37,119.54 164.15,128.48
+3.3V_RUN on IN4 (solid shape): outline of 83 points within 168.99,137.1 177.91,141.42
+3.3V_RUN on VCC: outline of 177 points within 1.02,18.47 223.71,206.68
+3.3V_RUN_CARD on TOP (solid shape): 207.02,32.14 207.02,31.33 208.07,30.28 208.07,27.92 207.89,27.74 206.33,27.74 206.12,27.94 206.12,29.57 204.99,30.7 204.99,32.01 205.25,32.27 206.9,32.27
+3.3V_RUN_CARD on TOP (solid shape): 187.9,24 187.9,21.64 187.74,21.48 187.74,20.45 187.37,20.08 187.37,19.19 187.08,18.9 187.08,18.72 186.87,18.51 186.06,18.51 185.93,18.64 185.93,19.93 186.33,20.34 186.33,21.31 186.78,21.76 187.02,21.76 187.28,22.03 187.28,22.23 187.62,22.57 187.62,23.17 187.68,23.22 187.68,23.99 187.75,24.06 187.84,24.06
+3.3V_RUN_CARD on IN3 (solid shape): 207.9,29.49 207.9,28.57 207.77,28.44 205.93,28.44 205.55,28.82 205.55,29.39 205.77,29.61 207.77,29.61
+3.3V_RUN_CARD on IN3 (solid shape): 189.42,20.06 189.42,19.39 189.1,19.07 187.24,19.07 186.98,18.82 186.98,18.62 186.88,18.52 185.77,18.52 185.6,18.69 185.6,19.87 185.91,20.18 189.3,20.18
+3.3V_RUN_DVDD on BOTTOM (solid shape): outline of 242 points within 264.99,155.28 268.54,159.63
+3.3V_RUN_EDP on TOP (solid shape): 205.98,152.87 205.98,152.4 206.12,152.26 206.12,151.54 205.91,151.33 204.47,151.33 204.31,151.49 204.31,152.82 204.46,152.97 205.88,152.97
+3.3V_RUN_EDP on TOP (solid shape): 198.45,169.35 198.5,169.34 198.55,169.35 198.95,169.35 199.03,169.26 199.03,168.77 198.94,168.68 198.45,168.68 197.83,168.06 197.23,168.06 196.83,167.66 193.77,167.66 193.15,167.04 192.6,167.04 192.58,167.06 192.58,168.52 192.93,168.88 196.99,168.88 197.45,169.35
+3.3V_RUN_EDP on IN2 (solid shape): 206.19,153.36 206.19,151.58 206.03,151.41 204.41,151.41 204.08,151.74 204.08,153.53 204.27,153.71 205.84,153.71
+3.3V_RUN_EDP on IN2 (solid shape): 198.73,168.6 198.73,167.56 198.43,167.26 197.05,167.26 196.99,167.2 195.28,167.2 194.77,167.7 194.77,168.85 194.94,169.02 198.32,169.02
+3.3V_RUN_FFS on TOP (solid shape): 91,54.09 91,53.34 89.98,52.32 88.65,52.32 88.48,52.49 88.48,54.13 88.64,54.28 90.81,54.28
+3.3V_RUN_FFS on IN3 (solid shape): 89.92,53.84 89.92,52.38 89.73,52.19 84.96,52.19 83.89,51.11 83.89,48 83.76,47.87 83.12,47.87 82.68,48.31 82.68,52.5 82.36,52.82 80.01,52.82 79.76,53.08 79.76,53.65 79.95,53.84 87.71,53.84 87.84,53.97 89.79,53.97
+3.3V_RUN_GFX on TOP (solid shape): 91.25,120.45 91.25,119.75 91.44,119.56 91.44,118.45 91.73,118.17 92.46,118.17 92.6,118.04 93.35,118.04 93.66,117.72 93.66,115.24 93.92,114.99 93.92,114.52 93.61,114.21 92.6,114.21 92.07,114.75 92.07,117.32 91.87,117.52 91.52,117.52 90.74,118.29 90.74,119.12 90.36,119.5 90.36,120.45 90.43,120.51 91.19,120.51
+3.3V_RUN_GFX on BOTTOM (solid shape): 56.97,131.75 57.01,131.74 57.02,131.7 57.02,130.04 56.93,129.94 56.3,129.94 55.95,130.29 54.93,130.29 54.42,130.8 54.42,130.99 54.67,131.24 54.93,131.24 54.99,131.19 55.63,131.19 56.2,131.75
+3.3V_RUN_HDD on TOP (solid shape): 81.18,48.18 81.18,45.4 80.68,44.89 79.32,44.89 79.23,44.98 79.23,45.79 79.53,46.08 79.53,46.58 78.98,46.58 78.98,46.75 79.53,46.75 79.53,47.8 79.95,48.22 79.95,48.22 81.13,48.22
+3.3V_RUN_HDD on BOTTOM (solid shape): 82.92,48.23 82.92,46.39 82.63,46.11 80.77,46.11 80.11,45.45 79.35,45.45 79.09,45.71 79.09,48.37 79.22,48.5 82.64,48.5
+3.3V_RUN_HDD_R on TOP (solid shape): 84.23,46.08 84.23,44.98 84.05,44.8 81.65,44.8 81.53,44.92 81.53,46.3 81.57,46.34 83.98,46.34
+3.3V_RUN_HDD_R on BOTTOM (solid shape): 84.19,46.01 84.19,45 84.05,44.86 80.48,44.86 80.41,44.92 80.41,45.56 80.63,45.77 82.75,45.77 83.17,46.19 84.01,46.19
+3.3V_RUN_TPM on TOP (solid shape): 209.77,118.71 210.25,118.71 210.32,118.65 210.32,117.71 210.05,117.44 210.05,115.77 210.05,115.76 210.05,115.42 209.94,115.32 208.63,115.32 208.44,115.5 208.44,118.54 208.62,118.71 209.59,118.71 209.59,119.25 209.77,119.25
+3.3V_RUN_TPM on IN4 (solid shape): outline of 314 points within 208.74,103.33 215.36,116.38
+3.3V_SPI on IN4 (solid shape): 226.9,127.57 226.9,120.31 226.56,119.97 225.91,119.97 225.6,120.28 225.6,121.79 224.81,122.58 224.81,126.86 224.86,126.95 224.96,126.95 225.43,127.01 225.42,127.48 225.4,127.55 225.43,127.62 225.52,127.72 226.76,127.72
+3.3V_SUS on TOP (solid shape): 225.99,74.2 225.99,71.81 225.93,71.74 225.21,71.74 224.91,72.05 223.63,72.05 223.49,72.19 223.49,73.57 224.37,74.45 225.74,74.45
+3.3V_SUS on TOP (solid shape): 48.58,98.8 48.58,97.78 48.39,97.59 47.06,97.59 46.92,97.45 46.9,97.45 46.9,97.44 46.8,97.34 46.8,96.89 46.42,96.51 46.42,94.16 46.36,94.1 45.15,94.1 45.09,94.16 45.09,97.02 45.47,97.4 46.04,97.4 46.29,97.65 46.29,98.48 46.8,98.99 48.39,98.99
+3.3V_SUS on IN2 (solid shape): 225.35,74.35 225.35,73.09 224.32,72.06 224.32,64.99 224.31,64.99 224.32,64.96 224.32,59.26 223.69,58.63 222.26,58.63 221.77,59.13 221.77,66.34 221.8,66.42 221.88,66.44 222.18,66.54 222.29,66.83 222.18,67.11 221.88,67.21 221.8,67.23 221.77,67.31 221.77,68.23 222.55,69.01 222.55,73.73 223.4,74.57 225.14,74.57
+3.3V_SUS on IN3 (solid shape): 47.86,96.47 47.86,94.84 47.76,94.74 45.34,94.74 45.22,94.85 45.22,96.42 45.44,96.63 47.7,96.63
+3.3V_SUS on IN3 (solid shape): 223.84,62.51 223.84,61.31 223.65,61.13 220.34,61.13 220.16,61.31 220.16,62.53 220.43,62.8 223.54,62.8
+3.3V_SUS on IN3 (solid shape): outline of 159 points within 163.01,51.34 175.59,54.37
+3.3V_TP on TOP (solid shape): 190.1,101.19 190.1,99.57 189.84,99.31 189.7,99.31 189.7,99.32 187.77,99.32 187.64,99.44 187.64,100.02 187.77,100.14 188.56,100.14 188.67,100.25 188.67,101.17 188.81,101.31 189.98,101.31
+3.3V_VCCPRTCSUS on IN1 (solid shape): outline of 457 points within 171.46,127.92 175.84,131.86
+3.3V_WLAN on TOP (solid shape): 214.41,143.29 214.41,142.4 214.16,142.15 211.35,142.15 211.21,142.3 211.21,143.49 211.25,143.53 214.16,143.53
+3.3V_WLAN on TOP (solid shape): 245.39,152.93 245.39,152.23 245.81,151.8 245.81,150.67 245.75,150.61 245.21,150.61 243.71,149.1 240.41,149.1 240.25,149.27 240.25,151.17 240.45,151.37 243.08,151.37 243.39,151.68 243.39,152.18 244.2,153 245.32,153
+3.3V_WLAN on BOTTOM (solid shape): 193.53,152.79 193.29,150.9 193.38,150.81 193.38,149.56 193.97,148.97 193.97,148.03 193.88,147.95 193.31,147.95 193.2,148.05 193.2,148.64 192.93,148.92 192.13,148.92 191.17,149.87 191.17,151.75 192.49,153.07 193.26,153.07
+3.3V_WLAN on BOTTOM (solid shape): 205.39,151.19 205.41,151.04 205.17,149.24 205.16,149.16 205.16,148.86 205.45,148.58 205.45,147.23 205.31,147.09 204.58,147.09 204.41,147.26 204.41,149.19 204.59,149.38 204.59,149.61 204.83,151.25 204.84,151.28 204.86,151.3 204.97,151.33 205.25,151.33
+3.3V_WLAN on BOTTOM (solid shape): 214.22,161.16 214.22,159.87 213.46,159.11 213.46,158.66 213.29,158.49 213.29,158.38 213.14,157.28 213.05,156.56 213.04,156.54 213.02,156.52 212.85,156.42 211.66,156.62 211.64,156.64 211.6,156.74 211.91,158.76 211.91,158.76 211.91,161.11 212.06,161.27 214.11,161.27
+3.3V_WLAN on IN2 (solid shape): outline of 1275 points within 204.32,142.51 241.5,161.02
+3.3V_WLAN on IN4 (solid shape): outline of 234 points within 191.61,147.43 205.42,151.14
+3V5V_PWR_SRC on TOP (solid shape): 208.56,40.75 208.56,38.52 208.45,38.41 206.25,38.41 206,38.66 206,38.92 205.74,39.17 204.22,39.17 203.58,38.53 203.58,37.14 203.52,37.07 203.01,37.07 202.95,37.14 202.95,40.06 203.77,40.88 208.42,40.88
+3V5V_PWR_SRC on TOP (solid shape): 205.81,51.62 205.81,50.92 206.06,50.66 206.06,48 205.93,47.87 196.92,47.87 196.53,48.25 196.53,50.66 196.79,50.92 199.59,50.92 199.86,50.65 200.73,50.65 200.99,50.92 204.34,50.92 204.54,51.11 204.54,51.55 204.73,51.74 205.68,51.74
+3V5V_PWR_SRC on BOTTOM (solid shape): 205.81,49.01 205.81,46.6 207.33,45.08 207.33,42.15 204.28,39.11 203.14,39.11 202.88,39.36 202.88,41.01 205.17,43.3 205.17,44.06 203.65,45.58 203.65,47.62 203.39,47.87 200.98,47.87 200.79,48.06 200.79,49.08 202.38,50.66 204.15,50.66
+3VALWP on TOP (solid shape): 216.71,51.37 216.71,51.01 216.71,51.01 216.71,50.91 217.21,50.91 217.21,51.43 217.51,51.43 217.51,50.91 218.01,50.91 218.01,51.43 218.4,51.43 218.95,50.88 221.04,50.88 221.05,50.88 221.05,51.43 221.5,51.43 221.5,50.89 221.5,50.89 222.22,50.89 222.25,50.92 222.25,51.43 222.7,51.43 222.7,50.92 222.72,50.89 223.48,50.89 223.71,50.66 223.71,40.25 222.44,38.98 220.35,38.98 219.71,38.34 219.71,35.23 219.52,35.04 214.57,35.04 214.06,35.55 214.06,41.58 214.57,42.09 214.57,43.35 217.74,43.35 217.74,40.2 218.07,39.87 220.21,39.87 220.66,40.32 220.66,43.22 220.08,43.81 218.2,43.81 217.74,43.35 214.57,43.35 214.57,46.47 216.09,48 216.09,51.22 216.31,51.44 216.64,51.44
+5V_ALW on TOP (solid shape): 6.85,182.62 6.85,181.46 6.66,181.27 3.95,181.27 3.79,181.44 3.79,182.06 4.41,182.68 6.79,182.68
+5V_ALW on TOP (solid shape): 229.38,109.3 229.38,108.18 227.79,106.59 227.01,106.59 226.83,106.76 226.83,107.53 227.93,108.63 227.93,109.31 228.09,109.46 229.21,109.46
+5V_ALW on TOP (solid shape): 177.29,41.46 177.29,39.11 177.13,38.95 175.73,38.95 175.45,39.22 175.45,41.59 175.53,41.67 177.08,41.67
+5V_ALW on TOP (solid shape): 272.92,184.14 272.92,183.7 273.37,183.25 273.58,183.25 273.71,183.12 273.71,182.38 273.05,181.73 271.91,181.73 271.65,181.98 271.65,184.14 271.85,184.33 272.73,184.33
+5V_ALW on TOP (solid shape): 281.61,168.74 281.61,168.13 281.3,167.82 278.3,167.82 278.02,167.54 278.02,166.91 277.94,166.83 277.32,166.83 277.17,166.98 277.17,168.52 277.63,168.98 281.36,168.98
+5V_ALW on TOP (solid shape): 174.06,41.58 174.06,40.3 173.91,40.15 173.91,39.19 173.76,39.04 173.06,39.04 173.04,39.05 172.69,39.39 172.69,40.53 173.14,40.98 173.14,41.53 173.28,41.67 173.97,41.67
+5V_ALW on TOP (solid shape): 283.19,192.9 283.19,191.46 282.89,191.16 282.89,190.36 283.1,190.16 283.63,190.16 283.71,190.08 283.71,188.2 283.48,187.98 282.23,187.98 281.99,188.22 281.99,191.47 282.08,191.56 282.08,192.86 282.27,193.06 283.03,193.06
+5V_ALW on TOP (solid shape): 230.59,70.66 230.59,69.56 229.64,68.61 229.64,67.34 229.29,66.99 228.11,66.99 227.98,67.13 227.98,67.69 227.98,67.7 227.98,68.16 229.91,70.08 229.91,70.37 229.34,70.94 227.3,70.94 227.24,71 227.24,71.13 227.28,71.17 230.08,71.17
+5V_ALW on TOP (solid shape): 283,181.27 283,180.53 282.84,180.38 281.42,180.38 281.19,180.15 281.19,179.11 281.03,178.95 279.45,178.95 279.34,179.06 279.34,180.25 279.48,180.39 280.13,180.39 280.23,180.5 280.23,180.9 280.48,181.16 281.23,181.16 281.51,181.43 282.83,181.43
+5V_ALW on TOP (solid shape): 222.38,62.98 222.38,55.02 222.19,54.83 218.71,54.83 218.57,54.98 218.57,55.55 219.08,55.55 219.08,56.26 218.57,56.26 218.57,56.75 219.08,56.75 219.08,57.46 218.57,57.46 218.57,60.82 219.08,60.82 219.08,61.53 218.57,61.53 218.57,62.02 219.08,62.02 219.08,62.73 218.57,62.73 218.57,63.24 218.57,63.24 218.57,63.4 218.79,63.62 221.74,63.62
+5V_ALW on TOP (solid shape): 257.75,153.6 257.75,152.75 257.7,152.69 257.22,152.69 257.19,152.72 257.16,152.79 257.16,153.03 256.68,153.03 256.63,152.98 256.54,152.91 256.48,152.82 255.98,152.33 255.53,152.33 255.4,152.45 255.4,152.71 255.71,153.02 255.72,153.02 255.86,153.1 255.94,153.24 255.94,153.25 256.03,153.34 256.03,154.36 256.1,154.42 256.92,154.42
+5V_ALW on BOTTOM (solid shape): 7.1,182.28 7.1,181.26 6.96,181.11 1.27,181.11 1.27,182.39 6.99,182.39
+5V_ALW on IN1 (solid shape): 230.7,108.99 230.7,108.1 230.5,107.9 228.55,107.9 228.3,108.15 228.3,108.95 228.5,109.14 230.54,109.14
+5V_ALW on IN1 (solid shape): 238.83,108.99 238.83,108.1 238.63,107.9 236.68,107.9 236.43,108.15 236.43,108.95 236.63,109.14 238.67,109.14
+5V_ALW on IN2 (solid shape): outline of 1851 points within 269.69,167.73 283.52,193.3
+5V_ALW on VCC: outline of 144 points within 1.02,1.02 289.37,196.9 ; 1 cut-out
+5V_ALW2 on TOP (solid shape): 202.69,38.6 202.69,38.09 202.57,37.96 202.54,37.94 200.86,37.94 200.81,37.98 200.81,38.16 200.93,38.28 201.04,38.28 201.42,38.66 202.63,38.66
+5V_HDD on TOP (solid shape): 80.73,40.71 80.73,40.3 80.77,40.26 81.25,40.26 81.29,40.23 81.29,40.05 81.26,40.02 80.75,40.02 80.74,40.01 80.74,39.47 80.75,39.46 81.27,39.46 81.29,39.44 81.29,39.23 81.28,39.22 80.77,39.22 80.74,39.2 80.74,38.12 78.96,36.34 78.96,35.35 79.16,35.15 79.16,34.48 79.04,34.36 77.76,34.36 77.56,34.57 77.56,37.35 78.74,38.53 78.74,40.65 78.87,40.77 80.67,40.77
+5V_HDD on BOTTOM (solid shape): 83.03,40.45 83.03,37.5 82.75,37.22 79.75,37.22 79.43,37.53 79.43,40.38 79.71,40.66 82.83,40.66
+5V_MOD on TOP (solid shape): outline of 97 points within 162.5,40.38 174.38,49.28
+5V_RUN on TOP (solid shape): 26.86,204.72 26.86,203.76 26.74,203.64 25.59,203.64 25.02,204.21 25.02,204.65 25.21,204.84 26.74,204.84
+5V_RUN on TOP (solid shape): 8.64,181.11 8.64,180.66 8.22,180.24 6.43,180.24 6.41,180.25 6.41,180.83 6.46,180.88 7.11,180.88 7.44,181.21 8.55,181.21
+5V_RUN on TOP (solid shape): 283.71,163.25 283.71,162.14 283.57,161.99 282.71,161.99 282.5,162.2 282.5,162.76 282.07,163.19 282.07,163.76 282.32,164.01 282.96,164.01
+5V_RUN on TOP (solid shape): 198.91,101.63 198.91,98.4 198.84,98.32 196.64,98.32 196.16,98.8 196.16,99.84 196.42,100.1 198.09,100.1 198.29,100.3 198.29,101.59 198.47,101.78 198.77,101.78
+5V_RUN on TOP (solid shape): 269.18,167.88 269.18,167 269.06,166.88 267.76,166.88 267.62,166.74 267.62,165.89 267.53,165.81 266.03,165.81 265.79,166.06 265.79,167.93 266.41,168.56 268.5,168.56
+5V_RUN on TOP (solid shape): 134.75,151.5 134.75,150.87 134.72,150.83 134.11,150.83 134.1,150.84 133.96,150.87 133.82,150.84 133.81,150.83 132.94,150.83 132.81,150.96 132.81,151.47 132.97,151.63 134.62,151.63
+5V_RUN on TOP (solid shape): 85.58,42.73 85.58,39.13 85.14,38.7 80.92,38.7 80.88,38.74 80.88,39.09 81.42,39.09 81.42,39.59 80.88,39.59 80.88,39.89 81.42,39.89 81.42,40.39 80.88,40.39 80.88,40.52 80.88,42.86 81.34,43.32 84.99,43.32
+5V_RUN on TOP (solid shape): 177.55,48.61 177.55,46.22 177.99,45.78 177.99,43.56 177.36,42.93 175.5,42.93 175.45,42.98 175.45,43.9 175.79,44.25 175.79,46.25 174.86,47.19 174.62,47.19 174.54,47.28 174.54,47.55 174.57,47.59 175.1,47.59 175.11,47.6 175.11,48.13 175.1,48.14 174.58,48.14 174.56,48.17 174.56,48.36 174.58,48.38 175.1,48.38 175.11,48.39 175.11,48.94 175.11,48.94 174.58,48.94 174.56,48.96 174.56,49.42 174.65,49.51 176.66,49.51
+5V_RUN on BOTTOM (solid shape): 147.52,159.3 147.52,157.44 147.33,157.25 146.49,157.25 146.28,157.45 146.28,159.32 146.43,159.46 147.36,159.46
+5V_RUN on BOTTOM (solid shape): 8.88,181.38 8.88,180.55 8.6,180.27 7.43,180.27 7.29,180.13 5.26,180.13 5.17,180.22 5.17,180.8 5.26,180.88 7.07,180.88 7.65,181.46 8.81,181.46
+5V_RUN on BOTTOM (solid shape): 195.81,145.99 195.81,144.53 195.81,144.53 195.81,144.39 195.6,144.19 193.8,144.19 193.62,144.01 191.64,144.01 191.51,144.15 191.51,145.27 191.71,145.47 192.91,145.47 193.68,146.24 195.56,146.24
+5V_RUN on BOTTOM (solid shape): 134.43,151.57 134.43,150.84 134.35,150.77 134.28,150.74 134.21,150.77 133.63,150.63 133.98,150.16 134.06,150.13 134.09,150.05 134.09,149.36 133.98,149.24 133.03,149.24 132.3,149.98 132.3,151.42 132.51,151.64 134.36,151.64
+5V_RUN on BOTTOM (solid shape): outline of 104 points within 38.74,88.67 48.64,96.95
+5V_RUN on IN1 (solid shape): 198.57,99.91 198.58,99.89 198.58,99.87 198.58,98.9 201.93,95.56 204.41,95.56 204.79,95.94 210.92,95.94 211.93,94.93 211.93,92.2 211.48,91.75 210.12,91.75 209.96,91.91 209.96,92.12 210.16,92.31 210.17,92.32 210.29,92.4 210.37,92.52 210.38,92.54 210.39,92.65 210.38,92.75 210.38,93.72 210.06,94.03 206.06,94.03 205.68,93.65 201.47,93.65 197.98,97.14 197.93,97.21 197.86,97.26 196.2,98.92 196.2,99.98 196.39,100.17 198.31,100.17
+5V_RUN on IN2 (solid shape): 85.34,44.15 85.34,41.77 85.01,41.44 82.57,41.44 81.96,42.05 81.96,44.2 82.26,44.49 84.99,44.49
+5V_RUN on IN2 (solid shape): 195.69,146.61 195.69,144.47 195.49,144.27 194.47,144.27 194.3,144.44 194.3,146.51 194.07,146.74 194.07,146.9 194.63,147.46 194.84,147.46
+5V_RUN on IN2 (solid shape): outline of 255 points within 165.66,157.67 177.38,159.74
+5V_RUN on IN2 (solid shape): outline of 280 points within 41.85,88.62 61.09,97.68
+5V_RUN on IN2 (solid shape): outline of 779 points within 25.97,120.32 48.01,152.2
+5V_RUN on IN3 (solid shape): 166.91,159.29 166.91,158.04 166.59,157.72 165.72,157.72 165.53,157.9 165.53,159.26 165.73,159.45 166.75,159.45
+5V_RUN on IN3 (solid shape): 147.49,159.35 147.49,158.31 147.76,158.04 147.76,157.56 147.33,157.13 147,157.13 146.24,157.88 146.24,159.34 146.34,159.44 147.4,159.44
+5V_RUN on IN3 (solid shape): 267.78,167.76 267.78,167.19 266.77,166.17 265.94,166.17 265.43,166.68 265.43,167.19 264.29,168.33 264.29,168.52 265.24,169.47 266.07,169.47
+5V_RUN on IN3 (solid shape): 28.73,152.32 28.73,150.45 27.56,149.28 26.54,149.28 26.16,149.66 26.16,150.1 26.74,150.68 26.74,152.38 26.99,152.63 28.42,152.63
+5V_RUN on IN3 (solid shape): 88.39,44.63 88.39,43.11 87.82,42.54 87.63,42.54 86.64,41.55 83.22,41.55 83.06,41.71 83.06,43.25 85.08,45.27 87.76,45.27
+5V_RUN on IN3 (solid shape): 196.41,145.21 196.41,142.72 195.97,142.28 194.69,142.28 194.34,142.63 194.34,145.54 194.66,145.86 195.75,145.86
+5V_RUN on IN3 (solid shape): 10.13,181.83 10.13,181.68 9.04,180.58 7.56,180.58 7.56,180.59 5.86,180.59 5.68,180.77 5.68,181.42 5.92,181.67 8.58,181.67 9.3,182.39 9.57,182.39
+5V_RUN on IN3 (solid shape): 26.86,204.59 26.86,203.89 26.52,203.55 26.5,203.54 26.29,203.44 26.19,203.22 26.16,203.19 25.15,203.19 24.89,203.44 24.89,204.08 25.59,204.78 26.67,204.78
+5V_RUN on IN3 (solid shape): outline of 102 points within 171.04,43.62 178.06,48.06
+5V_RUN on IN4 (solid shape): 196.25,145.62 196.25,145.31 196.92,144.65 196.92,141.02 197.74,140.2 197.74,136.39 197.17,135.82 195.14,135.82 194.12,136.83 194.12,138.7 195.54,138.7 195.54,138.65 195.55,138.59 195.57,138.54 195.59,138.5 195.62,138.45 195.66,138.41 195.7,138.38 195.74,138.35 195.79,138.33 195.85,138.32 195.9,138.32 195.95,138.32 196,138.33 196.05,138.35 196.1,138.38 196.14,138.41 196.18,138.45 196.21,138.5 196.23,138.54 196.25,138.59 196.25,138.65 196.25,138.7 196.25,138.75 196.23,138.8 196.21,138.85 196.18,138.9 196.14,138.94 196.1,138.97 196.05,139 196,139.02 195.95,139.03 195.9,139.03 195.85,139.03 195.79,139.02 195.74,139 195.7,138.97 195.66,138.94 195.62,138.9 195.59,138.85 195.57,138.8 195.55,138.75 195.54,138.7 194.12,138.7 194.12,145.91 194.25,146.04 195.84,146.04
+5V_RUN on IN4 (solid shape): 198.2,104.24 198.2,98.11 197.3,97.21 195.45,97.21 195.45,97.21 194.95,97.21 194.69,97.46 194.69,101.27 195.26,101.84 195.26,102.32 195.61,102.32 195.61,102.26 195.61,102.21 195.63,102.16 195.65,102.11 195.68,102.07 195.72,102.03 195.76,101.99 195.81,101.97 195.86,101.95 195.91,101.94 195.96,101.93 196.02,101.94 196.07,101.95 196.12,101.97 196.16,101.99 196.21,102.03 196.24,102.07 196.27,102.11 196.29,102.16 196.31,102.21 196.32,102.26 196.32,102.32 196.31,102.37 196.29,102.42 196.27,102.47 196.24,102.51 196.21,102.55 196.16,102.58 196.12,102.61 196.07,102.63 196.02,102.64 195.96,102.65 195.91,102.64 195.86,102.63 195.81,102.61 195.76,102.58 195.72,102.55 195.68,102.51 195.65,102.47 195.63,102.42 195.61,102.37 195.61,102.32 195.26,102.32 195.26,104.38 195.65,104.77 197.68,104.77
+5V_RUN on IN4 (solid shape): outline of 100 points within 175.71,44.29 179.01,52
+5V_RUN on IN4 (solid shape): outline of 106 points within 189.52,57.14 195.51,61.57
+5V_RUN on IN4 (solid shape): outline of 529 points within 193.68,68.2 199.07,84.19
+5V_TSP on BOTTOM (solid shape): 191.01,145.83 191.01,144.46 190.46,143.92 188.71,143.92 188.55,143.76 180.91,143.76 180.88,143.78 180.86,143.81 180.86,145.39 180.94,145.47 183.77,145.47 184.22,145.02 185.52,145.02 186.12,145.63 189.14,145.63 189.63,146.12 190.72,146.12
+5V_USB_CHG_PWR on TOP (solid shape): outline of 86 points within 280.81,195.82 287.59,208.08
+5V_USB_CHG_PWR on BOTTOM (solid shape): 284.01,207.43 284.01,204.16 283.94,204.08 280.99,204.08 280.84,204.23 280.84,207.71 281.17,208.04 283.4,208.04
+5V_USB_PWR2 on TOP (solid shape): 296.51,187.46 296.51,185.58 296.42,185.49 296.07,185.49 296.07,186.02 295.56,186.02 295.56,185.49 295.27,185.49 295.27,186.02 294.76,186.02 294.76,185.49 294.28,185.49 292.98,184.19 289.56,184.19 288.26,182.89 288.26,181.43 287.2,180.38 285.87,180.38 285.74,180.51 285.74,183.62 286.95,184.83 288.51,184.83 289.45,185.76 290.66,185.76 290.81,185.92 292.92,185.92 292.93,185.93 293.09,185.93 293.75,186.59 293.75,187.38 294.32,187.96 296.01,187.96
+5V_USB_PWR2 on BOTTOM (solid shape): 292.38,187.06 292.38,184.43 292.34,184.39 289.68,184.39 288.61,183.33 288.61,182.25 288.51,182.15 287.09,182.15 286.94,182.3 286.94,184.71 287.17,184.94 288.56,184.94 289.59,185.97 289.59,186.96 289.79,187.16 292.27,187.16
+5V_USB_PWR2 on IN1 (solid shape): 293.63,190.87 293.63,190.81 293.65,190.78 293.65,190.76 293.93,189.79 294.69,189.14 294.69,188.11 294.85,187.96 296.01,187.96 296.51,187.46 296.51,185.77 296.23,185.49 294.1,185.49 292.95,184.33 289.56,184.33 288.26,183.02 288.26,182.1 287.77,181.61 286.32,181.61 285.91,182.02 285.91,183.79 287.43,185.3 288.9,185.3 289.59,185.99 289.59,186.96 289.79,187.16 292.58,187.16 293.44,188.01 293.44,189.6 292.1,190.93 291.47,190.93 290.83,191.57 290.83,192.01 291.21,192.4 292.1,192.4
+5V_USB_PWR2 on IN2 (solid shape): 293.63,190.87 293.63,190.81 293.65,190.78 293.65,190.76 293.93,189.79 294.69,189.14 294.69,188.11 294.85,187.96 296.01,187.96 296.51,187.46 296.51,185.77 296.23,185.49 294.1,185.49 292.95,184.33 289.56,184.33 288.26,183.02 288.26,181.43 287.2,180.38 285.87,180.38 285.74,180.51 285.74,183.62 286.95,184.83 288.42,184.83 289.59,185.99 289.59,186.96 289.79,187.16 292.58,187.16 293.44,188.01 293.44,189.6 292.1,190.93 291.47,190.93 290.83,191.57 290.83,192.01 291.21,192.4 292.1,192.4
+5V_USB_PWR2 on IN3 (solid shape): 293.63,190.87 293.63,190.81 293.65,190.78 293.65,190.76 293.93,189.79 294.69,189.14 294.69,188.11 294.85,187.96 296.01,187.96 296.51,187.46 296.51,185.77 296.23,185.49 294.1,185.49 292.95,184.33 289.56,184.33 288.26,183.02 288.26,181.43 287.2,180.38 285.87,180.38 285.74,180.51 285.74,183.62 286.95,184.83 288.42,184.83 289.59,185.99 289.59,186.96 289.79,187.16 292.58,187.16 293.44,188.01 293.44,189.6 292.1,190.93 291.47,190.93 290.83,191.57 290.83,192.01 291.21,192.4 292.1,192.4
+5V_USB_PWR2 on IN4 (solid shape): 293.63,190.87 293.63,190.81 293.65,190.78 293.65,190.76 293.93,189.79 294.69,189.14 294.69,188.11 294.85,187.96 296.01,187.96 296.51,187.46 296.51,185.77 296.23,185.49 294.1,185.49 292.95,184.33 289.56,184.33 288.26,183.02 288.26,181.43 287.2,180.38 285.87,180.38 285.74,180.51 285.74,183.62 286.95,184.83 288.42,184.83 289.59,185.99 289.59,186.96 289.79,187.16 292.58,187.16 293.44,188.01 293.44,189.6 292.1,190.93 291.47,190.93 290.83,191.57 290.83,192.01 291.21,192.4 292.1,192.4
+5V_USB_PWR3 on TOP (solid shape): 295.14,185.36 295.69,185.36 295.69,185.89 295.94,185.89 295.94,185.36 296.47,185.36 296.55,185.28 296.55,184.62 293.61,181.67 293.61,179.87 293.73,179.75 293.73,172.79 292,171.06 289.56,171.06 287.97,169.48 285.7,169.48 284.68,168.45 284.66,168.45 284.66,168.43 284.15,167.93 282.82,167.93 281.88,168.87 281.88,170.93 282.02,171.07 282.41,171.07 282.49,171.15 282.79,171.15 282.87,171.07 283.33,171.07 283.41,171.15 287.89,171.15 288.3,171.57 289.78,171.57 289.78,171.56 290.12,171.53 290.44,171.66 290.45,171.67 290.55,171.67 290.87,171.98 290.87,173.26 291.33,173.73 292.18,173.73 292.88,174.43 292.88,175.99 293.11,176.21 293.11,180.17 292.69,180.59 292.69,181.68 293.3,182.29 293.3,183.99 294.33,185.03 294.33,185.26 294.44,185.36 294.89,185.36 294.89,185.89 295.14,185.89
+5V_USB_PWR3 on BOTTOM (solid shape): 295.19,183.84 295.19,183.26 293.61,181.68 293.61,179.87 293.74,179.75 293.74,172.76 292.79,171.81 291.21,171.81 290.87,172.15 290.87,173.27 291.33,173.73 292.16,173.73 292.61,174.17 292.61,181.58 293.32,182.3 293.32,183.71 293.66,184.05 294.98,184.05
+5V_USB_PWR3 on IN1 (solid shape): 296.08,185.23 296.08,184.14 293.61,181.68 293.61,179.87 293.74,179.75 293.74,172.76 292.05,171.07 289.57,171.07 287.99,169.48 285.74,169.48 284.2,167.95 282.82,167.95 282.21,168.56 282.21,170.71 282.63,171.14 287.9,171.14 288.32,171.56 289.8,171.56 289.81,171.56 290.02,171.53 290.23,171.56 290.24,171.56 290.49,171.56 290.84,171.91 290.84,173.23 291.34,173.73 292.17,173.73 292.61,174.17 292.61,181.62 293.29,182.3 293.29,183.98 294.66,185.35 295.96,185.35
+5V_USB_PWR3 on IN2 (solid shape): 296.08,185.23 296.08,184.14 293.61,181.68 293.61,179.87 293.74,179.75 293.74,172.76 292.05,171.07 289.57,171.07 287.99,169.48 285.74,169.48 284.2,167.95 282.82,167.95 282.21,168.56 282.21,170.71 282.63,171.14 287.9,171.14 288.28,171.52 290.34,171.52 290.84,172.02 290.84,173.23 291.34,173.73 292.17,173.73 292.61,174.17 292.61,181.62 293.29,182.3 293.29,183.98 294.66,185.35 295.96,185.35
+5V_USB_PWR3 on IN3 (solid shape): 296.08,185.23 296.08,184.14 293.61,181.68 293.61,179.87 293.74,179.75 293.74,172.76 292.05,171.07 289.57,171.07 287.99,169.48 285.74,169.48 284.2,167.95 282.82,167.95 282.21,168.56 282.21,170.71 282.63,171.14 287.9,171.14 288.32,171.56 289.8,171.56 289.81,171.56 290.02,171.53 290.23,171.56 290.24,171.56 290.49,171.56 290.84,171.91 290.84,173.23 291.34,173.73 292.17,173.73 292.61,174.17 292.61,181.62 293.29,182.3 293.29,183.98 293.97,184.66 293.97,184.66 294.65,185.35 295.96,185.35
+5V_USB_PWR3 on IN4 (solid shape): 296.08,185.23 296.08,184.14 293.61,181.68 293.61,179.87 293.74,179.75 293.74,172.76 292.05,171.07 289.57,171.07 287.99,169.48 285.74,169.48 284.2,167.95 282.82,167.95 282.21,168.56 282.21,170.71 282.63,171.14 287.9,171.14 288.32,171.56 289.8,171.56 289.81,171.56 290.02,171.53 290.23,171.56 290.24,171.56 290.49,171.56 290.84,171.91 290.84,173.23 291.34,173.73 292.17,173.73 292.61,174.17 292.61,181.62 293.29,182.3 293.29,183.98 293.97,184.66 293.97,184.66 294.65,185.35 295.96,185.35
+5VALWP on TOP (solid shape): 218.43,63.31 218.43,62.62 218.44,62.62 218.44,62.6 218.95,62.6 218.95,62.15 218.44,62.15 218.44,62.13 218.43,62.13 218.43,61.42 218.44,61.42 218.44,61.4 218.95,61.4 218.95,60.95 218.44,60.95 218.44,60.93 218.43,60.93 218.43,57.33 218.96,57.33 218.96,56.88 218.41,56.88 218.41,56.13 218.96,56.13 218.96,55.68 218.41,55.68 218.41,54.98 218.35,54.92 218.19,54.92 215.58,52.31 215.58,48.25 215.18,47.85 210.26,47.85 209.87,48.24 209.87,52.82 211.52,54.47 211.52,58.52 216.55,63.55 218.19,63.55
+AVCC33 on TOP (solid shape): 195.14,166.81 195.14,165.06 194.94,164.87 194.77,164.87 194.24,164.34 193.66,163.76 193.66,162.92 193.63,162.9 193.15,162.9 193.08,162.97 193.08,164.81 193.17,164.9 193.17,166.44 193.62,166.89 195.06,166.89
+AVCC33 on BOTTOM (solid shape): 198.01,164.99 198.01,163.74 197.76,163.49 196.7,163.49 195.9,164.3 193.93,164.3 193.74,164.5 193.74,165.31 193.82,165.39 197.61,165.39
+DVCC33 on TOP (solid shape): 201.33,160.62 201.33,159 201.4,158.94 201.45,158.87 201.52,158.81 201.89,158.45 202.63,158.45 203.2,157.88 203.2,157.2 203.36,157.04 203.5,157.04 204.85,155.69 204.85,155.02 205.02,154.86 206.11,154.86 206.25,155 206.25,155.56 206.63,155.94 207.05,155.94 207.35,155.64 207.35,154.03 207.08,153.76 204.27,153.76 203.84,154.2 203.84,155.5 203.2,156.14 202.76,156.14 202.25,156.65 202.25,157.5 201.74,158.01 201.74,158.14 201.12,158.76 201.12,160.63 201.16,160.68 201.28,160.68
+DVCC33 on IN3 (solid shape): outline of 212 points within 202.21,154.55 209.49,160.36
+VCC_CORE on TOP (solid shape): 125.56,94.62 125.56,91.44 125.44,91.31 123.75,91.31 123.59,91.48 123.59,94.56 123.77,94.75 125.43,94.75
+VCC_CORE on TOP (solid shape): outline of 2271 points within 114.17,96.47 138.26,124.13
+VCC_CORE on BOTTOM (solid shape): outline of 3186 points within 111.76,96.49 140.2,124.07
+VCC_CORE on IN1 (solid shape): outline of 4268 points within 112.85,93.91 140.23,115.88
+VCC_CORE on IN2 (solid shape): outline of 7418 points within 108.63,94.14 140.07,111.54
+VCC_CORE on IN3 (solid shape): outline of 12218 points within 112.84,90.02 140.07,125.4
+VCC_CORE on IN4 (solid shape): outline of 3305 points within 114.81,95.49 140.23,110.86
+VCC_CORE on VCC: 118.41,85.27 113.14,90.54 108.08,90.54 108.08,122.5 111.42,125.85 135.41,125.85 142.62,118.63 142.62,88.38 140.29,88.38 139.38,87.47 139.38,86.01 138.64,85.27
