# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D18: length 74.2
  IN1 w0.089: 112.06,74.98 112.06,75.33 112.31,75.57 112.78,75.57 113.06,75.86 113.06,78.4 113.47,78.81 v3(113.47,79.2)
  IN1 w0.102: 112.06,74.98 112.06,64.46 107.7,60.11 107.7,51.33 107.05,50.68 107.05,46.94 106.92,46.81 106.15,46.81 106.02,46.68 106.02,46.43 106.15,46.3 106.75,46.3 106.87,46.17 106.87,45.88 106.75,45.75 105.8,45.75 105.67,45.63 105.67,45.33 105.8,45.21 106.68,45.21 106.81,45.08 106.81,44.83 106.68,44.7 105.8,44.7 105.67,44.57 105.67,44.31 105.8,44.19 106.52,44.19 106.64,44.06 106.64,43.8 106.52,43.67 105.78,43.67 105.68,43.57 105.68,43.27 105.78,43.16 106.52,43.16 106.64,43.04 106.64,42.78 106.52,42.66 105.78,42.66 105.68,42.55 105.68,42.25 105.78,42.15 106.52,42.15 106.64,42.02 106.64,41.77 106.52,41.64 105.78,41.64 105.68,41.54 105.68,41.23 105.78,41.13 106.1,41.13 106.23,41 106.23,40.75 106.1,40.62 105.78,40.62 105.67,40.51 105.67,22.65 106.2,22.12 v3(106.2,20.75)
  BOTTOM w0.089: v3(113.47,79.2) 113.94,79.67 JCPU1.AM5
  BOTTOM w0.102: JDIMM2.51 106.44,20.99 v3(106.2,20.75)
DDR_B_D19: length 74.4
  IN1 w0.089: 111.66,73.63 111.66,74.59 111.86,74.79 111.86,75.4 112.23,75.76 112.7,75.76 112.87,75.94 112.87,79.16 113.47,79.76 v3(113.47,80.2)
  IN1 w0.102: v3(106.2,19.23) 105.92,19.23 105.79,19.36 105.79,22.1 105.37,22.53 105.37,22.85 105.26,22.95 104.93,22.95 104.8,23.08 104.8,23.34 104.93,23.46 105.26,23.46 105.37,23.56 105.37,24.34 105.26,24.44 104.9,24.44 104.8,24.54 104.8,24.84 104.9,24.95 105.26,24.95 105.37,25.05 105.37,26.08 105.26,26.18 104.9,26.18 104.8,26.29 104.8,26.59 104.9,26.69 105.26,26.69 105.37,26.79 105.37,27.1 105.26,27.2 104.9,27.2 104.8,27.3 104.8,27.61 104.9,27.71 105.26,27.71 105.37,27.81 105.37,28.11 105.26,28.22 104.9,28.22 104.8,28.32 104.8,28.62 104.9,28.72 105.26,28.72 105.37,28.83 105.37,32.1 105.26,32.2 104.9,32.2 104.8,32.3 104.8,32.61 104.9,32.71 105.26,32.71 105.37,32.81 105.37,46.2 105.72,46.55 105.72,47.71 106.75,48.74 106.75,50.81 107.4,51.46 107.4,60.23 111.66,64.49 111.66,73.63
  BOTTOM w0.089: JCPU1.AM6 113.94,80.67 v3(113.47,80.2)
  BOTTOM w0.102: JDIMM2.53 107.04,20.07 v3(106.2,19.23)
DDR_B_D20: length 70.9
  IN1 w0.102: v3(103.33,17.71) 102.56,17.71 102.1,18.16 102.1,21.69 101.81,21.98 101.81,36.92 101.33,37.4 101.33,40.02 101.84,40.53 101.84,45.39 102.88,46.44 102.88,48.55 104.29,49.96 104.29,51.82 104.95,52.48 104.95,61.25 109.07,65.37 109.07,78.81 v3(109.47,79.21)
  BOTTOM w0.089: JCPU1.AT5 109.94,79.68 v3(109.47,79.21)
  BOTTOM w0.102: JDIMM2.40 103.14,15.02 102.85,15.31 102.85,17.23 v3(103.33,17.71)
DDR_B_D21: length 71.6
  IN1 w0.102: v3(103.33,16.18) 101.77,17.74 101.77,21.56 101.51,21.82 101.51,36.79 101.02,37.27 101.02,40.19 101.53,40.69 101.53,45.51 102.58,46.56 102.58,48.68 103.99,50.09 103.99,51.95 104.64,52.6 104.64,61.38 108.77,65.5 108.77,79.06 109.47,79.76 v3(109.47,80.2)
  BOTTOM w0.089: v3(109.47,80.2) 109.94,80.67 JCPU1.AT6
  BOTTOM w0.102: v3(103.33,16.18) 103.74,15.77 JDIMM2.42
DDR_B_D22: length 73.2
  IN1 w0.089: 111.35,73.63 111.35,75.16 112.06,75.87 112.06,78.44 112.47,78.85 v3(112.47,79.2)
  IN1 w0.102: 111.35,73.63 111.35,64.62 107.09,60.36 107.09,51.59 106.44,50.93 106.44,48.86 105.41,47.84 105.41,46.67 105.06,46.32 105.06,40.57 104.5,40 104.5,36.92 104.6,36.82 104.93,36.82 105.03,36.72 105.03,36.42 104.93,36.31 104.6,36.31 104.5,36.21 104.5,35.91 104.6,35.81 104.93,35.81 105.03,35.7 105.03,35.4 104.93,35.3 104.6,35.3 104.5,35.2 104.5,34.89 104.6,34.79 104.93,34.79 105.03,34.69 105.03,34.38 104.93,34.28 104.6,34.28 104.5,34.18 104.5,22.59 105.44,21.65 105.44,17.87 105.6,17.71 v3(106.2,17.71)
  BOTTOM w0.089: JCPU1.AN5 112.94,79.67 v3(112.47,79.2)
  BOTTOM w0.102: v3(106.2,17.71) 105.76,17.26 105.76,15.29 106.14,14.9 JDIMM2.50
DDR_B_D23: length 74.4
  IN1 w0.089: 111.05,73.63 111.05,75.12 111.87,75.95 111.87,79.6 v3(112.47,80.2)
  IN1 w0.102: 111.05,73.63 111.05,64.74 106.79,60.49 106.79,51.71 106.14,51.06 106.14,48.99 105.11,47.96 105.11,46.8 104.76,46.45 104.76,40.69 104.19,40.13 104.19,22.47 105.11,21.55 105.11,17.3 105.24,17.18 105.67,17.18 105.79,17.05 105.79,16.8 105.67,16.67 104.71,16.67 104.59,16.54 104.59,16.12 104.71,15.99 106.07,15.99 106.2,16.12 v3(106.2,16.18)
  BOTTOM w0.089: JCPU1.AN6 112.94,80.67 v3(112.47,80.2)
  BOTTOM w0.102: v3(106.2,16.18) 106.74,15.64 JDIMM2.52
DDR_B_D24: length 72.5
  IN1 w0.089: v3(116.47,78.2) 116.09,78.2 115.63,77.73 115.48,77.73 114.87,77.13 114.87,77.07 114.6,76.8 114.54,76.8 114.07,76.33 114.07,74.22 113.94,74.09 113.61,74.09
  IN1 w0.102: 113.61,74.09 113.48,73.97 113.48,73.61 113.59,73.5 114.22,73.5 114.35,73.38 114.35,73.12 114.22,73 113.59,73 113.48,72.89 113.48,72.59 113.59,72.49 114.22,72.49 114.35,72.36 114.35,72.11 114.22,71.98 113.59,71.98 113.48,71.88 113.48,71.57 113.59,71.47 114.01,71.47 114.14,71.34 114.14,71.09 114.01,70.96 113.59,70.96 113.48,70.86 113.48,63.87 109.13,59.52 109.13,44.79 108.08,43.75 108.08,32.95 107.09,31.96 107.09,28.95 107.2,28.85 107.47,28.85 107.57,28.75 107.57,28.45 107.47,28.34 107.2,28.34 107.09,28.24 107.09,27.94 107.2,27.84 107.47,27.84 107.57,27.73 107.57,27.43 107.47,27.33 107.2,27.33 107.09,27.23 107.09,26.92 107.2,26.82 107.47,26.82 107.57,26.72 107.57,26.41 107.47,26.31 107.2,26.31 107.09,26.21 107.09,23.51 108.08,22.52 108.08,20.68 v3(108.74,20.02)
  BOTTOM w0.089: JCPU1.AJ4 116.94,78.67 v3(116.47,78.2)
  BOTTOM w0.102: JDIMM2.57 108.24,20.52 v3(108.74,20.02)
DDR_B_D25: length 71.8
  IN1 w0.089: 113.18,73.63 113.18,74.38 113.87,75.07 113.87,77.13 114.54,77.8 114.6,77.8 115,78.2 v3(115.47,78.2)
  IN1 w0.102: v3(108.74,18.5) 108.33,18.91 108.33,19.99 107.78,20.54 107.78,21 107.65,21.13 107.44,21.13 107.33,21.23 107.33,21.54 107.44,21.64 107.65,21.64 107.78,21.77 107.78,22.02 107.65,22.15 107.44,22.15 107.33,22.25 107.33,22.57 106.79,23.12 106.79,34.54 106.89,34.64 107.13,34.64 107.25,34.77 107.25,35.02 107.13,35.15 106.89,35.15 106.79,35.25 106.79,35.55 106.89,35.66 107.47,35.66 107.57,35.76 107.57,36.06 107.47,36.16 106.89,36.16 106.79,36.27 106.79,39.73 107.76,40.7 107.76,43.86 108.82,44.92 108.82,59.64 113.18,64 113.18,73.63
  BOTTOM w0.089: JCPU1.AK4 115.94,78.67 v3(115.47,78.2)
  BOTTOM w0.102: JDIMM2.59 108.84,21.32 109.16,21 109.16,18.92 v3(108.74,18.5)
DDR_B_D26: length 69.3
  IN1 w0.089: 116.88,73.63 116.88,74.79 v3(116.47,75.2)
  IN1 w0.102: v3(111.41,20.02) 111,20.43 111,22.66 110.23,23.43 110.23,40.26 110.33,40.36 110.64,40.36 110.75,40.46 110.75,40.77 110.64,40.87 110.33,40.87 110.23,40.97 110.23,41.28 110.33,41.38 110.63,41.38 110.75,41.51 110.75,43.38 111.27,43.9 111.27,58.63 115.63,62.98 115.63,63.69 115.76,63.81 116.46,63.81 116.59,63.94 116.59,64.24 116.46,64.37 115.76,64.37 115.64,64.5 115.64,64.75 115.76,64.88 116.75,64.88 116.88,65 116.88,65.26 116.75,65.39 115.76,65.39 115.64,65.51 115.64,65.77 115.76,65.89 116.75,65.89 116.88,66.02 116.88,66.27 116.75,66.4 115.76,66.4 115.64,66.53 115.64,66.78 115.76,66.91 116.75,66.91 116.88,67.04 116.88,73.63
  BOTTOM w0.089: v3(116.47,75.2) 116.94,75.67 JCPU1.AJ1
  BOTTOM w0.102: v3(111.41,20.02) 110.95,20.48 110.95,21.02 111.24,21.31 JDIMM2.67
DDR_B_D27: length 70.7
  IN1 w0.089: v3(116.47,76.2) 116.47,75.76 116.1,75.39 116.1,74.96 116.22,74.83 116.4,74.83 116.52,74.7 116.52,73.63
  IN1 w0.102: v3(111.41,18.5) 111.07,18.5 110.7,18.87 110.7,22.53 109.92,23.3 109.92,41.55 110.05,41.68 110.28,41.68 110.41,41.81 110.41,42.17 110.3,42.27 110.09,42.27 109.98,42.37 109.98,42.68 110.09,42.78 110.3,42.78 110.41,42.88 110.41,43.47 110.97,44.03 110.97,58.75 115.33,63.11 115.33,67.27 115.43,67.38 116.42,67.38 116.52,67.48 116.52,67.78 116.42,67.88 115.43,67.88 115.33,67.98 115.33,68.29 115.43,68.39 116.42,68.39 116.52,68.49 116.52,68.8 116.42,68.9 115.99,68.9 115.89,69 115.89,69.3 115.99,69.41 116.42,69.41 116.52,69.51 116.52,73.63
  BOTTOM w0.089: v3(116.47,76.2) 116.94,76.67 JCPU1.AJ2
  BOTTOM w0.102: v3(111.41,18.5) 111.84,18.93 JDIMM2.69
DDR_B_D28: length 67.2
  IN1 w0.089: v3(113.47,75.2) 112.87,74.6 112.87,73.63
  IN1 w0.102: 112.87,73.63 112.87,64.13 108.52,59.77 108.52,45.04 107.46,43.98 107.46,40.83 106.48,39.86 106.48,22.99 107.03,22.45 107.03,20.8 108.03,19.8 108.03,16.73 108.16,16.6 108.61,16.6 108.74,16.73 v3(108.74,16.98)
  BOTTOM w0.089: v3(113.47,75.2) 113.94,75.67 JCPU1.AM1
  BOTTOM w0.102: JDIMM2.56 107.94,16.18 v3(108.74,16.98)
DDR_B_D29: length 66.4
  IN1 w0.102: v3(108.74,15.45) 107.72,16.47 107.72,19.68 106.71,20.69 106.71,22.34 106.18,22.86 106.18,39.98 107.15,40.95 107.15,44.11 107.56,44.52 107.56,45.8 107.66,45.9 107.85,45.9 107.98,46.03 107.98,46.28 107.85,46.41 107.66,46.41 107.56,46.51 107.56,50.47 108.21,51.12 108.21,59.9 112.57,64.25 112.57,75.1 v3(112.47,75.2)
  BOTTOM w0.089: v3(112.47,75.2) 112.47,75.26 JCPU1.AN1
  BOTTOM w0.102: JDIMM2.58 108.54,15.25 v3(108.74,15.45)
DDR_B_D30: length 69.7
  IN1 w0.089: v3(115.47,76.2) 115.85,75.82 115.85,74.94 116.22,74.57 116.22,73.63
  IN1 w0.102: 116.22,73.63 116.22,70.05 116.09,69.92 115.15,69.92 115.02,69.8 115.02,69.54 115.15,69.41 115.47,69.41 115.57,69.31 115.57,69.01 115.47,68.91 115.15,68.91 115.02,68.78 115.02,63.24 110.66,58.88 110.66,44.15 109.62,43.11 109.62,22.64 110.39,21.87 110.39,18.74 110.82,18.31 110.82,16.73 110.95,16.6 111.28,16.6 111.41,16.73 v3(111.41,16.98)
  BOTTOM w0.089: v3(115.47,76.2) 115.94,76.67 JCPU1.AK2
  BOTTOM w0.102: v3(111.41,16.98) 110.89,16.46 110.89,15.39 111.28,15 111.44,15 111.54,14.91 JDIMM2.68
DDR_B_D31: length 68.7
  IN1 w0.089: v3(115.47,75.2) 115.47,74.98 115.91,74.54 115.91,73.63
  IN1 w0.102: 115.91,73.63 115.91,70.46 115.69,70.23 115.02,70.23 114.72,69.92 114.72,63.36 110.36,59 110.36,44.28 109.31,43.24 109.31,22.52 110.09,21.74 110.09,18.62 110.52,18.19 110.52,16.34 110.62,16.24 110.9,16.24 111,16.14 111,15.83 110.9,15.73 110.47,15.73 110.34,15.6 110.34,15.29 110.47,15.17 111.28,15.17 111.41,15.29 v3(111.41,15.45)
  BOTTOM w0.089: v3(115.47,75.2) 115.94,75.67 JCPU1.AK1
  BOTTOM w0.102: v3(111.41,15.45) 111.88,15.45 112.14,15.2 JDIMM2.70
DDR_B_D32: length 68.1
  IN1 w0.102: v3(133.48,19.1) 133.89,19.51 133.89,22.37 134.96,23.44 134.96,31.85 135.37,32.25 135.37,33.95 135.24,34.08 134.49,34.08 134.37,34.2 134.37,34.48 134.49,34.61 135.24,34.61 135.37,34.73 135.37,34.99 135.24,35.12 134.49,35.12 134.37,35.24 134.37,35.49 134.49,35.61 134.78,35.61 134.91,35.74 134.91,36.13 134.66,36.38 134.66,36.88 134.91,37.13 134.91,37.46 134.66,37.7 134.66,38.04 134.88,38.25 134.88,38.54 134.66,38.75 134.66,39.06 134.88,39.27 134.88,39.56 134.66,39.77 134.66,40.29 135.47,41.1 137.4,43.03 137.4,65.4 135.04,67.76 135.04,74.66 135.06,74.67 135.06,75.78 v3(135.47,76.2)
  BOTTOM w0.089: v3(135.47,76.2) JCPU1.L2
  BOTTOM w0.102: v3(133.48,19.1) 132.24,20.35 JDIMM2.129
DDR_B_D33: length 67.4
  IN1 w0.102: v3(133.48,20.63) 133.59,20.73 133.59,21.08 133.48,21.18 133.03,21.18 132.93,21.28 132.93,21.58 133.03,21.69 133.48,21.69 133.59,21.79 133.59,22.49 134.66,23.56 134.66,24.05 134.55,24.15 134.09,24.15 133.99,24.25 133.99,24.55 134.09,24.66 134.55,24.66 134.66,24.76 134.66,26.26 134.55,26.36 134.09,26.36 133.99,26.46 133.99,26.77 134.09,26.87 134.55,26.87 134.66,26.97 134.66,27.27 134.55,27.38 134.09,27.38 133.99,27.48 133.99,27.78 134.09,27.88 134.55,27.88 134.66,27.98 134.66,32.16 134.75,32.25 134.93,32.25 135.06,32.38 135.06,32.63 134.93,32.76 134.44,32.76 134.31,32.88 134.31,33.14 134.44,33.26 134.81,33.26 134.94,33.39 134.94,33.65 134.81,33.77 134.37,33.77 134.06,34.08 134.06,36.2 134.36,36.5 134.36,40.41 135.35,41.4 137.1,43.15 137.1,65.27 134.74,67.64 134.74,74.62 134.85,74.73 134.85,75.82 v3(134.47,76.2)
  BOTTOM w0.089: v3(134.47,76.2) JCPU1.M2
  BOTTOM w0.102: JDIMM2.131 132.84,21.27 v3(133.48,20.63)
DDR_B_D34: length 70.1
  IN1 w0.089: v3(135.47,78.2) 135.47,78 136.08,77.39 136.08,77 136.32,76.76 136.71,76.76 137.06,76.41 137.06,74.44 137.18,74.33 137.18,73.68 137.13,73.63
  IN1 w0.102: 137.13,73.63 136.9,73.4 136.9,68.51 139.26,66.15 139.26,42.28 137.21,40.23 137.21,37.26 137.91,36.57 137.91,35.05 137.78,34.92 137.33,34.92 137.21,34.8 137.21,33.48 137.33,33.35 137.78,33.35 137.91,33.22 137.91,32.36 137.78,32.23 137.33,32.23 137.21,32.11 137.21,28.33 137.33,28.21 137.73,28.21 137.86,28.08 137.86,25.99 137.73,25.86 137.33,25.86 137.21,25.73 137.21,22.28 136.83,21.9 136.83,18.85 136.7,18.72 136.53,18.72 136.3,18.95 v3(136.3,19.1)
  BOTTOM w0.089: v3(135.47,78.2) JCPU1.L4
  BOTTOM w0.102: v3(136.3,19.1) 135.84,19.56 JDIMM2.141
DDR_B_D35: length 70.7
  IN1 w0.089: 136.59,73.63 136.59,75.53 136.87,75.81 136.87,76.33 136.63,76.57 136.24,76.57 135.89,76.92 135.89,77.31 135.6,77.6 134.37,77.6 134.24,77.73 134.24,78.07 134.37,78.2 v3(134.47,78.2)
  IN1 w0.102: 136.59,73.63 136.59,68.39 138.94,66.04 138.94,42.39 136.9,40.35 136.9,36.85 137,36.75 137.29,36.75 137.42,36.62 137.42,36.37 137.29,36.24 136.86,36.24 136.73,36.12 136.73,35.86 136.86,35.74 137.47,35.74 137.6,35.61 137.6,35.35 137.47,35.23 137,35.23 136.9,35.13 136.9,33.15 137,33.05 137.31,33.05 137.42,32.95 137.42,32.64 137.31,32.54 137,32.54 136.9,32.44 136.9,28.9 136.5,28.49 136.5,28 136.61,27.88 137.44,27.88 137.54,27.78 137.54,27.48 137.44,27.38 136.62,27.38 136.5,27.25 136.5,27 136.62,26.87 137.44,26.87 137.54,26.77 137.54,26.46 137.44,26.36 137,26.36 136.9,26.26 136.9,22.89 136.3,22.29 v3(136.3,20.63)
  BOTTOM w0.089: v3(134.47,78.2) JCPU1.M4
  BOTTOM w0.102: JDIMM2.143 136.44,20.77 v3(136.3,20.63)
DDR_B_D36: length 67
  IN1 w0.102: v3(135.47,75.2) 135.35,75.07 135.35,67.89 137.71,65.53 137.71,42.9 135.45,40.64 135.21,40.4 135.21,35.57 135.67,35.11 135.67,32.13 135.26,31.72 135.26,23.31 134.2,22.24 134.2,18.7 134.09,18.59 134.02,18.59 133.89,18.47 133.89,18.21 134.02,18.09 134.47,18.09 134.6,17.96 134.6,17.71 134.47,17.58 v3(133.48,17.58)
  BOTTOM w0.089: v3(135.47,75.2) JCPU1.L1
  BOTTOM w0.102: v3(133.48,17.58) 132.54,16.63 JDIMM2.130
DDR_B_D37: length 66.5
  IN1 w0.102: v3(134.47,75.2) 134.43,75.16 134.43,67.51 136.8,65.15 136.8,43.28 134.05,40.54 134.05,36.63 133.67,36.25 133.67,23.01 132.19,21.53 132.19,20.98 133.08,20.09 133.08,16.69 132.95,16.56 132.77,16.56 132.65,16.44 132.65,16.18 132.77,16.06 133.48,16.06 v3(133.48,16.05)
  BOTTOM w0.089: v3(134.47,75.2) JCPU1.M1
  BOTTOM w0.102: v3(133.48,16.05) 133.05,15.62 133.05,15.16 133.14,15.08 JDIMM2.132
DDR_B_D38: length 71.5
  IN1 w0.089: v3(135.47,79.2) 135.85,78.82 135.85,77.89 136.17,77.57 136.63,77.57 136.87,77.33 136.87,76.87 137.17,76.57 137.63,76.57 137.87,76.33 137.87,74.8 137.66,74.59 137.66,73.73 137.57,73.63
  IN1 w0.102: v3(136.3,17.58) 136.3,17.33 136.43,17.2 137.01,17.2 137.13,17.33 137.13,21.77 137.7,22.34 137.7,24.58 138.21,25.09 138.21,40.8 139.56,42.15 139.56,66.28 137.2,68.64 137.2,73.27 137.57,73.63
  BOTTOM w0.089: v3(135.47,79.2) JCPU1.L5
  BOTTOM w0.102: v3(136.3,17.58) 135.54,16.82 JDIMM2.140
DDR_B_D39: length 71.8
  IN1 w0.089: 138.06,73.63 138.06,76.41 137.71,76.76 137.38,76.76 137.06,77.08 137.06,78.14 135.63,79.57 134.85,79.57 v3(134.47,79.2)
  IN1 w0.102: 138.06,73.63 137.54,73.11 137.54,68.73 139.87,66.41 139.87,42.02 138.52,40.67 138.52,24.96 138.03,24.48 138.03,22.24 137.44,21.65 137.44,17.19 v3(136.3,16.05)
  BOTTOM w0.089: v3(134.47,79.2) JCPU1.M5
  BOTTOM w0.102: v3(136.3,16.05) 135.87,15.62 135.87,15.13 136.14,14.86 JDIMM2.142
DDR_B_D40: length 75.9
  IN1 w0.089: 139.6,73.63 139.6,74.02 140.06,74.48 140.06,75.41 139.57,75.9 139.57,76.43 139.04,76.97 139.04,80.43 138.47,81 v3(138.47,81.2)
  IN1 w0.102: 139.6,73.63 139.6,72.75 139.5,72.65 139.09,72.65 138.96,72.52 138.96,72.27 139.09,72.14 139.62,72.14 139.75,72.01 139.75,71.76 139.62,71.63 139.09,71.63 138.96,71.51 138.96,71.25 139.09,71.13 139.62,71.13 139.75,71 139.75,70.74 139.62,70.62 139.09,70.62 138.96,70.49 138.96,70.24 139.09,70.11 139.62,70.11 139.75,69.98 139.75,69.73 139.62,69.6 139.19,69.6 139.06,69.47 139.06,69.22 139.19,69.09 139.5,69.09 139.6,68.99 139.6,68.69 141.29,67 141.29,41.43 140.66,40.8 140.66,28.46 140.96,28.15 140.96,23.32 140.74,23.1 139.7,23.1 139.55,22.95 139.55,19.1 138.84,18.39 v3(138.84,18.38)
  BOTTOM w0.089: v3(138.47,81.2) 138.94,81.67 JCPU1.G7
  BOTTOM w0.102: JDIMM2.147 137.64,19.58 v3(138.84,18.38)
DDR_B_D41: length 76.6
  IN1 w0.089: 139.26,73.63 139.26,74.09 139.87,74.7 139.87,75.33 139.38,75.82 139.38,76.35 138.85,76.89 138.85,80.35 138.63,80.57 138.25,80.57 138.04,80.79 138.04,82.63 v3(137.47,83.2)
  IN1 w0.102: v3(138.84,19.91) 139.25,20.31 139.25,23.54 139.63,23.93 139.63,24.32 139.74,24.43 140.53,24.43 140.65,24.55 140.65,24.81 140.53,24.93 139.74,24.93 139.63,25.03 139.63,25.85 139.74,25.96 140.53,25.96 140.65,26.08 140.65,26.34 140.53,26.46 139.74,26.46 139.63,26.57 139.63,26.87 139.74,26.97 140.4,26.97 140.53,27.1 140.53,27.35 140.4,27.48 139.74,27.48 139.63,27.58 139.63,27.89 139.74,27.99 140.23,27.99 140.34,28.09 140.34,28.39 140.23,28.5 139.74,28.5 139.63,28.6 139.63,28.91 139.76,29.04 140.22,29.04 140.35,29.17 140.35,40.93 140.98,41.56 140.98,66.87 138.66,69.19 138.66,72.65 139.26,73.25 139.26,73.63
  BOTTOM w0.089: JCPU1.J8 137,82.73 v3(137.47,83.2)
  BOTTOM w0.102: JDIMM2.149 138.24,20.51 v3(138.84,19.91)
DDR_B_D42: length 76.2
  IN1 w0.089: v3(139.47,83.2) 139.72,83.2 139.85,83.07 139.85,80.98 140.25,80.57 140.63,80.57 140.85,80.35 140.85,75.81 141.19,75.46 141.19,74.5 140.98,74.29 140.98,73.63
  IN1 w0.102: v3(141.38,18.38) 141.38,18.24 140.97,17.83 140.79,17.83 140.5,18.13 140.5,18.3 140.78,18.59 140.97,18.78 140.97,19.23 140.78,19.42 140.78,21.01 140.91,21.14 141.41,21.14 141.54,21.26 141.54,22.16 142.19,22.81 142.19,28.06 142.32,28.18 142.38,28.18 142.51,28.31 142.51,31.93 142.38,32.06 142.01,32.06 141.89,32.19 141.89,32.44 142.01,32.57 142.38,32.57 142.51,32.7 142.51,32.97 142.38,33.1 142.01,33.1 141.89,33.22 141.89,33.45 142.01,33.58 142.39,33.58 142.51,33.7 142.51,40.59 142.52,40.6 142.52,67.51 140.98,69.05 140.98,73.63
  BOTTOM w0.089: JCPU1.G8 139,82.73 v3(139.47,83.2)
  BOTTOM w0.102: v3(141.38,18.38) 140.64,19.12 JDIMM2.157
DDR_B_D43: length 76.8
  IN1 w0.089: 141.38,73.63 141.38,75.65 141.04,76 141.04,80.43 140.71,80.76 140.33,80.76 140.04,81.06 140.04,83.56 139.9,83.7 139.26,83.7 139.13,83.82 139.13,84.07 139.26,84.2 v3(139.47,84.2)
  IN1 w0.102: 141.38,73.63 141.38,73.52 141.29,73.43 141.29,70.38 141.61,70.06 141.61,69.84 141.29,69.52 141.29,69.34 141.49,69.14 141.67,69.14 142.01,69.48 142.18,69.48 142.36,69.3 142.36,69.12 141.92,68.68 141.92,68.54 142.14,68.32 142.28,68.32 142.47,68.5 142.65,68.5 142.83,68.32 142.83,68.14 142.64,67.96 142.64,67.82 142.83,67.63 142.83,40.47 142.81,40.46 142.81,27.8 142.71,27.7 142.6,27.7 142.5,27.6 142.5,27.29 142.6,27.19 142.71,27.19 142.81,27.09 142.81,26.78 142.71,26.68 142.6,26.68 142.5,26.58 142.5,26.27 142.6,26.17 142.71,26.17 142.81,26.07 142.81,25.77 142.71,25.66 142.6,25.66 142.5,25.56 142.5,25.26 142.6,25.16 142.71,25.16 142.81,25.06 142.81,24.75 142.71,24.65 142.6,24.65 142.5,24.55 142.5,24.24 142.6,24.14 142.71,24.14 142.81,24.04 142.81,23.73 142.71,23.63 142.6,23.63 142.5,23.53 142.5,23.23 142.6,23.12 142.71,23.12 142.81,23.02 142.81,22.23 142.62,22.04 142.47,22.04 142.23,22.28 142.09,22.28 141.87,22.06 141.87,21.92 142.12,21.68 142.12,21.53 141.94,21.36 141.94,21.13 142.09,20.98 142.09,19.72 141.91,19.53 141.51,19.53 141.38,19.66 v3(141.38,19.91)
  BOTTOM w0.089: JCPU1.G9 139,83.73 v3(139.47,84.2)
  BOTTOM w0.102: v3(141.38,19.91) 140.96,20.32 140.96,20.83 141.24,21.1 JDIMM2.159
DDR_B_D44: length 76.6
  IN1 w0.089: v3(137.47,82.2) 137.47,81.73 137.85,81.35 137.85,80.62 138.04,80.43 138.04,76.97 138.24,76.76 138.71,76.76 139.07,76.4 139.07,74.59 138.95,74.48 138.95,73.63
  IN1 w0.102: v3(138.84,16.86) 138.43,17.27 138.43,21.49 138.85,21.9 138.85,24.09 139.33,24.57 139.33,29.22 139.46,29.34 139.92,29.34 140.05,29.47 140.05,32.48 139.94,32.59 139.46,32.59 139.33,32.71 139.33,32.97 139.46,33.09 139.92,33.09 140.05,33.22 140.05,33.47 139.92,33.6 139.46,33.6 139.33,33.73 139.33,33.98 139.46,34.11 139.92,34.11 140.05,34.24 140.05,34.49 139.92,34.62 139.46,34.62 139.33,34.74 139.33,35 139.46,35.13 139.94,35.13 140.05,35.23 140.05,41.05 140.68,41.68 140.68,66.74 138.36,69.07 138.36,72.78 138.95,73.38 138.95,73.63
  BOTTOM w0.089: JCPU1.J7 137,81.73 v3(137.47,82.2)
  BOTTOM w0.102: JDIMM2.146 137.34,15.36 v3(138.84,16.86)
DDR_B_D45: length 76.6
  IN1 w0.089: 138.65,73.63 138.65,74.56 138.88,74.79 138.88,76.32 138.63,76.57 138.17,76.57 137.85,76.89 137.85,80.35 137.45,80.75 137.39,80.75 137.1,81.04 137.1,83.82 v3(137.47,84.2)
  IN1 w0.102: 138.65,73.63 138.65,73.5 138.05,72.9 138.05,68.94 140.37,66.62 140.37,41.81 139.02,40.46 139.02,36.24 139.13,36.14 139.61,36.14 139.74,36.01 139.74,35.76 139.61,35.63 139.13,35.63 139.02,35.53 139.02,24.75 138.54,24.27 138.54,22.03 138.13,21.62 138.13,16.05 v3(138.84,15.34)
  BOTTOM w0.089: v3(137.47,84.2) 137,83.73 JCPU1.J9
  BOTTOM w0.102: JDIMM2.148 137.94,15.08 138.19,15.34 v3(138.84,15.34)
DDR_B_D46: length 76.6
  IN1 w0.089: 142.04,73.63 142.04,80.5 141.77,80.76 141.3,80.76 141.06,81.01 141.06,83.41 140.68,83.79 140.35,83.79 140.07,84.07 140.07,84.6 v3(139.47,85.2)
  IN1 w0.102: v3(141.38,15.34) 142.31,15.34 142.43,15.46 142.43,15.87 142.33,15.97 141.96,15.97 141.86,16.07 141.86,16.38 141.96,16.48 142.33,16.48 142.43,16.58 142.43,17.26 142.7,17.53 142.7,21.26 143.42,21.98 143.42,40.21 143.44,40.22 143.44,69.09 142.04,70.49 142.04,73.63
  BOTTOM w0.089: JCPU1.G10 139,84.73 v3(139.47,85.2)
  BOTTOM w0.102: JDIMM2.158 140.94,14.89 v3(141.38,15.34)
DDR_B_D47: length 76.9
  IN1 w0.089: 141.69,73.63 141.69,75.01 141.85,75.17 141.85,80.42 141.69,80.57 141.23,80.57 140.87,80.93 140.87,83.33 140.6,83.6 140.27,83.6 139.88,83.99 139.88,84.32 139.51,84.69 137.98,84.69 v3(137.47,85.2)
  IN1 w0.102: 141.69,73.63 141.69,70.41 143.13,68.97 143.13,40.35 143.12,40.33 143.12,22.11 142.4,21.39 142.4,17.88 v3(141.38,16.86)
  BOTTOM w0.089: v3(137.47,85.2) 137,84.73 JCPU1.J10
  BOTTOM w0.102: JDIMM2.160 141.54,14.92 141.84,15.22 141.84,16.4 v3(141.38,16.86)
DDR_B_D48: length 76.8
  IN1 w0.089: 143.46,73.63 143.46,75.39 144.06,75.99 144.06,81.79 v3(144.47,82.2)
  IN1 w0.102: 143.46,73.63 143.46,71.08 144.97,69.57 144.97,52.29 145.07,52.19 146,52.19 146.11,52.08 146.11,51.78 146,51.68 145.07,51.68 144.97,51.58 144.97,51.27 145.07,51.17 146,51.17 146.11,51.07 146.11,50.76 146,50.66 145.07,50.66 144.97,50.56 144.97,50.26 145.07,50.15 146,50.15 146.11,50.05 146.11,49.75 146,49.65 145.07,49.65 144.97,49.54 144.97,49.24 145.07,49.14 146,49.14 146.11,49.04 146.11,40.88 145.51,40.28 145.51,22.98 145.45,22.91 144.97,22.91 144.85,22.79 144.85,21.25 144.34,20.74 144.34,19.29 144.27,19.23 v3(143.92,19.23)
  BOTTOM w0.089: JCPU1.A8 144.94,82.67 v3(144.47,82.2)
  BOTTOM w0.102: v3(143.92,19.23) 142.44,20.71 JDIMM2.163
DDR_B_D49: length 77.7
  IN1 w0.089: v3(144.47,83.2) 143.87,82.6 143.87,76.07 143.15,75.35 143.15,73.63
  IN1 w0.102: v3(143.92,20.75) 144.54,21.37 144.54,23.27 144.67,23.4 145.08,23.4 145.21,23.52 145.21,24.18 145.1,24.28 144.69,24.28 144.59,24.38 144.59,24.68 144.69,24.79 145.1,24.79 145.21,24.89 145.21,25.83 145.1,25.94 144.69,25.94 144.59,26.04 144.59,26.34 144.69,26.44 145.1,26.44 145.21,26.55 145.21,26.85 145.1,26.95 144.69,26.95 144.59,27.05 144.59,27.36 144.69,27.46 145.1,27.46 145.21,27.56 145.21,32.02 145.1,32.12 144.69,32.12 144.59,32.22 144.59,32.53 144.69,32.63 145.1,32.63 145.21,32.73 145.21,34.29 145.1,34.39 144.69,34.39 144.59,34.49 144.59,34.8 144.69,34.9 145.1,34.9 145.21,35 145.21,35.31 145.1,35.41 144.69,35.41 144.59,35.51 144.59,35.81 144.69,35.92 145.1,35.92 145.21,36.02 145.21,36.32 145.1,36.42 144.69,36.42 144.59,36.52 144.59,36.83 144.69,36.93 145.1,36.93 145.21,37.03 145.21,40.41 145.8,41 145.8,47.49 145.67,47.62 144.71,47.62 144.58,47.75 144.58,48 144.71,48.13 145.68,48.13 145.8,48.25 145.8,48.51 145.67,48.64 144.71,48.64 144.58,48.76 144.58,69.53 143.15,70.96 143.15,73.63
  BOTTOM w0.089: JCPU1.B8 144,82.73 v3(144.47,83.2)
  BOTTOM w0.102: v3(143.92,20.75) 143.13,20.75 143.04,20.84 JDIMM2.165
DDR_B_D50: length 77.2
  IN1 w0.089: v3(145.47,84.2) 145.74,84.2 145.87,84.06 145.87,80.07 145.37,79.57 145.37,76.11 144.75,75.49 144.75,73.63
  IN1 w0.102: 144.75,73.63 144.75,71.53 146.2,70.08 146.2,55.29 146.33,55.17 147.24,55.17 147.34,55.07 147.34,54.76 147.24,54.66 146.33,54.66 146.2,54.53 146.2,54.28 146.33,54.15 147.24,54.15 147.34,54.05 147.34,53.75 147.24,53.64 146.8,53.64 146.67,53.52 146.67,53.26 146.8,53.14 147.24,53.14 147.34,53.03 147.34,40.88 147.77,40.45 147.77,36.82 147.41,36.46 147.41,22.52 146.44,21.54 146.44,21 146.33,20.9 146.17,20.9 146.05,20.77 146.05,20.52 146.17,20.39 146.33,20.39 146.44,20.29 146.44,19.99 146.31,19.87 146.21,19.87 146.08,19.74 146.08,18.98 146.21,18.85 146.71,18.85 146.84,18.98 v3(146.84,19.23)
  BOTTOM w0.089: v3(145.47,84.2) 145,83.73 JCPU1.A9
  BOTTOM w0.102: JDIMM2.175 146.04,20.03 v3(146.84,19.23)
DDR_B_D51: length 78.5
  IN1 w0.089: 146.18,84.03 145.63,84.57 144.85,84.57 v3(144.47,84.2)
  IN1 w0.102: v3(146.84,20.75) 146.84,21.52 147.74,22.42 147.74,36.36 148.1,36.72 148.1,40.56 147.64,41.01 147.64,55.46 147.54,55.56 146.66,55.56 146.56,55.66 146.56,55.96 146.66,56.07 147.54,56.07 147.64,56.17 147.64,56.47 147.54,56.57 146.66,56.57 146.56,56.68 146.56,56.98 146.66,57.08 147.54,57.08 147.64,57.18 147.64,57.49 147.54,57.59 146.66,57.59 146.56,57.69 146.56,58 146.66,58.1 147.54,58.1 147.64,58.2 147.64,58.5 147.54,58.61 146.66,58.61 146.56,58.71 146.56,59.01 146.66,59.11 147.54,59.11 147.64,59.22 147.64,59.52 147.54,59.62 146.66,59.62 146.56,59.72 146.56,70.16 145.06,71.66 145.06,72.06 145.16,72.16 145.29,72.16 145.39,72.27 145.39,72.57 145.29,72.67 145.16,72.67 145.06,72.77 145.06,75.45 145.61,76 145.61,79.53 146.18,80.09 146.18,84.03
  BOTTOM w0.089: JCPU1.B9 144,83.73 v3(144.47,84.2)
  BOTTOM w0.102: v3(146.84,20.75) 146.64,20.96 JDIMM2.177
DDR_B_D52: length 79.7
  IN1 w0.089: v3(142.47,83.2) 142.47,83 143.06,82.41 143.06,75.99 142.85,75.78 142.85,73.63
  IN1 w0.102: v3(143.92,17.71) 143.51,18.11 143.51,20.92 144.24,21.64 144.24,39.87 145.5,41.13 145.5,44.17 145.4,44.27 144.38,44.27 144.27,44.37 144.27,44.68 144.38,44.78 145.4,44.78 145.5,44.88 145.5,45.18 145.4,45.29 144.38,45.29 144.27,45.39 144.27,45.69 144.38,45.79 145.4,45.79 145.5,45.89 145.5,46.2 145.4,46.3 144.38,46.3 144.27,46.4 144.27,46.71 144.38,46.81 145.16,46.81 145.29,46.94 145.29,47.19 145.16,47.32 144.38,47.32 144.27,47.42 144.27,69.4 142.85,70.83 142.85,73.63
  BOTTOM w0.089: v3(142.47,83.2) 142,82.73 JCPU1.D8
  BOTTOM w0.102: JDIMM2.164 142.74,16.52 v3(143.92,17.71)
DDR_B_D53: length 80
  IN1 w0.089: v3(141.47,83.2) 141.85,82.82 142.38,82.82 142.87,82.33 142.87,76.07 142.54,75.74 142.54,73.63
  IN1 w0.102: v3(143.92,16.18) 143.92,15.99 143.79,15.87 143.07,15.87 142.94,15.99 142.94,16.45 143.07,16.58 143.41,16.58 143.51,16.68 143.51,16.98 143.41,17.08 143.31,17.08 143.21,17.18 143.21,21.05 143.93,21.77 143.93,40 144.02,40.08 144.02,40.97 144.15,41.09 144.93,41.09 145.04,41.2 145.04,41.5 144.93,41.6 144.04,41.6 143.94,41.7 143.94,42.01 144.04,42.11 144.93,42.11 145.04,42.21 145.04,42.52 144.93,42.62 144.04,42.62 143.94,42.72 143.94,43.02 144.04,43.13 144.93,43.13 145.04,43.23 145.04,43.53 144.93,43.63 144.04,43.63 143.94,43.74 143.94,69.3 142.54,70.7 142.54,73.63
  BOTTOM w0.089: v3(141.47,83.2) 141,82.73 JCPU1.E8
  BOTTOM w0.102: v3(143.92,16.18) 143.34,15.6 JDIMM2.166
DDR_B_D54: length 80.7
  IN1 w0.089: v3(142.47,84.2) 143.07,84.8 145.84,84.8 146.33,84.31
  IN1 w0.102: v3(146.84,17.71) 147.25,18.11 147.25,21.49 148.07,22.32 148.07,33.87 148.43,34.23 148.43,40.66 147.95,41.14 147.95,59.95 147.85,60.05 146.98,60.05 146.88,60.15 146.88,60.46 146.98,60.56 147.85,60.56 147.95,60.66 147.95,60.97 147.85,61.07 146.98,61.07 146.88,61.17 146.88,70.27 145.76,71.39 145.76,74.35 145.36,74.74 145.36,75.47 145.86,75.97 145.86,79.35 146.48,79.97 146.48,84.16 146.33,84.31
  BOTTOM w0.089: JCPU1.D9 142,83.73 v3(142.47,84.2)
  BOTTOM w0.102: v3(146.84,17.71) 145.74,16.6 JDIMM2.174
DDR_B_D55: length 80.3
  IN1 w0.089: v3(141.47,84.2) 141.47,84.2 142,84.73 142,85.25 142.32,85.57 145.65,85.57 146.11,85.11 146.11,84.95 146.33,84.74
  IN1 w0.102: 146.33,84.74 146.79,84.28 146.79,79.84 146.06,79.12 146.06,71.51 147.18,70.4 147.18,62.22 148.25,61.15 148.25,41.26 148.76,40.76 148.76,34.09 148.4,33.74 148.4,22.22 147.55,21.37 147.55,17.02 146.84,16.31 v3(146.84,16.18)
  BOTTOM w0.089: JCPU1.E9 141,83.73 v3(141.47,84.2)
  BOTTOM w0.102: v3(146.84,16.18) 146.34,15.68 JDIMM2.176
DDR_B_D56: length 87.2
  IN1 w0.089: v3(141.47,90.2) 141.89,90.2 142.32,89.78 142.42,89.78 142.87,89.33 142.87,89 143.27,88.6 143.6,88.6 143.88,88.32 143.88,87.99 144.39,87.48 144.66,87.48 145.35,86.79 146.04,86.79 146.33,86.5
  IN1 w0.102: v3(149.14,18.51) 148.67,18.98 148.67,20.9 149.95,22.19 149.95,32.24 150.43,32.72 150.43,40.66 149.37,41.73 149.37,64.61 149.27,64.71 148.44,64.71 148.34,64.81 148.34,65.11 148.44,65.22 149.27,65.22 149.37,65.32 149.37,65.62 149.27,65.72 148.44,65.72 148.34,65.82 148.34,66.13 148.44,66.23 149.27,66.23 149.37,66.33 149.37,66.64 149.27,66.74 148.44,66.74 148.34,66.84 148.34,70.82 147.18,71.98 147.18,78.66 147.9,79.38 147.9,85.24 146.64,86.5 146.33,86.5
  BOTTOM w0.089: v3(141.47,90.2) 141,89.73 JCPU1.E15
  BOTTOM w0.102: v3(149.14,18.51) 147.84,19.81 JDIMM2.181
DDR_B_D57: length 86.5
  IN1 w0.089: v3(142.47,90.2) 142.47,90.04 143.06,89.45 143.06,89.08 143.34,88.8 143.67,88.8 144.07,88.4 144.07,88.07 144.47,87.67 145.52,87.67 146.12,87.08 146.33,87.08
  IN1 w0.102: 146.33,87.08 146.49,87.08 148.21,85.36 148.21,79.25 147.49,78.53 147.49,72.14 148.64,70.98 148.64,70.45 148.77,70.32 149.31,70.32 149.43,70.19 149.43,69.94 149.31,69.81 148.77,69.81 148.64,69.68 148.64,69.39 148.77,69.27 149.57,69.27 149.68,69.17 149.68,68.89 149.55,68.76 148.74,68.76 148.64,68.66 148.64,68.35 148.74,68.25 149.55,68.25 149.68,68.12 149.68,67.87 149.55,67.74 148.74,67.74 148.64,67.64 148.64,67.34 148.74,67.24 149.55,67.24 149.68,67.11 149.68,41.85 150.78,40.75 150.78,29.09 150.68,28.99 150.41,28.99 150.31,28.89 150.31,28.58 150.41,28.48 150.68,28.48 150.78,28.38 150.78,28.08 150.68,27.97 150.41,27.97 150.31,27.87 150.31,27.57 150.41,27.47 150.68,27.47 150.78,27.36 150.78,27.06 150.68,26.96 150.41,26.96 150.31,26.86 150.31,26.55 150.41,26.45 150.68,26.45 150.78,26.35 150.78,23.01 150.35,22.57 150.35,21.24 v3(149.14,20.03)
  BOTTOM w0.089: v3(142.47,90.2) 142,89.73 JCPU1.D15
  BOTTOM w0.102: JDIMM2.183 148.44,20.73 v3(149.14,20.03)
DDR_B_D58: length 86.7
  IN1 w0.102: v3(145.47,90.2) 146.88,90.2 150.47,86.61 150.47,78.37 149.68,77.58 149.68,72.98 151.96,70.71 151.96,57.43 152.06,57.33 152.97,57.33 153.08,57.23 153.08,56.93 152.97,56.82 152.06,56.82 151.96,56.72 151.96,56.42 152.06,56.32 152.97,56.32 153.08,56.21 153.08,55.91 152.97,55.81 152.06,55.81 151.96,55.71 151.96,55.4 152.06,55.3 152.97,55.3 153.08,55.2 153.08,40.82 153.74,40.15 153.74,22.42 153.08,21.75 153.08,19.27 v3(152.3,18.48)
  BOTTOM w0.089: v3(145.47,90.2) 145,89.73 JCPU1.A15
  BOTTOM w0.102: JDIMM2.191 150.84,19.95 v3(152.3,18.48)
DDR_B_D59: length 86.5
  IN1 w0.102: v3(144.47,90.2) 144.89,89.78 146.75,89.78 150.16,86.37 150.16,78.49 149.37,77.7 149.37,72.86 151.58,70.66 151.58,55.02 151.68,54.91 152.67,54.91 152.77,54.81 152.77,54.51 152.67,54.41 151.68,54.41 151.58,54.3 151.58,54 151.68,53.9 152.67,53.9 152.77,53.8 152.77,53.49 152.67,53.39 151.68,53.39 151.58,53.29 151.58,52.98 151.68,52.88 152.67,52.88 152.77,52.78 152.77,52.48 152.67,52.37 151.68,52.37 151.58,52.27 151.58,51.97 151.68,51.87 152.67,51.87 152.77,51.76 152.77,40.69 153.44,40.02 153.44,22.62 152.78,21.96 152.78,20.34 152.45,20.01 v3(152.3,20.01)
  BOTTOM w0.089: v3(144.47,90.2) 144,89.73 JCPU1.B15
  BOTTOM w0.102: JDIMM2.193 151.44,20.87 v3(152.3,20.01)
DDR_B_D60: length 87.2
  IN1 w0.089: v3(141.47,89.2) 141.91,88.76 141.91,87.23 142.54,86.6 145.82,86.6 146.33,86.09
  IN1 w0.102: 146.33,86.09 146.61,86.09 147.6,85.11 147.6,79.5 146.88,78.78 146.88,71.85 147.99,70.73 147.99,64.25 148.1,64.15 148.96,64.15 149.07,64.05 149.07,63.75 148.96,63.64 148.1,63.64 147.99,63.54 147.99,63.24 148.1,63.14 148.96,63.14 149.07,63.03 149.07,62.73 148.96,62.63 148.5,62.63 148.4,62.53 148.4,62.22 148.5,62.12 148.96,62.12 149.07,62.02 149.07,41.6 149.6,41.07 149.6,22.26 148.37,21.03 148.37,17.76 v3(149.14,16.99)
  BOTTOM w0.089: JCPU1.E14 141,88.73 v3(141.47,89.2)
  BOTTOM w0.102: v3(149.14,16.99) 148.8,16.99 147.54,15.72 JDIMM2.180
DDR_B_D61: length 86.5
  IN1 w0.089: 146.33,85.79 141.35,85.79 141.1,86.04 141.1,89.35 141.32,89.57 142.1,89.57 v3(142.47,89.2)
  IN1 w0.102: v3(149.14,15.46) 148.06,16.54 148.06,21.16 149.27,22.36 149.27,40.97 148.76,41.47 148.76,61.36 147.69,62.43 147.69,70.61 146.57,71.72 146.57,78.91 147.29,79.63 147.29,84.98 146.49,85.79 146.33,85.79
  BOTTOM w0.089: JCPU1.D14 142,88.73 v3(142.47,89.2)
  BOTTOM w0.102: v3(149.14,15.46) 148.48,15.46 148.14,15.12 JDIMM2.182
DDR_B_D62: length 86.6
  IN1 w0.102: v3(145.47,89.2) 145.72,88.95 146.9,88.95 149.86,86 149.86,78.62 149.07,77.83 149.07,72.73 151.26,70.54 151.26,51.37 151.36,51.26 152.37,51.26 152.47,51.16 152.47,50.86 152.37,50.76 151.36,50.76 151.26,50.65 151.26,50.35 151.36,50.25 152.37,50.25 152.47,50.15 152.47,49.84 152.37,49.74 151.36,49.74 151.26,49.64 151.26,49.33 151.36,49.23 152.37,49.23 152.47,49.13 152.47,40.57 153.14,39.9 153.14,22.74 151.9,21.5 151.9,17.37 v3(152.3,16.96)
  BOTTOM w0.089: v3(145.47,89.2) 145,88.73 JCPU1.A14
  BOTTOM w0.102: v3(152.3,16.96) 151.9,16.55 151.9,15.96 151.14,15.2 JDIMM2.192
DDR_B_D63: length 86.4
  IN1 w0.102: v3(144.47,89.2) 144.72,89.2 145.28,88.64 146.79,88.64 149.55,85.87 149.55,78.75 148.76,77.96 148.76,72.6 150.94,70.43 150.94,48.87 151.04,48.77 151.82,48.77 151.94,48.64 151.94,48.39 151.82,48.26 151.03,48.26 150.91,48.14 150.91,47.88 151.03,47.75 152.06,47.75 152.16,47.65 152.16,47.35 152.06,47.25 151.03,47.25 150.91,47.12 150.91,46.87 151.03,46.74 152.06,46.74 152.16,46.64 152.16,22.2 151.59,21.63 151.59,16.15 v3(152.3,15.44)
  BOTTOM w0.089: v3(144.47,89.2) 144,88.73 JCPU1.B14
  BOTTOM w0.102: v3(152.3,15.44) 152,15.44 151.74,15.18 JDIMM2.194
DDR_B_DQS0: length 89.3
  IN1 w0.102: v3(111.47,91.2) 111.47,91.47 111.32,91.62 111.24,91.62 111.07,91.45 111.07,90.95 110.7,90.58 110.31,90.58 110.08,90.35 110.08,89.97 109.7,89.58 108.89,89.58 97.68,78.36 97.68,53.77 96.33,52.42 96.33,50.2 94.89,48.77 94.89,42.33 93.51,40.96 93.51,34.24 94.17,33.58 94.17,28.83 93,27.66 93,17.4 93.44,16.97 93.5,16.97 93.68,17.15 v3(93.68,17.32)
  BOTTOM w0.089: v3(111.47,91.2) 111.94,91.67 JCPU1.AP17
  BOTTOM w0.102: v3(93.68,17.32) 93.97,17.03 94.15,17.03 94.44,16.74 94.44,15.21 94.74,14.91 JDIMM2.12
DDR_B_DQS1: length 80.7
  IN1 w0.102: v3(99.52,18.85) 99.52,18.85 99.2,19.17 99.02,19.17 98.79,19.4 98.79,20.68 99.02,20.91 99.18,20.91 99.3,21.03 99.3,21.29 99.18,21.41 99.04,21.41 98.79,21.66 98.79,22.3 99.02,22.53 99.13,22.53 99.25,22.65 99.25,22.91 99.13,23.03 99.02,23.03 98.79,23.26 98.79,36.42 97.8,37.42 97.8,38.27 98.15,38.62 98.15,39.4 97.8,39.75 97.8,40.5 98.24,40.94 98.24,47.38 99.68,48.81 99.68,51.03 101.03,52.38 101.03,57.33 102.12,58.42 102.29,58.42 102.47,58.6 102.47,62.24 106.59,66.36 106.59,81.26 109.13,83.8 109.68,83.8 109.87,83.99 109.87,84.59 110.09,84.81 110.65,84.81 110.87,85.03 110.87,85.78 111.08,85.99 111.27,85.99 v3(111.47,86.2)
  BOTTOM w0.089: v3(111.47,86.2) 111.94,86.67 JCPU1.AP12
  BOTTOM w0.102: v3(99.52,18.85) 99.83,19.16 100.07,19.16 100.27,19.36 100.27,20.52 99.84,20.95 JDIMM2.29
DDR_B_DQS2: length 72.6
  IN1 w0.102: v3(104.6,18.85) 104.42,19.03 104.1,19.03 103.84,19.29 103.84,21.68 102.95,22.57 102.95,26.07 103.18,26.3 103.34,26.3 103.47,26.43 103.47,26.68 103.34,26.81 103.18,26.81 102.95,27.04 102.95,27.52 103.18,27.75 103.34,27.75 103.47,27.88 103.47,28.13 103.34,28.26 103.18,28.26 102.95,28.48 102.95,35.38 103.13,35.55 103.34,35.55 103.47,35.68 103.47,35.96 103.37,36.06 103.21,36.06 102.95,36.31 102.95,36.75 103.21,37 103.37,37 103.47,37.1 103.47,40.65 103.68,40.87 103.91,40.87 104.03,40.99 104.03,47.9 105.41,49.29 105.41,51.36 106.06,52.01 106.06,60.79 110.28,65 110.28,75.13 110.86,75.71 110.86,79.78 111.11,80.03 111.3,80.03 v3(111.47,80.2)
  BOTTOM w0.089: v3(111.47,80.2) 111.94,80.67 JCPU1.AP6
  BOTTOM w0.102: JDIMM2.47 105.24,20.64 105.45,20.43 105.45,19.48 105.1,19.13 104.88,19.13 v3(104.6,18.85)
DDR_B_DQS3: length 70.7
  IN1 w0.102: v3(115.47,77.2) 115.57,77.2 115.67,77.1 115.67,76.91 115.56,76.8 115.18,76.8 114.85,76.47 114.85,71.09 113.99,70.22 113.99,63.66 109.63,59.31 109.63,44.58 108.59,43.54 108.59,32.74 108.13,32.28 108.13,29.15 108.36,28.93 108.46,28.93 108.59,28.8 108.59,28.55 108.46,28.42 108.36,28.42 108.13,28.19 108.13,23.19 108.59,22.73 108.59,21.44 108.84,21.19 109.24,21.19 109.32,21.11 109.32,17.1 109.56,16.86 109.75,16.86 v3(110.01,16.6)
  BOTTOM w0.089: JCPU1.AK3 116.04,77.63 116.04,77.34 115.9,77.2 v3(115.47,77.2)
  BOTTOM w0.102: JDIMM2.64 110.34,15.13 110.09,15.38 109.84,15.38 109.48,15.75 109.48,16.67 109.63,16.82 109.79,16.82 v3(110.01,16.6)
DDR_B_DQS4: length 68.6
  IN1 w0.102: v3(134.47,77.2) 134.54,77.27 134.97,77.27 135.09,77.14 135.09,76.8 135.31,76.58 135.64,76.58 135.87,76.36 135.87,68.09 138.22,65.74 138.22,42.69 136.18,40.65 136.18,37.71 135.96,37.48 135.96,35.61 136.18,35.39 136.18,29.2 135.77,28.79 135.77,25.93 136.18,25.53 136.18,25.16 135.83,24.81 135.83,24.12 136.18,23.77 136.18,23.19 135.55,22.56 135.55,21.95 135.43,21.82 134.96,21.82 134.7,21.57 134.7,21.14 134.96,20.88 135.46,20.88 135.58,20.76 135.58,19.22 135.46,19.11 135.14,19.11 135.01,19.23 v3(135.01,19.48)
  BOTTOM w0.089: v3(134.47,77.2) JCPU1.M3
  BOTTOM w0.102: JDIMM2.137 134.64,20.69 134.47,20.52 134.47,19.35 134.61,19.21 134.73,19.21 v3(135.01,19.48)
DDR_B_DQS5: length 77.4
  IN1 w0.089: v3(138.47,83.2) 138.47,83.62 138.53,83.68 138.7,83.68 138.89,83.49 138.89,80.88 139.19,80.59 139.68,80.59 139.89,80.37 139.89,75.87 140.25,75.51 140.45,75.31 140.45,74.57 140.27,74.38 140.27,74.32 140.26,74.31 140.26,74.3
  IN1 w0.102: 140.26,74.3 140.26,68.74 141.8,67.21 141.8,41.22 141.16,40.59 141.16,36.5 141.41,36.25 141.66,36.25 141.79,36.13 141.79,35.87 141.66,35.75 141.42,35.75 141.16,35.49 141.16,35.06 141.42,34.81 141.66,34.81 141.79,34.68 141.79,34.43 141.66,34.3 141.37,34.3 141.16,34.09 141.16,28.67 141.47,28.36 141.47,23.11 140.87,22.51 140.44,22.51 140.06,22.13 140.06,18.89 139.36,18.19 139.36,17.12 139.67,16.82 140.02,16.82 140.11,16.73 v3(140.11,16.48)
  BOTTOM w0.089: v3(138.47,83.2) 138,82.73 JCPU1.H8
  BOTTOM w0.102: JDIMM2.154 139.74,15.13 139.6,15.26 139.6,16.59 139.76,16.74 139.85,16.74 v3(140.11,16.48)
DDR_B_DQS6: length 77.9
  IN1 w0.102: v3(145.57,19.61) 145.57,19.36 145.44,19.23 145.19,19.23 145.06,19.36 145.06,20.44 145.57,20.95 145.57,21.87 145.75,22.05 146.22,22.05 146.83,22.66 146.83,26.16 146.6,26.39 146.36,26.39 146.23,26.51 146.23,26.77 146.36,26.9 146.65,26.9 146.9,27.15 146.9,27.58 146.65,27.83 146.36,27.83 146.23,27.96 146.23,28.22 146.36,28.34 146.6,28.34 146.83,28.57 146.83,33.1 146.6,33.33 146.36,33.33 146.23,33.45 146.23,33.71 146.36,33.83 146.6,33.83 146.83,34.06 146.83,34.55 146.6,34.77 146.36,34.77 146.23,34.9 146.23,35.15 146.36,35.28 146.6,35.28 146.83,35.51 146.83,35.99 146.6,36.22 146.36,36.22 146.23,36.35 146.23,36.6 146.36,36.73 146.6,36.73 146.83,36.96 146.83,52.38 145.7,53.52 145.7,69.87 144.24,71.33 144.24,75.52 145.09,76.37 145.09,83.56 144.83,83.81 143.6,83.81 143.47,83.94 v3(143.47,84.2)
  BOTTOM w0.089: v3(143.47,84.2) 143,83.73 JCPU1.C9
  BOTTOM w0.102: v3(145.57,19.61) 145.28,19.32 145.04,19.32 144.72,19.64 144.72,20.84 144.84,20.96 JDIMM2.171
DDR_B_DQS7: length 89.2
  IN1 w0.102: v3(150.43,16.6) 150.64,16.82 150.86,16.82 151.07,17.04 151.07,19.1 150.9,19.27 150.9,20.6 151.07,20.77 151.07,22.02 151.51,22.46 151.51,41.58 151.29,41.8 150.75,41.8 150.62,41.93 150.62,42.18 150.75,42.31 151.29,42.31 151.51,42.54 151.51,43.02 151.29,43.25 150.53,43.25 150.4,43.38 150.4,43.63 150.53,43.76 151.29,43.76 151.51,43.99 151.51,44.47 151.29,44.7 150.53,44.7 150.4,44.83 150.4,45.08 150.53,45.21 151.29,45.21 151.51,45.44 151.51,45.92 151.29,46.15 150.53,46.15 150.4,46.27 150.4,70.25 148.21,72.44 148.21,78.16 148.97,78.92 148.97,85.64 146.71,87.9 146.15,87.9 145.87,88.18 145.41,88.18 144.79,88.8 144.3,88.8 144.09,89.01 144.09,89.5 143.72,89.87 143.51,89.87 143.47,89.91 v3(143.47,90.2)
  BOTTOM w0.089: JCPU1.C15 143.04,89.73 143.47,90.16 v3(143.47,90.2)
  BOTTOM w0.102: v3(150.43,16.6) 150.43,16.79 150.21,17.01 150.05,17.01 149.94,16.9 JDIMM2.188
DDR_B_DQS#0: length 89.3
  IN1 w0.102: v3(93.68,16.56) 93.68,16.56 93.49,16.75 93.35,16.75 92.79,17.31 92.79,27.75 93.96,28.92 93.96,33.49 93.3,34.15 93.3,41.05 94.67,42.42 94.67,48.86 96.11,50.29 96.11,52.51 97.46,53.86 97.46,78.45 108.8,89.8 109.61,89.8 109.87,90.06 109.87,90.44 110.22,90.8 110.61,90.8 110.85,91.04 110.85,91.54 111.19,91.87 111.38,91.87 111.47,91.97 v3(111.47,92.2)
  BOTTOM w0.089: v3(111.47,92.2) 111.94,92.67 JCPU1.AP18
  BOTTOM w0.102: JDIMM2.10 94.14,15.07 94.21,15.14 94.21,16.65 94.05,16.81 93.92,16.81 v3(93.68,16.56)
DDR_B_DQS#1: length 80.6
  IN1 w0.102: v3(111.47,85.2) 111.7,85.43 111.7,85.72 111.63,85.78 111.17,85.78 111.09,85.7 111.09,84.94 110.74,84.6 110.18,84.6 110.09,84.5 110.09,83.9 109.77,83.58 109.22,83.58 106.81,81.17 106.81,66.27 102.69,62.15 102.69,58.51 102.38,58.2 102.21,58.2 101.25,57.24 101.25,52.29 99.89,50.94 99.89,48.72 98.46,47.29 98.46,40.85 98.01,40.41 98.01,39.84 98.36,39.49 98.36,38.53 98.01,38.18 98.01,37.51 99.01,36.51 99.01,23.35 99.11,23.25 99.21,23.25 99.47,23 99.47,22.56 99.21,22.31 99.11,22.31 99.01,22.21 99.01,21.75 99.13,21.63 99.27,21.63 99.52,21.38 99.52,20.94 99.27,20.69 99.11,20.69 99.01,20.59 99.01,19.49 99.11,19.38 99.29,19.38 v3(99.52,19.61)
  BOTTOM w0.089: v3(111.47,85.2) 111.94,85.67 JCPU1.AP11
  BOTTOM w0.102: JDIMM2.27 99.24,20.96 99.42,20.78 99.69,20.78 100.04,20.43 100.04,19.45 99.98,19.39 99.74,19.39 v3(99.52,19.61)
DDR_B_DQS#2: length 72.5
  IN1 w0.102: v3(104.6,19.61) 104.6,19.33 104.51,19.25 104.19,19.25 104.05,19.38 104.05,21.77 103.17,22.65 103.17,25.98 103.27,26.09 103.43,26.09 103.68,26.34 103.68,26.77 103.43,27.03 103.27,27.03 103.17,27.13 103.17,27.43 103.27,27.53 103.43,27.53 103.68,27.79 103.68,28.22 103.43,28.47 103.27,28.47 103.17,28.57 103.17,35.29 103.22,35.33 103.43,35.33 103.68,35.59 103.68,36.05 103.46,36.28 103.3,36.28 103.17,36.4 103.17,36.66 103.3,36.78 103.46,36.78 103.68,37.01 103.68,40.57 103.77,40.65 104,40.65 104.24,40.9 104.24,47.82 105.63,49.2 105.63,51.27 106.28,51.92 106.28,60.7 110.49,64.91 110.49,75.04 111.07,75.62 111.07,79.69 111.2,79.81 111.44,79.81 111.63,79.62 111.63,79.36 v3(111.47,79.2)
  BOTTOM w0.089: v3(111.47,79.2) 111.94,79.67 JCPU1.AP5
  BOTTOM w0.102: JDIMM2.45 104.64,20.92 105.22,20.34 105.22,19.57 105.01,19.36 104.85,19.36 v3(104.6,19.61)
DDR_B_DQS#3: length 70.7
  IN1 w0.102: v3(116.47,77.2) 116.4,77.27 116.02,77.27 115.89,77.14 115.89,76.83 115.65,76.58 115.27,76.58 115.07,76.38 115.07,71 114.21,70.13 114.21,63.57 109.85,59.22 109.85,44.49 108.81,43.45 108.81,32.65 108.35,32.19 108.35,29.24 108.45,29.14 108.55,29.14 108.81,28.89 108.81,28.46 108.55,28.2 108.45,28.2 108.35,28.1 108.35,23.28 108.81,22.82 108.81,21.53 108.93,21.41 109.33,21.41 109.53,21.2 109.53,17.19 109.65,17.07 109.92,17.07 110.01,17.16 v3(110.01,17.36)
  BOTTOM w0.089: JCPU1.AJ3 116.94,77.67 v3(116.47,77.2)
  BOTTOM w0.102: JDIMM2.62 109.74,15.16 109.25,15.65 109.25,16.76 109.53,17.05 109.7,17.05 v3(110.01,17.36)
DDR_B_DQS#4: length 68.5
  IN1 w0.102: v3(135.01,18.72) 135.18,18.89 135.55,18.89 135.79,19.13 135.79,20.85 135.55,21.1 135.05,21.1 134.92,21.23 134.92,21.48 135.05,21.61 135.52,21.61 135.77,21.86 135.77,22.47 136.39,23.1 136.39,23.86 136.04,24.21 136.04,24.72 136.39,25.07 136.39,25.62 135.99,26.02 135.99,28.7 136.39,29.11 136.39,35.48 136.17,35.7 136.17,37.39 136.39,37.62 136.39,40.56 138.43,42.6 138.43,65.83 136.08,68.18 136.08,76.45 135.73,76.8 135.4,76.8 135.31,76.89 135.31,77.13 135.37,77.2 v3(135.47,77.2)
  BOTTOM w0.089: v3(135.47,77.2) JCPU1.L3
  BOTTOM w0.102: v3(135.01,18.72) 134.75,18.98 134.52,18.98 134.24,19.26 134.24,20.56 134.04,20.76 JDIMM2.135
DDR_B_DQS#5: length 77.4
  IN1 w0.089: 140.48,74.3 140.66,74.48 140.66,75.39 140.39,75.66 140.1,75.95 140.1,80.46 139.76,80.79 139.27,80.79 139.09,80.97 139.09,83.57 138.78,83.89 138.57,83.89 138.47,83.99 v3(138.47,84.2)
  IN1 w0.102: v3(140.11,17.24) 139.9,17.03 139.76,17.03 139.57,17.21 139.57,18.1 140.28,18.8 140.28,22.04 140.53,22.3 140.96,22.3 141.68,23.02 141.68,28.45 141.38,28.76 141.38,34 141.46,34.08 141.75,34.08 142,34.34 142,34.77 141.75,35.02 141.51,35.02 141.38,35.15 141.38,35.4 141.51,35.53 141.75,35.53 142,35.78 142,36.22 141.75,36.47 141.5,36.47 141.38,36.59 141.38,40.5 142.01,41.13 142.01,67.3 140.48,68.83 140.48,74.3
  BOTTOM w0.089: v3(138.47,84.2) 138,83.73 JCPU1.H9
  BOTTOM w0.102: v3(140.11,17.24) 139.84,16.97 139.66,16.97 139.38,16.68 139.38,15.15 139.14,14.92 JDIMM2.152
DDR_B_DQS#6: length 78
  IN1 w0.102: v3(143.47,83.2) 143.87,83.6 144.74,83.6 144.87,83.47 144.87,76.46 144.02,75.61 144.02,71.24 145.48,69.78 145.48,53.43 146.61,52.29 146.61,37.05 146.51,36.94 146.27,36.94 146.02,36.69 146.02,36.26 146.27,36 146.51,36 146.61,35.9 146.61,35.6 146.51,35.5 146.27,35.5 146.02,35.24 146.02,34.81 146.27,34.56 146.51,34.56 146.61,34.46 146.61,34.15 146.51,34.05 146.27,34.05 146.02,33.8 146.02,33.36 146.27,33.11 146.51,33.11 146.61,33.01 146.61,28.66 146.51,28.56 146.27,28.56 146.02,28.31 146.02,27.87 146.27,27.62 146.56,27.62 146.69,27.49 146.69,27.24 146.56,27.11 146.27,27.11 146.02,26.86 146.02,26.42 146.27,26.17 146.51,26.17 146.61,26.07 146.61,22.75 146.13,22.26 145.66,22.26 145.35,21.96 145.35,21.04 144.85,20.53 144.85,19.27 145.1,19.02 145.4,19.02 v3(145.57,18.85)
  BOTTOM w0.089: JCPU1.C8 143,82.73 v3(143.47,83.2)
  BOTTOM w0.102: v3(145.57,18.85) 145.33,19.09 144.94,19.09 144.49,19.54 144.49,20.9 144.24,21.15 JDIMM2.169
DDR_B_DQS#7: length 89.2
  IN1 w0.102: v3(150.43,17.37) 150.43,17.17 150.55,17.04 150.77,17.04 150.85,17.13 150.85,19.01 150.69,19.18 150.69,20.69 150.85,20.86 150.85,22.11 151.3,22.55 151.3,41.49 151.2,41.59 150.66,41.59 150.41,41.84 150.41,42.27 150.66,42.53 151.2,42.53 151.3,42.63 151.3,42.93 151.2,43.04 150.44,43.04 150.18,43.29 150.18,43.72 150.44,43.98 151.2,43.98 151.3,44.08 151.3,44.38 151.2,44.48 150.44,44.48 150.18,44.74 150.18,45.17 150.44,45.42 151.2,45.42 151.3,45.52 151.3,45.83 151.2,45.93 150.44,45.93 150.18,46.18 150.18,70.16 148,72.35 148,78.25 148.76,79.01 148.76,85.55 146.62,87.69 146.06,87.69 145.78,87.97 145.32,87.97 144.7,88.58 144.21,88.58 143.87,88.92 143.87,89.41 143.63,89.65 143.45,89.65 143.38,89.59 143.38,89.29 v3(143.47,89.2)
  BOTTOM w0.089: JCPU1.C14 143,88.73 v3(143.47,89.2)
  BOTTOM w0.102: v3(150.43,17.37) 150.3,17.24 149.96,17.24 149.71,16.99 149.71,15.32 149.34,14.95 JDIMM2.186
DDR_B_MA0: length 81.4
  IN1 w0.089: 124.89,73.63 124.89,74.39 124.25,75.04 124.25,78.63 124.42,78.81 124.42,79.29 125.15,80.03 125.15,80.36 125.45,80.66 128.38,80.66 129.32,81.6 130.87,81.6 v3(131.47,82.2)
  IN1 w0.165: 124.89,73.63 124.89,61.06 123.51,59.68 123.51,59.45 124.04,58.92 124.04,58.69 123.81,58.45 123.57,58.45 123.04,58.98 122.81,58.98 120.39,56.56 120.39,55.16 120.55,55 121.18,55 121.31,54.87 121.31,54.46 121.18,54.34 120.55,54.34 120.39,54.17 120.39,22.56 121.88,21.06 121.88,18.14 v3(122.85,17.17)
  BOTTOM w0.089: v3(131.47,82.2) JCPU1.R8
  BOTTOM w0.165: v3(122.85,17.17) 123.35,16.67 123.35,15.23 122.94,14.82 JDIMM2.98
DDR_B_MA1: length 78.7
  IN1 w0.089: 125.9,73.63 125.9,74.24 124.63,75.51 124.63,78.48 124.8,78.65 124.8,79 125.59,79.79 126.07,79.79 v3(126.47,80.19)
  IN1 w0.165: v3(121.52,24.77) 121.52,24.63 121.65,24.5 122.68,24.5 122.81,24.63 122.81,25.33 122.68,25.45 122.22,25.45 121.38,26.29 121.38,27.38 121.54,27.55 121.86,27.55 121.99,27.67 121.99,28.08 121.86,28.21 121.54,28.21 121.38,28.37 121.38,28.8 121.51,28.93 121.83,28.93 121.96,29.06 121.96,34.69 121.79,34.86 121.51,34.86 121.38,34.98 121.38,35.39 121.51,35.52 121.79,35.52 121.96,35.68 121.96,36.01 121.79,36.18 121.51,36.18 121.38,36.3 121.38,36.71 121.51,36.84 121.79,36.84 121.96,37 121.96,41.2 121.83,41.33 121.51,41.33 121.38,41.46 121.38,42.05 121.51,42.18 122.27,42.18 122.39,42.31 122.39,42.71 122.27,42.84 121.54,42.84 121.38,43 121.38,43.34 121.54,43.5 122.27,43.5 122.39,43.63 122.39,44.03 122.27,44.16 121.54,44.16 121.38,44.33 121.38,44.66 121.54,44.82 122.27,44.82 122.39,44.95 122.39,45.35 122.27,45.48 121.54,45.48 121.38,45.65 121.38,45.98 121.54,46.14 122.27,46.14 122.39,46.27 122.39,46.68 122.27,46.8 121.54,46.8 121.38,46.97 121.38,47.55 121.51,47.68 122.27,47.68 122.39,47.81 122.39,48.23 122.27,48.35 121.54,48.35 121.41,48.48 121.41,48.99 121.58,49.15 122.14,49.15 122.3,49.32 122.3,49.65 122.14,49.81 121.58,49.81 121.41,49.98 121.41,50.31 121.58,50.47 122.14,50.47 122.3,50.64 122.3,54.78 125.9,58.38 125.9,73.63
  BOTTOM w0.089: JCPU1.Y5 126.01,79.73 v3(126.47,80.19)
  BOTTOM w0.165: v3(121.52,24.77) 122.64,23.65 JDIMM2.97
DDR_B_MA2: length 75.9
  IN1 w0.089: 124.4,73.63 124.4,74.28 124.05,74.62 124.05,78.71 124.23,78.89 124.23,79.37 124.92,80.06 124.92,80.39 125.37,80.85 125.65,80.85 126.02,81.21 126.02,82.28 126.78,83.04 126.78,83.89 v3(126.47,84.2)
  IN1 w0.165: v3(122.85,15.64) 121.39,17.11 121.39,20.86 119.85,22.4 119.85,56.72 124.4,61.27 124.4,73.63
  BOTTOM w0.089: v3(126.47,84.2) JCPU1.Y10
  BOTTOM w0.165: JDIMM2.96 122.34,15.13 v3(122.85,15.64)
DDR_B_MA3: length 77.1
  IN1 w0.089: 125.39,73.63 125.39,74.46 124.44,75.41 124.44,78.56 124.61,78.73 124.61,79.21 125.53,80.13 v3(125.53,80.2)
  IN1 w0.165: v3(122.85,19.45) 122.38,19.93 122.38,21.27 120.88,22.76 120.88,50.87 121.05,51.03 121.63,51.03 121.79,51.2 121.79,51.53 121.63,51.69 121.05,51.69 120.88,51.86 120.88,52.19 121.05,52.35 121.63,52.35 121.79,52.52 121.79,52.85 121.63,53.01 121.05,53.01 120.88,53.18 120.88,53.71 121.01,53.84 121.68,53.84 121.81,53.97 121.81,54.99 122.06,55.24 122.06,55.48 121.12,56.42 121.12,56.59 121.41,56.88 121.59,56.88 122.53,55.94 122.76,55.94 123,56.18 123,56.41 122.06,57.35 122.06,57.53 122.35,57.82 122.53,57.82 123.46,56.88 123.7,56.88 125.39,58.57 125.39,73.63
  BOTTOM w0.089: JCPU1.AA5 125.06,79.73 v3(125.53,80.2)
  BOTTOM w0.165: v3(122.85,19.45) 122.04,20.27 JDIMM2.95
