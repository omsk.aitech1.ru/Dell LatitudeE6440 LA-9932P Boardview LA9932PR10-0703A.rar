# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GREEN_DOCK: length 9
  IN1 w0.102: v3(132.65,159.86) 132.65,159.31 131,157.66 131,157.22 131.58,156.64 v3(131.58,155.94)
  BOTTOM w0.102: U6.24 133,155.1 132.72,155.37 v1(132.38,155.37) 132.15,155.37 131.59,155.94 v3(131.58,155.94) ; v3(132.65,159.86) 133.01,159.86 133.34,160.19 JDOCK1.59
H_CATERR#: length 8.1
  TOP w0.089: v3(112.47,107.2) 112.48,107.2 112.98,107.7 v2(112.98,107.94) 112.87,108.06 112.87,109.5 112.56,109.81 112.21,109.81 111.44,110.59 109.74,110.59 RC28.2
  BOTTOM w0.089: v3(112.47,107.2) JCPU1.AN32
H_CPU_RSVD: length 2.5
  TOP w0.089: RC82.1 138.42,99.44 v1(138.42,100.68) 138.42,101.15 v3(138.47,101.2)
  BOTTOM w0.089: JCPU1.G26 v3(138.47,101.2)
H_CPU_SVIDALRT#: length 22.9
  TOP w0.102: v3(105.48,116.85) 105.27,116.65 v1(105.27,116.32) RC88.1
  IN1 w0.102: v3(105.48,116.85) 105.48,116.24 107.08,114.64 107.08,105.36 108.75,103.69 112.78,103.69 113.03,103.43 113.03,102.64 v3(113.47,102.2)
  BOTTOM w0.089: JCPU1.AM28 113.94,102.67 v3(113.47,102.2)
H_CPU_TESTLO: length 5.9
  TOP w0.089: 129.48,111.73 v1(129.48,110.85) 128.96,110.33 128.96,109.87 128.75,109.67 126.93,109.67 v3(126.47,109.21)
  TOP w0.102: RC80.1 129.48,111.73
  BOTTOM w0.089: JCPU1.W34 126.94,108.74 v3(126.47,109.21)
H_CPUPWRGD: length 175.9
  TOP w0.102: v3(138.03,147.77) 137.78,148.02 v1(135.96,148.02) 133.43,148.02 129.32,152.13 122.22,152.13 120.72,150.62 118.17,150.62 114.97,147.42 102.39,147.42 97.12,142.15 97.12,141.37 96.66,140.91 96.66,138.7 96.41,138.45 96.41,122.42 97.09,121.73 97.09,115.11 v3(96.59,114.61)
  IN1 w0.102: v3(96.59,114.61) 96.59,103.87 97.26,103.2 97.26,99.11 96.37,98.22 96.37,88.04 92.03,83.7 92.03,72.68 v3(92.65,72.06)
  BOTTOM w0.089: UH1.AV3 160.31,128.86 160.31,128.39 159.97,128.04 159.97,127.99 159.37,127.4 159.37,127.23 158.87,126.72 158.24,126.72 158.14,126.62
  BOTTOM w0.102: v3(96.59,114.61) 96.61,114.62 103.67,114.62 RC33.1 ; v3(138.03,147.77) 139.12,147.77 140.34,146.55 140.34,146.1 150.92,135.53 150.92,125.75 151.61,125.05 156.57,125.05 158.14,126.62 ; RC20.1 96.98,73.03 95.57,71.62 93.09,71.62 v3(92.65,72.06)
H_CPUPWRGD_XDP: length 13.1
  BOTTOM w0.102: RC20.2 95.76,76.19 95.63,76.06 95.63,75.73 95.73,75.63 96.37,75.63 96.5,75.51 96.5,75.25 96.37,75.12 95.73,75.12 95.63,75.02 95.63,74.72 95.73,74.62 96.37,74.62 96.5,74.49 96.5,74.24 96.37,74.11 v1(96.08,74.11) 95.73,74.11 95.63,74.01 95.63,73.7 95.73,73.6 96.36,73.6 96.49,73.47 96.49,73.22 96.36,73.09 95.73,73.09 95.63,72.99 95.63,72.82 95.51,72.7 95.25,72.7 95.12,72.82 95.12,76.51 94.9,76.73 JXDP1.10
H_PM_SYNC: length 153.6
  TOP w0.102: v3(158.81,127.52) 158.9,127.42 158.9,126.75 158.37,126.22 154.62,126.22 153.47,125.06 151.29,125.06 148.16,128.19 v1(148.16,129.28) 148.16,141.79 v3(147.62,142.34)
  IN2 w0.127: v3(97.64,143.62) 94.87,146.4 86.97,146.4 84.65,144.08 84.65,141.04 84.22,140.6 84.22,131.73 87.86,128.08 87.86,127.18 90.98,124.06 90.98,122.9 99.53,114.35 99.87,114.35 107.35,106.87 107.35,105.32 v3(109.47,103.2)
  IN4 w0.102: v3(97.64,143.62) 103.16,143.62 109.57,150.03 112.95,150.03 113.53,150.61 130.66,150.61 132.21,149.05 137.75,149.05 144.39,142.41 147.55,142.41 v3(147.62,142.34)
  BOTTOM w0.089: UH1.AY3 159.58,128.52 159.21,128.15 159.21,127.83 158.9,127.52 v3(158.81,127.52)
  BOTTOM w0.102: v3(109.47,103.2) JCPU1.AT28
H_PROCHOT#: length 369.3
  TOP w0.102: PQ805.3 224.3,77.13 223.79,77.64 223.79,85.17 222.32,86.64 222.32,89.13 218.93,92.51 216.17,92.51 215.28,93.4 213.81,93.4 212.79,94.41 204.29,94.41 204.14,94.57 203.47,94.57 ; v3(127.26,149.72) 126.75,149.22 124.65,149.22 123.83,148.39 123.83,145.47 122.89,144.53 122.16,144.53 119.75,142.12 112.58,142.12 111.53,141.07 v1(111.53,137.09) 111.53,129.93 111.53,129.93 111.53,129.47 110.64,128.58 110.64,123.53 108.85,121.74 108.85,114.72 107.4,113.26 RC29.2 RC30.1 ; QV8.3 59.5,148.69 59.5,146.36 v3(59.56,146.29) ; 203.47,94.57 187.93,94.57 185.45,97.05 185.45,100.03 187.01,101.59 187.01,105.1 183.6,108.5 183.6,111.77 v3(184.02,112.19) ; 203.47,94.57 203.46,94.56 Q47.1 204.09,90.54 204.41,90.22 204.41,88.08 R1180.2 ; v3(237.87,137.39) 237.67,137.59 232.17,137.59 231.95,137.81 231.95,139.61 232.53,140.19 232.53,140.96 PR724.2
  IN1 w0.102: v3(237.87,137.39) 237.85,137.39 237.43,136.97 237.43,135.89 225.71,124.18 224.66,124.18 221.32,120.84 221.32,119.22 222.06,118.48 222.06,117.48 218.11,113.53 208.84,113.53 207.69,112.38 184.21,112.38 v3(184.02,112.19)
  IN4 w0.102: v3(127.26,149.72) 126.85,150.12 114.64,150.12 113.41,148.9 109.12,148.9 103.28,143.06 97.53,143.06 97.16,143.42 97.16,143.7 96.37,144.48 92.05,144.48 89.43,141.87 87.12,141.87 86.67,141.42 80.06,141.42 79.7,141.78 79.22,141.78 78.98,141.53 71.76,141.53 70.95,142.35 70.56,142.35 69.28,143.63 61.47,143.63 59.53,145.57 59.53,146.25 59.56,146.29 v3(59.56,146.29)
  BOTTOM w0.102: PR524.1 126.49,149.39 PC510.1 127.01,149.47 v3(127.26,149.72) 129.29,149.72 132.79,146.21 137.57,146.21 149.37,134.42 149.37,123.83 158.15,115.05 162.56,115.05 162.66,114.95 165.84,114.95 166,114.79 167.68,114.79 168.72,113.74 170.2,113.74 170.67,114.21 173.12,114.21 174.74,112.59 183.63,112.59 v3(184.02,112.19)
H_PROCHOT#_R: length 11.3
  TOP w0.089: v3(113.47,105.2) 113.47,105.65 112.96,106.16 112.96,106.35 112.68,106.63 112.46,106.63 112.04,107.06 112.04,108.11 111.89,108.26 111.89,109.34 111.68,109.55
  TOP w0.102: 111.68,109.55 111.25,109.97 v2(110.92,109.97) 108.58,109.97 RC30.2
  BOTTOM w0.089: JCPU1.AM30 v3(113.47,105.2)
H_THERMTRIP#: length 190.4
  TOP w0.102: Q4.3 217.22,86.46 215.77,85.02 v3(215.2,85.02)
  BOTTOM w0.102: RC31.1 RC27.2 102.03,111.53 97.49,111.53 95.92,109.97 95.92,104.1 94.59,102.77 94.59,94.88 v1(93.33,93.61) 89.98,90.27 89.98,84.58 90.5,84.07 90.5,69.58 92.99,67.08 164.63,67.08 172.68,75.14 173.39,75.14 173.99,75.74 173.99,77.42 176.61,80.04 197.56,80.04 197.96,80.43 197.96,80.95 198.86,81.85 200.75,81.85 202.54,83.64 213.83,83.64 v3(215.2,85.02)
H_THERMTRIP#_R: length 12.8
  BOTTOM w0.089: JCPU1.AM35 113.94,111.12 113.33,111.73
  BOTTOM w0.102: RC31.2 105.1,112.58 106.74,114.23 111.47,114.23 v2(112.04,113.66) 112.99,112.7 112.99,112.07 113.33,111.73
HDD_DET#: length 240.9
  IN2 w0.127: v3(153.52,94.24) 155.26,95.98 155.26,102.04 157.03,103.81 157.03,107.31 162.88,113.15 162.88,115.03 162.31,115.6 162.31,118.07 158.62,121.76 v3(158.62,122.22) 158.62,123.54 157.15,125.01 157.15,125.87 v3(155.61,127.41)
  IN3 w0.127: v3(153.52,94.24) 154.75,93.02 154.75,80.51 157.35,77.9 157.35,67.94 146.56,57.14 113.77,57.14 106.95,63.96 94.36,63.96 v3(93.97,63.57) ; v3(202.43,113.24) 202.02,113.64 201.04,113.64 200.42,113.02 185.94,113.02 184.2,114.76 173.91,114.76 173.64,115.03 170.67,115.03 169.55,116.15 167.71,116.15 165.97,117.89 164.94,117.89 163.73,119.1 161.29,119.1 160.78,119.6 160.78,120.2 158.76,122.22 v3(158.62,122.22)
  BOTTOM w0.089: UH1.AT1 161.21,127.94 160.74,127.48 160.74,126.62
  BOTTOM w0.102: RH11.1 201.46,108.67 200.84,109.29 200.84,111.3 202.43,112.89 v3(202.43,113.24) ; v3(158.62,122.22) 158.62,122.29 159.32,122.99 v1(159.32,123.18) 159.32,124.91 160.74,126.33 160.74,126.62 ; JSATA1.12 79.16,42.75 77.6,44.31 77.6,59.87 80.71,62.98 93.39,62.98 v3(93.97,63.57) ; v3(155.61,127.41) 154.24,127.41 153.81,126.97 RPH20.6
HDD_FALL_INT: length 146.9
  TOP w0.102: R503.2 84.51,57.76 84.96,58.22 87,58.22 v1(87.38,58.6) v3(92.46,63.68) ; v3(170.37,116.39) 170.08,116.68 RH106.1
  TOP w0.254: R503.2 84.48,57.5 84.48,56.56 84.65,56.39 U88.11
  IN2 w0.127: v3(170.37,116.39) 170.37,114.75 168.51,112.89 163.34,112.89 157.54,107.09 157.54,103.6 155.77,101.83 155.77,95.2 v3(153.52,92.95)
  IN3 w0.127: v3(92.46,63.68) 93.24,64.47 107.16,64.47 113.98,57.65 146.35,57.65 156.77,68.07 156.77,77.77 154.24,80.3 154.24,92.25 153.54,92.95 v3(153.52,92.95)
HDMI_BUF: length 5.5
  TOP w0.102: U19.14 21.53,199.29 21.63,199.19 21.88,199.19 22.29,198.78 22.29,198.48 R81.1 23,197.77 23.13,197.77 23.31,197.59 23.58,197.59 23.99,197.18 v1(24.16,197.18) 24.21,197.18 R79.2
HDMI_CEC: length 9.6
  BOTTOM w0.102: v1(26.77,206.68) 26.5,206.95 R73.2 25.72,208.14 23.88,209.98 23.88,210.68 23.5,211.06 21.38,211.06 JHDMI1.13
HDMI_EQ: length 7
  TOP w0.102: v1(27.14,200.4) 25.58,200.4 R80.2 24.62,200.35 23.18,200.35 R82.1 22.12,200.49 U19.17
HDMI_HPD_SINK: length 15.2
  TOP w0.102: v3(17.38,203.24) 17.48,203.14 U19.28
  IN1 w0.102: JHDMI1.19 24.55,210.89 24.55,207.67 22.26,205.37 20.51,205.37 18.38,203.24 v3(17.38,203.24)
  BOTTOM w0.102: v3(17.38,203.24) v1(17.38,203.76)
HDMI_ISET: length 6.3
  TOP w0.102: v1(10.54,199.46) 10.8,199.71 R85.2 12.22,199.24 13.53,199.24 R87.1 13.99,199.78 14.6,200.39 15.18,200.39 15.28,200.49 U19.34
HDMI_PRE: length 7.3
  TOP w0.102: U19.16 21.96,200.09 22.29,199.76 22.29,199.43 R88.1 22.85,199 23.31,198.54 24.62,198.54 R86.2 25.53,198.54 v1(27.08,198.54)
HDMI_SCL_SINK: length 22.1
  TOP w0.102: U19.32 15.5,201.29 15.43,201.22 15.17,201.22 v3(15.01,201.38) 14.82,201.19 14.28,201.19 R69.2
  IN1 w0.102: JHDMI1.15 21.44,211.57 21.69,211.32 23.31,211.32 24.32,210.3 24.32,208.9 21.69,206.26 18.57,206.26 15.62,203.32 15.05,203.32 14.35,202.62 14.35,201.54 14.69,201.2 14.83,201.2 v3(15.01,201.38)
HDMI_SDA_SINK: length 21.6
  TOP w0.102: R70.2 14.36,200.96 14.85,200.96 v3(15.01,200.8) 15.21,200.99 15.46,200.99 15.56,200.89 U19.33
  IN1 w0.102: JHDMI1.16 21.94,210.9 22.13,211.09 23.21,211.09 24.09,210.21 24.09,208.99 21.59,206.49 18.47,206.49 15.53,203.55 14.96,203.55 14.12,202.71 14.12,201.45 14.6,200.98 14.83,200.98 v3(15.01,200.8)
HDMIB_PCH_HPD: length 199.5
  TOP w0.102: U19.3 17.48,196.6 v3(17.4,196.52)
  IN2 w0.127: v3(171.1,145.14) 169.46,146.78 163.96,146.78 163.11,147.63 162.82,147.63 158.56,151.88 156.73,151.88 154.84,153.77 152.05,153.77 151.08,152.81 141.64,152.81 v3(141.23,152.39)
  IN3 w0.127: v3(17.4,196.52) 17.65,196.52 18.48,195.7 18.48,185.58 22.66,181.4 22.66,176.9 25.21,174.35 25.21,171.24 33.45,162.99 39.95,162.99 45.69,157.25 45.69,156.35 50.48,151.56 58.01,151.56 58.68,150.89 67.89,150.89 68.55,150.23 69.56,150.23 70.65,149.13 70.65,148.35 71.69,147.31 78.79,147.31 81.14,149.66 85.42,149.66 85.92,150.16 102.39,150.16 108.53,156.3 125.68,156.3 126.98,157.6 127.35,157.6 129.03,155.91 129.03,155.44 130.33,154.14 133.06,154.14 133.94,153.27 136.06,153.27 136.35,152.97 139.5,152.97 140.21,152.26 141.1,152.26 v3(141.23,152.39)
  BOTTOM w0.089: UH1.K40 171.5,144.73 v3(171.1,145.14)
  BOTTOM w0.102: R75.1 17.47,196.59 v3(17.4,196.52) 17.4,196.08 v1(17.59,195.89)
HOST_DEB_TX: length 2.7
  TOP w0.102: R853.1 237.8,76.17 v1(238,76.17) JDEG2.8
HOST_DEBUG_RX: length 9.1
  TOP w0.102: v3(207.91,89.41) 207.83,89.49 RP7.7 ; U51.B46 v3(208.18,82.73)
  IN2 w0.127: v3(208.18,82.73) 208.18,84.23 208.22,84.27 208.22,89.1 v3(207.91,89.41)
  BOTTOM w0.102: v1(208.15,88.7) 207.91,88.94 v3(207.91,89.41)
HOST_DEBUG_TX: length 113.5
  TOP w0.102: U51.B44 v3(209.18,82.73) ; v3(237.36,76.84) 236.92,76.39 R853.2 236.34,75.62 RP12.2
  IN1 w0.102: v3(209.18,82.73) 210.19,83.75 217.17,83.75 218.64,82.27 222.23,82.27 223.94,80.57 232.36,80.57 236.09,76.84 v3(237.36,76.84)
  IN2 w0.127: v3(197.82,148.3) 197.82,147.98 200.27,145.52 201.24,145.52 204.74,142.02 204.74,135.07 206.08,133.73 206.08,128.02 207.56,126.55 207.56,123.45 208.19,122.82 208.19,118.93 211.56,115.56 211.56,91.85 210.25,90.54 208.66,90.54 208.33,90.21 208.33,89.58 208.47,89.44 208.47,87.09 209.13,86.43 209.13,82.78 v3(209.18,82.73)
  BOTTOM w0.102: v3(209.18,82.73) 209.23,82.73 v1(209.62,83.11) ; JMINI2.16 198.46,149.76 197.82,149.12 v3(197.82,148.3) C595.1
HSYNC: length 8.1
  TOP w0.089: v3(172.63,149.79) 172.63,149.11 v1(171.95,148.43)
  TOP w0.102: v3(172.63,149.79) 172.63,149.9 RH94.2
  BOTTOM w0.089: UH1.N42 170.55,145.77 170.18,146.14 170.18,146.27 170.46,146.55 170.46,146.87 170.75,147.16 170.75,147.22 171.38,147.85 171.38,148.42 172.63,149.67 v3(172.63,149.79)
HSYNC_BUF: length 150.5
  IN4 w0.102: v3(129.47,154.41) 129.47,153.65 127.8,151.98 109.58,151.98 102.82,145.22 97.81,145.22 97.18,145.85 91.48,145.85 90.39,144.76 86.73,144.76 86.03,145.46 81.92,145.46 80.84,144.39 79.57,144.39 78.81,143.63 72.01,143.63 70.64,145 62.3,145 59.2,148.1 57.67,148.1 56.8,148.97 51.34,148.97 48.32,152 47.98,152 37.85,162.12 35.97,162.12 34.24,162.12 32.69,163.67 29.01,163.67 20.91,171.77 10.95,171.77 7.39,175.33 v3(7.11,175.33)
  BOTTOM w0.102: U6.20 v1(131.13,153.49) 130.38,153.49 v3(129.47,154.41) ; v3(7.11,175.33) 7.7,175.33 8,175.63 8,177.03 7.28,177.75 JIO1.6
HSYNC_DOCK: length 13.3
  TOP w0.102: v3(134.78,159.9) 134.31,159.44 133.68,159.44 132.84,158.6 v1(132.84,158.3) 132.84,156.63 131.48,155.27 131.48,152.43 v3(131.6,152.31)
  BOTTOM w0.102: U6.19 131.9,153.1 131.6,152.8 v3(131.6,152.31) ; JDOCK1.65 134.84,159.97 v3(134.78,159.9)
HW_GPS_DISABLE2#: length 213.3
  TOP w0.102: U46.B34 181.87,72.83 181.63,73.06 181.63,74.16 v3(181.47,74.32) 180.9,74.9 RP2.8
  IN2 w0.127: v3(181.47,74.32) 181.47,74.24 183.01,72.71 183.01,70.79 183.41,70.39 187.52,70.39 187.83,70.7 187.83,72 188.25,72.41 188.93,72.41 190.67,74.15 190.67,79.26 191.99,80.58 191.99,84.69 192.34,85.04 192.34,88.68 193.23,89.57 193.23,91.79 195.05,93.6 195.05,100.42 196.64,102.01 196.64,117.99 197.04,118.39 197.04,125.35 199.43,127.74 199.43,143.53 v3(199.62,143.72)
  IN3 w0.127: v3(199.62,143.72) 199.62,144.5 200.33,145.21 203.28,145.21 206.29,148.22 206.29,149 207.01,149.72 216.17,149.72 223.85,157.41 229.55,157.41 235.27,163.12 235.27,165.97 236.33,167.04 241.5,167.04 243.23,168.77 252.36,168.77 255.52,171.92 260.26,171.92 262.35,174.01 262.35,192.81 267.61,198.07 v3(280.37,198.07)
  BOTTOM w0.102: JMINI1.51 281.16,201.37 280.37,200.57 v3(280.37,198.07) ; v3(181.47,74.32) v1(181.47,75.19)
I2S_BCLK: length 11.1
  TOP w0.102: U74.16 270.29,153.06 270.45,152.9 v3(270.45,152.83) ; R1668.2 266.89,151.81 v3(266.89,151.88)
  IN1 w0.102: v3(266.89,151.88) 266.49,152.29 266.49,153.55 266.66,153.73 267.76,154.83 269.91,154.83 270.45,154.3 v3(270.45,152.83)
  BOTTOM w0.102: v3(266.89,151.88) 266.55,151.88 v1(265.96,151.3)
I2S_DO: length 14.8
  TOP w0.102: v3(271.27,152.2) 271.27,152.26 270.88,152.65 270.88,153 270.79,153.09 U74.17 ; R1097.2 265.24,150.23 v3(265.18,150.29)
  IN1 w0.102: v3(271.27,152.2) 271.27,152.26 270.88,152.65 270.88,154.43 270.26,155.06 267.67,155.06 266.26,153.65 266.26,151.37 v3(265.18,150.29)
  BOTTOM w0.102: v3(265.18,150.29) v1(264.43,150.29)
I2S_MCLK: length 11.1
  TOP w0.102: v3(270.38,152.2) 270.19,152.2 269.94,152.45 269.94,153.06 269.79,153.22 U74.15 ; v3(266.96,152.64) 266.5,152.64 266.21,152.35 R1654.2
  IN1 w0.102: v3(270.38,152.2) 270,152.58 270,154.42 269.82,154.6 267.9,154.6 267.4,154.1 267.4,153.09 v3(266.96,152.64)
  BOTTOM w0.102: v3(266.96,152.64) 266.45,152.64 v1(266,153.09)
ICLK_IREF: length 1.6
  TOP w0.254: RH163.1 162.62,147.31 v3(162.77,147.17)
  BOTTOM w0.254: UH1.AM45 162.77,146.73 v3(162.77,147.17)
IMON: length 2.9
  BOTTOM w0.203: PU500.4 124.9,146.75 124.72,146.93 PC500.2 PR521.1
IMVP_PWRGD: length 151.5
  TOP w0.102: U46.A62 188.62,62.04 188.43,61.85 188.43,61.46 v3(188.03,61.06)
  IN4 w0.102: v3(188.03,61.06) 187.62,61.46 187.62,62.35 187.33,62.64 187.33,64.76 186.79,65.31 186.22,65.31 184.17,67.35 181.8,67.35 181.27,67.88 181.27,72.55 181.9,73.18 181.9,75.23 183.94,77.27 184.65,77.27 185.29,77.91 185.29,78.18 185.67,78.55 186.4,78.55 188.41,80.56 188.41,90.19 188.83,90.6 188.83,99.46 187.92,100.37 187.92,109.58 v3(187.09,110.42)
  BOTTOM w0.102: v3(187.09,110.42) 186.23,111.27 185.83,111.27 183.99,113.11 174.9,113.11 173.32,114.7 170.47,114.7 170,114.23 168.92,114.23 167.88,115.27 166.2,115.27 166.04,115.43 162.89,115.43 162.79,115.53 158.35,115.53 149.77,124.11 v1(149.77,132.93) 149.77,134.7 137.77,146.7 132.99,146.7 129.53,150.15 123.83,150.15 123.37,149.69 123.37,148.27 123.83,147.81 PR519.1
  BOTTOM w0.203: PU500.3 124.5,146.49 123.83,147.16 PR519.1
IMVP_VR_ON: length 145.9
  TOP w0.102: U46.B66 v3(188.87,63.87)
  IN4 w0.102: v3(188.87,63.87) 188.87,64.36 188.09,65.14 187.84,65.14 184.67,68.32 181.92,68.32 181.5,68.74 181.5,72.46 182.13,73.09 182.13,75.13 184.01,77.02 184.72,77.02 185.52,77.82 185.52,78.08 185.76,78.32 186.49,78.32 188.66,80.49 188.66,90.02 189.05,90.41 189.05,99.55 188.15,100.46 188.15,109.98 v3(187.71,110.42)
  BOTTOM w0.102: v3(187.71,110.42) 186.31,111.81 185.61,111.81 184.09,113.34 175,113.34 173.41,114.93 170.37,114.93 169.9,114.46 169.02,114.46 167.97,115.5 166.3,115.5 166.13,115.66 162.98,115.66 162.88,115.76 158.44,115.76 150.1,124.1 v1(150.1,130.65) 150.1,134.69 137.87,146.93 133.08,146.93 129.63,150.38 123.73,150.38 122.75,149.4 PR511.1
INT_SPK_L+: length 221.4
  TOP w0.102: v1(177.08,12.08) 178.11,13.11 L702.1
  IN4 w0.762: 272.69,161.24 272.16,160.71 270.75,160.71 269.73,159.69 265.44,159.69 260.25,154.5 260.02,154.5 258.82,153.3 258.82,151.72 257.33,150.23 254.22,150.23 253.11,149.12 253.11,141.82 244.67,133.37 244.67,129.21 245.4,128.48 245.4,76.57 239.14,70.31 239.14,68.07 238.08,67.01 238.08,64 237.38,63.3 237.38,62.3 235.78,60.7 235.66,60.7 234.13,60.7 233.36,59.93 230.95,59.93 229.36,58.35 229.36,51.11 224.86,46.6 224.86,41.32 225.94,40.24 225.94,29.12 219.35,22.53 202.69,22.53 197.87,17.71 197.87,13.13 195.52,10.79 188.6,10.79 187.26,12.12 180.53,12.12 178.75,13.9
  vias: v3(178.75,15.56) v3(178.75,14.98) v3(272.92,162.69) v3(272.92,162.11)
INT_SPK_L-: length 215.7
  IN4 w0.762: 180.47,14.15 181.48,13.13 187.68,13.13 189.02,11.8 195.1,11.8 196.85,13.56 196.85,18.13 202.27,23.55 218.93,23.55 224.93,29.54 224.93,39.81 223.84,40.9 223.84,47.02 228.35,51.53 228.35,58.77 230.53,60.95 232.94,60.95 233.71,61.71 235.23,61.71 236.36,62.84 236.36,63.74 237.03,64.42 237.03,67.43 238.13,68.52 238.13,70.73 244.39,76.99 244.39,128.06 243.65,128.79 243.65,133.8 252.1,142.24 252.1,149.54 253.8,151.24 256.91,151.24 257.8,152.14 257.8,153.72 259.6,155.52 259.83,155.52 265.02,160.71 269.31,160.71 271.02,162.42
  vias: v1(272.29,161.98) v3(179.83,15.5) v3(179.83,14.91) v3(271.85,162.82) v3(271.85,162.23)
INT_SPK_R+: length 209.2
  TOP w0.254: 270.79,164.1 U74.44
  IN4 w0.762: 182.6,16.41 182.6,16.76 183.6,17.76 187.6,17.76 192.25,22.41 196.76,22.41 200.44,26.09 217.88,26.09 220.73,28.94 220.73,31.01 221.87,32.15 221.87,39.01 221.3,39.58 221.3,48.66 224.86,52.22 224.86,62.22 230.06,67.43 230.06,68.63 235.34,73.92 235.34,78.72 241.24,84.61 241.24,138.14 250.06,146.97 250.06,150.2 250.06,150.38 251.49,151.81 251.49,152.46 253.94,154.9 254.69,154.9 257.84,158.06 258.78,158.06 261.09,160.37 261.09,162.18 262.56,163.65 265.39,163.65 266.83,165.09 270.77,165.09
  vias: v1(271.4,164.71) v3(182.56,15.5) v3(182.56,14.91) v3(271.95,165.01) v3(272.54,165.01)
INT_SPK_R-: length 206
  TOP w0.254: U74.43 271.29,162.83 271.29,162.83
  IN4 w0.762: 270.64,163.82 270.38,164.07 267.25,164.07 265.81,162.64 262.98,162.64 262.1,161.76 262.1,159.94 259.2,157.04 258.26,157.04 255.11,153.89 254.36,153.89 252.51,152.04 252.51,151.39 251.08,149.96 251.08,146.55 242.25,137.72 242.25,84.19 236.36,78.3 236.36,73.49 231.08,68.21 231.08,67.01 225.87,61.8 225.87,51.8 222.32,48.24 222.32,40 222.89,39.43 222.89,31.73 221.74,30.59 221.74,28.52 218.3,25.07 200.86,25.07 197.18,21.39 192.67,21.39 188,16.72 184.39,16.72 183.95,16.27
  vias: v1(271.85,163.38) v3(183.77,15.5) v3(183.77,14.91) v3(271.53,163.87) v3(272.11,163.87)
INT_SPKL_L+:
  vias: v1(178.3,10.56) v3(179.07,11.18) v3(179.07,10.59)
INT_SPKL_L-:
  vias: v1(180.94,10.71) v3(180.41,11.18) v3(180.41,10.59)
INT_SPKR_R+:
  vias: v1(182.69,10.7) v3(181.93,11.12) v3(181.93,10.53)
INT_SPKR_R-:
  vias: v1(184.49,10.71) v3(183.64,11.05) v3(183.64,10.47)
INTRUDER#: length 5.3
  BOTTOM w0.089: UH1.A8 176.1,130.95 178.66,130.95 178.96,131.25 178.98,131.25
  BOTTOM w0.102: 178.98,131.25 v1(179.71,131.25) 180.33,131.25 RH43.2
IRQ_SERIRQ: length 154.1
  TOP w0.102: v3(204.87,123.94) 204.87,123.07 204.59,122.79 204.59,120.47 204.1,119.99 204.1,119.36 203.91,119.16 RPH18.2 ; U46.B21 v3(188.37,71.74) ; U51.A28 v3(215.87,80.54) ; U39.27 216.56,108.34 216.89,108.68 218.73,108.68 v1(219.42,109.37) v3(220.78,110.73)
  IN2 w0.127: v3(215.87,80.54) 216.34,81.02 216.66,81.02 217.53,81.88 217.53,99.19 219.3,100.96 219.3,109.01 220.78,110.49 v3(220.78,110.73) 221.04,110.73 221.3,110.99 221.3,114.12 219.9,115.52 219.9,121.16 v3(219.59,121.47)
  IN3 w0.089: v3(162.75,132.01) 162.38,131.63 162.38,131.44 162.18,131.24 162.18,129.4 162.92,128.66 171.75,128.66 172.02,128.39 172.68,128.39 173.32,127.74 174.63,127.74 174.7,127.81 175.04,127.81 176.05,126.8 176.65,126.8 177.22,127.37
  IN3 w0.127: v3(215.87,80.54) 215.49,80.54 214.23,79.28 205.56,79.28 203.99,77.72 202.72,77.72 201.61,76.61 201.61,75.82 199.98,74.18 198.16,74.18 196.83,72.85 190.67,72.85 190.29,72.47 188.69,72.47 188.37,72.15 v3(188.37,71.74) ; 177.22,127.37 177.31,127.46 178.26,127.46 178.94,126.77 182.22,126.77 182.92,126.08 190.25,126.08 192.39,123.94 v3(204.87,123.94) 205.06,124.13 207.36,124.13 208.91,122.58 211.99,122.58 212.35,122.22 213.24,122.22 213.99,121.47 v3(219.59,121.47)
  BOTTOM w0.089: UH1.AL11 163.1,132.36 v3(162.75,132.01)
ISEN1: length 11.1
  TOP w0.254: PR555.1 131.32,140.01 v3(131.7,140.39) 132.16,140.39 v1(132.21,140.34) 132.4,140.15 PR553.2
  IN1 w0.254: v3(131.7,140.39) 131.7,141.47 129.03,144.14 v3(128.53,144.14)
  BOTTOM w0.203: PU500.12 127.7,143.89 127.77,143.96 127.77,143.96 127.95,144.14 v3(128.53,144.14) 128.59,144.07 128.7,144.07 PC539.2
ISEN1_VGA: length 15.9
  TOP w0.203: PU600.11 26.01,146.91 26.11,146.8 26.11,146.5 v3(25.97,146.36)
  TOP w0.254: PC616.1 26.86,144.52 26.16,145.21 26.16,146.17 v3(25.97,146.36) ; PR652.2 31.05,152.14 v3(31.28,151.91) 31.73,151.46 32.48,151.46 v1(32.7,151.69) 32.96,151.95 PR656.1
  IN3 w0.254: v3(31.28,151.91) 31.28,150.2 29.59,148.52 28.13,148.52 v3(25.97,146.36)
ISEN2: length 13.5
  TOP w0.254: v3(133.29,140.52) 133.61,140.2 PR538.2 134.13,138.99 134.2,139.07 PR546.1
  IN1 w0.254: v3(129.41,145.28) 129.41,144.39 v3(133.29,140.52)
  BOTTOM w0.102: v1(134.49,140.71) 133.92,140.71 133.73,140.52 v3(133.29,140.52)
  BOTTOM w0.203: PU500.11 127.64,144.29 127.99,144.64 129.02,144.64 PC540.2
  BOTTOM w0.254: PC540.2 129.15,145.01 v3(129.41,145.28)
ISEN2_VGA: length 17.6
  TOP w0.203: v3(25.08,145.15) 24.98,145.26 PU600.10
  TOP w0.254: PC615.1 25.91,144.33 v3(25.08,145.15) ; PR623.2 34.16,148.77 34.55,148.39 v3(34.8,148.39) 35.05,148.39 36.01,149.34 PR626.1
  BOTTOM w0.254: v3(34.8,148.39) 31.05,144.64 v1(29.53,144.64) 25.59,144.64 v3(25.08,145.15)
ISUM-_VGA: length 2.9
  TOP w0.203: 26.88,147.66 26.83,147.72 26.71,147.72 26.32,148.11 PU600.14
  TOP w0.254: 26.88,147.66 27.29,147.25 27.29,147.05 27.44,146.9 27.45,146.9 PR659.1
ISUMN: length 44.6
  TOP w0.254: v3(130.05,145.21) 130.05,145.09 129.73,144.77 128.92,144.77 PC547.1
  IN1 w0.254: v3(130.05,145.21) 130.05,144.45 v3(134.75,139.75) 134,139 v3(130.57,139)
  BOTTOM w0.254: PC528.1 PR549.1 130.06,142.55 PR548.1 130.93,142.75 131.26,143.08 132.42,143.08 132.65,143.31 132.65,145.6 132.21,146.04 131.51,146.04 130.99,145.52 PR545.1 131,145.39 PR535.1 130.07,144.53 PC540.1 ; PC539.1 PC540.1 ; PC540.1 130.05,144.53 v3(130.05,145.21) ; PH501.1 137.23,124.46 137.23,137 v1(136.89,137.34) 136.89,138.8 135.93,139.75 v3(134.75,139.75) 134.75,139.13 PR544.2 ; v3(130.57,139) PR556.2
ISUMP: length 18
  TOP w0.254: v3(128.04,142.5) 127.75,142.5 PR558.1
  IN1 w0.254: v3(132.4,138.29) 130.49,138.29 129.61,139.18 129.61,141.14 128.25,142.5 v3(128.04,142.5)
  BOTTOM w0.203: v3(128.04,142.5) 127.85,142.69 PU500.15
  BOTTOM w0.254: PR536.1 PR552.1 v3(132.4,138.29) ; v3(128.04,142.5) 128.21,142.33 128.48,142.33 PC528.2 129.16,141.33 129.05,141.21 v1(129.05,140.68) 129.15,140.58 129.85,140.58 PR551.2 PR549.2 130.82,141.65 PC529.2 PC538.2
JTAG_CLK: length 40.8
  TOP w0.102: U51.B56 205.57,80.79 v3(205.73,80.95) ; JDEG2.4 238.58,74.17 v3(238.32,73.9) 237.85,73.43 237.47,73.43 237.17,73.14 RP11.3
  IN1 w0.102: v3(238.32,73.9) 237.81,73.4 237.25,73.4 234.86,75.79 229.47,75.79 227.34,77.91 223.87,77.91 222.12,79.65 214.76,79.65 214.34,79.24 212.04,79.24 211.85,79.43 210.83,79.43 210.38,79.88 207.88,79.88 206.96,80.8 206.96,81.03 206.59,81.4 205.96,81.4 205.73,81.16 v3(205.73,80.95)
JTAG_RST#: length 20.1
  TOP w0.102: RP16.2 195.4,77.52 197.21,79.33 v3(197.21,79.63) 197.7,80.13 197.7,81.35 197.36,81.69 197.36,82.93 R836.1 C735.1 197.85,85.46 197.83,85.49 JTAG1.1 ; U51.A57 203.31,78.54 v3(203.3,78.54)
  IN1 w0.102: v3(197.21,79.63) 198.01,78.83 201.37,78.83 202.03,78.17 202.93,78.17 v3(203.3,78.54)
JTAG_TDI: length 45.1
  TOP w0.102: JDEG2.2 238.6,73.17 v3(237.89,72.47) 237.36,71.94 236.68,71.94 RP11.1 ; v3(202.83,82.09) 203.38,81.54 U51.A51
  IN1 w0.102: v3(237.89,72.47) 237.45,72.91 231.66,72.91 227.73,76.84 223.59,76.84 223.11,76.36 222,76.36 221.11,77.24 215.16,77.24 214.37,78.03 212.03,78.03 211.79,78.28 207.85,78.28 207.11,79.02 207.11,79.97 206.61,80.47 205.03,80.47 203.97,81.52 203.14,81.52 202.83,81.83 v3(202.83,82.09)
JTAG_TDO: length 39
  TOP w0.102: RP11.4 236.78,73.64 237.11,73.97 v3(237.36,73.97) 237.62,73.97 v1(237.87,74.22) 237.95,74.22 238.4,74.67 JDEG2.5 ; U51.B55 205.32,81.29 205.49,81.46 205.9,81.46 v3(206.36,81.92)
  IN1 w0.102: v3(206.36,81.92) 206.75,81.92 207.49,81.18 211.29,81.18 212.34,80.14 222.32,80.14 223.34,79.12 226.81,79.12 228.57,77.36 233.97,77.36 v3(237.36,73.97)
JTAG_TMS: length 42.8
  TOP w0.102: JDEG2.3 238.77,73.67 238.06,72.95 237.75,72.95 v3(237.24,72.44) 237.04,72.64 RP11.2 ; v3(203.2,80.64) 203.3,80.54 U51.A53
  IN1 w0.102: v3(237.24,72.44) 237,72.68 231.56,72.68 227.64,76.61 223.69,76.61 223.2,76.13 220.52,76.13 219.86,76.78 214.34,76.78 213.93,77.19 212.55,77.19 211.7,78.05 207.76,78.05 206.88,78.92 206.88,79.87 206.51,80.24 203.6,80.24 v3(203.2,80.64)
KB_DET#: length 64.9
  TOP w0.102: RPH15.3 174.12,120.13 v3(174.32,119.93) ; v2(202.59,97.94) JKB1.1 202.59,102.25 202.11,102.73 v3(201.42,102.73)
  IN2 w0.089: 172.09,126.62 171.9,126.81 171.87,126.81 171.64,127.04 171.64,128.71 171.59,128.76 171.59,131.11 171.32,131.37 170.88,131.37 170.53,131.73 169.89,131.73 169.63,131.99 169.63,132.43 169.34,132.73 v3(169.24,132.73)
  IN2 w0.127: v3(174.32,119.93) 174.32,120.84 173.99,121.16 173.99,122.84 174.03,122.88 174.03,123.92 172.92,125.02 172.92,125.78 172.09,126.62
  IN3 w0.127: v3(198.38,115.75) 198.27,115.65 187.78,115.65 185.81,117.62 181.55,117.62 180.72,118.44 174.63,118.44 173.93,119.15 173.93,119.54 v3(174.32,119.93)
  BOTTOM w0.089: UH1.U12 169.01,132.96 v3(169.24,132.73)
  BOTTOM w0.102: v3(198.38,115.75) 198.27,115.65 198.27,104.11 199.65,102.73 v3(201.42,102.73)
LAN_ACTLED_YEL#: length 3.9
  TOP w0.102: Q325.1 257.07,177.54 v1(256.48,177.54) 256.1,177.54 255.49,176.93 254.45,176.93 254.26,177.12 U32.17
LAN_ACTLED_YEL#_Q: length 43.9
  TOP w0.102: Q325.6 259.69,177.17 259.81,177.28 259.81,181.41 v1(259.59,181.63) 259.44,181.78 v3(258.59,181.78)
  BOTTOM w0.102: R1166.1 243.46,203.52 243.46,183.63 243.71,183.38 245.49,183.38 245.8,183.07 245.8,181.74 246.57,180.97 255.23,180.97 256.04,181.78 v3(258.59,181.78)
LAN_DISABLE#_R: length 151.8
  TOP w0.102: R549.2 R557.1 R555.2 244.82,161.85 v3(244.44,162.24) 244.19,162.48 U31.3 ; v3(181.99,65.77) 181.96,65.81 U46.B47
  IN2 w0.127: v3(201.35,143.73) 203.14,141.93 203.14,122.85 201.89,121.6 201.89,120.17 202.16,119.9 202.16,117.12 201.13,116.09 201.13,108.96 201.87,108.22 201.87,100.34 202.19,100.03 202.19,96.85 196.88,91.55 196.88,84.59 195.18,82.89 195.18,79.85 195.67,79.36 195.67,76.89 195.12,76.34 195.12,70.23 194.12,69.23 191.23,69.23 190.17,68.18 187.85,68.18 187.8,68.23 186.96,68.23 186.12,67.39 183.84,67.39 182.7,66.24 182.45,66.24 181.99,65.78 v3(181.99,65.77)
  IN3 w0.127: v3(244.44,162.24) 244.44,159.93 242.87,158.36 239.32,158.36 237.87,156.9 224.06,156.9 216.38,149.22 207.29,149.22 206.82,148.75 206.82,148.02 202.53,143.73 v3(201.35,143.73)
  BOTTOM w0.102: v3(181.99,65.77) v1(181.43,65.77)
LAN_SMBCLK: length 120.7
  TOP w0.102: RH174.2 169.04,113.28 169.37,113.6 169.37,113.86 169.83,114.32 169.83,114.93 169.74,115.01 169.46,115.01 v3(169.3,114.86) ; R551.1 234.49,165.78 233.81,165.09 233.81,164.46 233.55,164.2 233.05,164.2 232.7,164.54 232.7,165.95 232.28,166.37 221.86,166.37 219.9,164.41 219.9,161.37 220.14,161.13 220.14,158.82 219.89,158.56 219.89,152.32 218.66,151.09 218.66,143.13 219.1,142.69 219.1,140.19 v3(218.91,140)
  IN1 w0.089: 179.38,132.57 179.36,132.57 179.35,132.56 179.28,132.56 179.28,132.55 179.02,132.55 178.56,132.1 177.32,132.1 177.13,132.28 171.93,132.28 171.27,131.63 170.87,131.63 170.78,131.71 169.96,131.71 169.61,131.36 169.61,131.01 v3(169.24,130.64)
  IN1 w0.102: 179.38,132.57 180.7,132.57 182.08,133.94 189.18,133.94 189.92,134.69 197.36,134.69 199.98,137.3 216.87,137.3 219.09,139.52 219.09,139.82 v3(218.91,140)
  IN4 w0.089: 170.67,126.62 170.67,126.63 170.68,126.64 170.68,127.21 169.04,128.84 169.04,129.36 169.61,129.93 169.61,130.38 169.35,130.64 v3(169.24,130.64)
  IN4 w0.102: v3(169.3,114.86) 169.14,115.03 168.91,115.03 168.62,115.32 168.62,115.72 170.98,118.08 170.98,119.27 171.77,120.06 171.77,121.74 171.35,122.15 171.35,124.04 170.44,124.95 170.44,125.48 170.67,125.71 170.67,126.62
  BOTTOM w0.089: UH1.U8 168.76,131.16 168.76,131.12 v3(169.24,130.64)
LAN_SMBCLK_R: length 2.2
  TOP w0.102: U31.28 236.36,164.88 235.46,165.79 R551.2
LAN_SMBDATA: length 119.5
  TOP w0.102: R552.1 233.36,163.57 232.48,164.45 232.48,165.86 232.19,166.14 221.96,166.14 220.13,164.32 220.13,161.46 220.37,161.22 220.37,158.72 220.12,158.47 220.12,152.23 218.89,151 218.89,143.23 219.33,142.78 219.33,140.16 v3(219.5,140) ; v3(169.3,115.45) 169.51,115.24 169.83,115.24 170.05,115.02 170.05,114.23 169.6,113.77 169.6,113.61 RH175.2
  IN1 w0.089: v3(170.23,130.33) 169.83,130.73 169.83,131.27 170.05,131.5 170.69,131.5 170.78,131.41 171.36,131.41 172,132.04 177.07,132.04 177.23,131.88 178.65,131.88 179.11,132.34 179.38,132.34
  IN1 w0.102: 179.38,132.34 180.8,132.34 182.17,133.71 189.27,133.71 190.02,134.46 197.45,134.46 200.07,137.07 216.96,137.07 219.32,139.43 219.32,139.82 v3(219.5,140)
  IN4 w0.089: 170.9,126.62 170.9,126.63 170.89,126.64 170.89,127.29 169.25,128.93 169.25,129.27 169.83,129.84 169.83,130.29 169.86,130.33 v3(170.23,130.33)
  IN4 w0.102: v3(169.3,115.45) 169.11,115.26 169,115.26 168.85,115.41 168.85,115.62 171.21,117.99 171.21,119.18 172,119.97 172,121.83 171.58,122.25 171.58,124.13 170.67,125.05 170.67,125.38 170.9,125.62 170.9,126.62
  BOTTOM w0.089: UH1.R7 169.97,130.33 v3(170.23,130.33)
LAN_SMBDATA_R: length 1.9
  TOP w0.102: U31.31 235.53,163.68 R552.2
LAN_TEST_EN: length 2.4
  TOP w0.102: U31.30 236.64,164.08 236.56,164.01 236.04,164.01 235.41,164.65 R561.1
LAN_TX0+: length 17.2
  TOP w0.089: R3770.1 254.48,172.75 254.48,171.7 253.42,170.64 249.87,170.64 248.93,169.7 v4(248.41,169.7) 243.22,169.7 242.7,169.19 242.7,167.64 242.42,167.35 U31.13
LAN_TX0+R: length 5
  TOP w0.089: R3770.2 254.46,175.37 254.46,175.48 254.2,175.73 v4(253.67,175.73) 252.57,175.73 252.12,176.18 251.69,176.61 251.69,176.77 251.76,176.84 U32.12
LAN_TX0-: length 17.2
  TOP w0.089: U31.14 242.02,167.37 242.41,167.76 242.41,169.31 243.1,170 248.81,170 249.75,170.93 v4(252.35,170.93) 253.3,170.93 254.19,171.82 254.19,172.78 R3769.1
LAN_TX0-R: length 5
  TOP w0.089: R3769.2 254.17,175.29 254.17,175.36 254.08,175.44 252.45,175.44 v4(252,175.88) 251.4,176.49 251.4,176.65 251.26,176.79 U32.11
LAN_TX1+: length 15.9
  TOP w0.089: R3768.1 251.59,172.78 251.59,172.2 251.04,171.66 249.55,171.66 248.46,170.57 v4(243.59,170.57) 242.06,170.57 241.01,169.52 241.01,168.25 240.77,168.01 240.77,167.61 240.82,167.56 U31.17
LAN_TX1+R: length 3.3
  TOP w0.089: R3768.2 251.64,175.27 251.53,175.38 251.53,175.54 250.84,176.22 250.65,176.41 250.65,176.63 250.76,176.73 U32.10
LAN_TX1-: length 15.9
  TOP w0.089: U31.18 240.42,167.56 240.48,167.61 240.48,168.13 240.72,168.37 240.72,169.64 241.94,170.86 248.34,170.86 249.43,171.95 v4(249.81,171.95) 250.92,171.95 251.3,172.32 251.3,172.75 R3767.1
LAN_TX1-R: length 3.3
  TOP w0.089: U32.9 250.26,176.73 250.36,176.63 250.36,176.29 v4(250.64,176.01) 251.23,175.42 251.23,175.28 R3767.2
LAN_TX2+: length 14.3
  TOP w0.089: U31.20 239.62,167.56 239.57,167.61 239.57,168.06 239.98,168.47 239.98,169.9 241.52,171.43 v4(247.65,171.43) 247.93,171.43 248.6,172.11 248.6,172.71 R3766.1
LAN_TX2+R: length 3.2
  TOP w0.089: R3766.2 248.64,175.34 248.64,175.82 v4(248.83,176.01) 249.15,176.33 249.15,176.63 249.26,176.73 U32.7
LAN_TX2-: length 14.2
  TOP w0.089: U31.21 239.22,167.56 239.28,167.61 239.28,168.18 239.69,168.59 239.69,170.02 241.39,171.72 v4(245.49,171.72) 247.81,171.72 248.31,172.23 248.31,172.82 R3765.1
LAN_TX2-R: length 3.1
  TOP w0.089: R3765.2 248.35,175.32 248.35,175.94 248.86,176.45 248.86,176.63 248.76,176.73 U32.6
LAN_TX3+: length 12.4
  TOP w0.089: U31.23 238.42,167.56 238.37,167.61 238.37,168.9 238.57,169.1 238.57,169.92 240.95,172.3 v4(241.37,172.3) 245.45,172.3 245.68,172.53 245.68,172.71 R3764.1
LAN_TX3+R: length 3.8
  TOP w0.089: U32.3 247.26,176.73 247.15,176.63 247.15,176.3 v4(246.81,175.96) 246.44,175.59 245.93,175.59 245.75,175.41 245.75,175.32 R3764.2
LAN_TX3-: length 12.4
  TOP w0.089: R3763.1 245.39,172.82 245.39,172.65 245.32,172.59 v4(243.33,172.59) 240.83,172.59 238.28,170.04 238.28,169.22 238.08,169.02 238.08,167.61 238.02,167.56 U31.24
LAN_TX3-R: length 3.8
  TOP w0.089: U32.2 246.76,176.73 246.86,176.63 246.86,176.43 246.32,175.89 245.81,175.89 245.45,175.53 245.45,175.34 R3763.2
LANCLK_REQ#: length 139.3
  TOP w0.102: v3(200.34,119.24) 200.92,118.66 RPH18.3 ; v3(244.12,154.77) 244.78,155.44 244.87,155.44 R1187.1
  IN2 w0.127: v3(200.34,119.24) 199.78,119.8 199.78,126.06 201.74,128.02 201.74,137.96 202.45,138.66 v3(202.45,139.63)
  IN3 w0.127: v3(244.12,154.77) 239.52,154.77 238.93,154.18 233.35,154.18 230.88,151.72 230.88,148.2 224.23,141.55 219.7,141.55 219.37,141.21 207.37,141.21 206.23,140.07 202.89,140.07 v3(202.45,139.63) ; v3(165.83,124.76) 166.84,124.76 167.03,124.57 169.22,124.57 170.19,123.6 173.92,123.6 174.45,123.08 176.03,123.08 176.44,123.49 176.84,123.49 177.32,123.01 177.32,122.29 178.55,121.06 185.6,121.06 187.37,119.29 200.3,119.29 v3(200.34,119.24)
  BOTTOM w0.089: UH1.AF1 165.27,127.89 165.04,127.65 165.04,127.22
  BOTTOM w0.102: v3(200.34,119.24) v1(199.77,118.67) 199.2,118.1 199.2,115.38 198.5,114.68 198.5,104.21 199.48,103.23 201.7,103.23 RH20.1 ; 165.04,127.22 165.04,125.92 165.37,125.59 165.37,125.22 v3(165.83,124.76)
LANCLK_REQ#_R: length 7.1
  TOP w0.102: R1187.2 243.91,156.52 v1(243.73,156.7) 243.73,158.89 244.04,159.21 244.04,160.01 243.73,160.33 242.51,160.33 242.42,160.41 U31.48
LANWAKE#: length 156.4
  TOP w0.102: U31.2 243.86,162.08 244.6,161.34 244.6,159.62 R558.2 245.04,158.66 245.4,158.3 R566.1 246.89,158.3 247.65,157.53 247.65,156.35 v1(247.44,156.14) 246.67,155.37 245.62,155.37 v3(245.05,154.8) ; U51.B27 213.42,79.29 213.01,79.7 v3(213.01,79.72)
  IN2 w0.127: v3(207.77,132.64) 207.61,132.48 207.61,128.66 209.08,127.18 209.08,124.08 209.72,123.45 209.72,122.03 214.28,117.47 216.11,117.47 218.84,114.74 218.84,110.71 217.77,109.65 217.77,103.84 215.95,102.02 215.95,84.81 214.66,83.52 214.66,79.82 213.97,79.13 213.35,79.13 213.01,79.47 v3(213.01,79.72)
  IN3 w0.127: v3(245.05,154.8) 245.05,154.35 244.93,154.23 239.69,154.23 238.51,153.05 238.51,148.81 239.51,147.81 239.51,138.8 238.63,137.91 236.82,137.91 233.9,134.99 218.12,134.99 217.21,134.08 209.21,134.08 v3(207.77,132.64)
  BOTTOM w0.102: RH196.2 189.85,134.71 193.45,131.12 206.25,131.12 v3(207.77,132.64)
LAT_ON_SW#: length 20.2
  TOP w0.102: RP15.4 199.71,65.95 199.9,65.76 203.13,65.76 v1(205.34,67.98) 205.94,68.58 205.94,71.4 205.69,71.66 v3(205.5,71.66) ; v3(206.32,77.78) 206.32,77.62 205.99,77.29 U51.B63
  IN2 w0.127: v3(206.32,77.78) 207.65,76.45 207.65,74.63 206.11,73.09 206.11,72.27 v3(205.5,71.66)
LCD_CBL_DET#: length 71.6
  TOP w0.089: v3(173.14,134.61) 173.14,134.78 173.31,134.95 173.53,134.95 173.58,134.99 175.2,134.99 175.96,134.23 177.06,134.23 177.5,134.66 179.17,134.66 179.38,134.87
  TOP w0.102: RPH6.1 180,136.12 179.64,135.77 179.64,135.13 179.38,134.87
  IN3 w0.127: v3(173.14,134.61) 175.82,137.29 175.82,138.88 176.83,139.89 182.28,139.89 182.72,140.34 188.86,140.34 190.62,138.58 v3(192.64,138.58)
  BOTTOM w0.089: UH1.G17 173.14,134.96 v3(173.14,134.61)
  BOTTOM w0.102: JLVDS1.40 202.04,167.92 203.66,166.3 203.66,161.65 201.17,159.16 201.17,156.78 199.77,155.38 199.77,150.17 198.28,148.68 198.28,141.06 197.52,140.3 194.32,140.3 v1(193.18,139.17) 192.64,138.62 v3(192.64,138.58)
LCD_EDID_CLK: length 10.9
  TOP w0.102: v3(204.02,171.03) 204.24,170.81 204.24,170.65 203.3,169.7 201.53,169.7 200.08,168.25 200.08,166.66 200.02,166.6 U27.46
  BOTTOM w0.102: JLVDS1.35 204.54,170.51 v3(204.02,171.03) 203.99,171.06 203.99,171.68 R160.2
LCD_EDID_DATA: length 10.7
  TOP w0.102: v3(204.6,171.03) 204.47,170.9 204.47,170.55 203.39,169.47 v4(202.44,169.47) 201.63,169.47 200.31,168.16 200.31,166.68 200.42,166.57 U27.45
  BOTTOM w0.102: JLVDS1.34 205.04,170.59 v3(204.6,171.03) 204.6,171.04 204.6,171.9 R159.2
LCD_ENVDD_CVT: length 28.2
  TOP w0.102: U27.20 202.02,159.41 v3(202.31,159.12) ; v3(189.07,159.37) 188.96,159.47 v1(188.96,169.85) 188.96,170.21 189.52,170.77 D7.2
  IN3 w0.127: v3(189.07,159.37) 189.27,159.17 200.98,159.17 201.49,158.65 201.85,158.65 v3(202.31,159.12)
LCD_SMBCLK: length 13.8
  TOP w0.102: v3(208.12,75.46) 208.09,75.46 207.68,75.04 U51.B5 ; v3(206.31,66.74) 206.31,67.1 R418.2
  IN4 w0.102: v3(208.12,75.46) 206.85,75.46 206.72,75.33 205.75,75.33 205.51,75.09 205.51,73.57 206.02,73.05 206.02,68.23 206.31,67.94 v3(206.31,66.74)
LCD_SMBDAT: length 2.7
  TOP w0.102: U51.A4 207.43,72.92 207.33,72.82 v1(207.33,71.94) 207.33,71.18 R420.2
LCD_TST: length 138
  TOP w0.102: RP19.4 172.11,64.52 177.92,70.32 177.92,71.3 178.39,71.77 v3(179.01,71.77) 178.68,71.44 178.68,70.34 178.96,70.06 U46.A36
  IN2 w0.127: v3(193.23,138.6) 193.39,138.43 193.39,133.53 191.17,131.31 191.17,121.29 190.4,120.52 190.4,104.4 190.6,104.19 190.6,96.4 187.78,93.57 187.78,87.07 187.22,86.52 187.22,80.85 186.12,79.75 184.83,79.75 180.22,75.14 180.22,72.39 179.6,71.77 v3(179.01,71.77)
  BOTTOM w0.102: JLVDS1.36 204.04,170.07 204.04,169.34 204.99,168.39 208.54,168.39 209.3,167.63 209.3,162.74 208.66,162.11 204.79,162.11 202.72,160.04 202.72,158 200.03,155.31 200.03,150.09 198.51,148.57 198.51,140.93 197.55,139.97 v1(195.96,139.97) 194.59,139.97 193.21,138.6 193.21,138.6 v3(193.23,138.6)
LCD_VCC_TEST_EN: length 118.8
  TOP w0.102: D7.3 191.77,170.06 191.77,169.47 190.34,168.04 190.34,160.29 191.07,159.56 v1(191.07,159.31) 191.07,141.9 194.41,138.57 194.41,125.19 191.49,122.28 188.47,122.28 183.17,116.97 183.17,113.96 181.33,112.12 v3(180.28,112.12) ; U46.A40 179.77,68.06 v3(179.69,68.14)
  IN2 w0.127: v3(179.69,68.14) 179.69,68.27 179.36,68.6 178.86,68.6 178.64,68.81 178.64,69.45 178.08,70.02 178.08,72.43 176.94,73.57 176.94,77.03 181.53,81.62 181.53,89.79 182.49,90.74 182.49,94.5 182.49,94.5 182.49,96.42 182.49,96.43 182.49,104.91 182.23,105.17 182.23,110.16 v3(180.28,112.12)
LED_10_GRN#: length 19.3
  TOP w0.102: Q326.3 259.03,178.73 257.65,180.11 v3(257.65,180.55) 257.65,180.57 256.82,181.4 v1(256.45,181.4) ; v3(244.86,178.55) 245.18,178.87 U32.41
  IN2 w0.102: v3(257.65,180.55) 255.94,180.55 253.43,178.04 245.37,178.04 v3(244.86,178.55)
LED_10_GRN#_Q: length 26.4
  TOP w0.102: Q326.1 v3(258.38,181.19) 258.35,181.19 257.95,181.59 v1(257.95,182.27) ; v3(258.56,203.71) 258.9,203.37 R1653.1
  IN2 w0.127: v3(258.56,203.71) 259.18,203.09 259.18,181.42 258.95,181.19 v3(258.38,181.19)
LED_100_ORG#: length 8.6
  TOP w0.102: v3(256.35,178.04) 255.53,178.04 255.2,178.37 U32.18 ; Q325.4 v1(260.58,175.87) 260.72,176.01 260.72,176.27 v3(260.4,176.58)
  IN3 w0.127: v3(260.4,176.58) 257.81,176.58 v3(256.35,178.04)
LED_100_ORG#_Q: length 35.2
  TOP w0.102: v3(264.64,199.77) 264.64,201.16 v1(263.58,202.22) 262.43,203.37 R1167.1 ; v3(258.73,175.26) 258.12,175.87 Q325.3
  IN2 w0.127: v3(264.64,199.77) 264.64,194.66 262.78,192.79 262.78,180.79 258.88,176.89 258.88,175.42 v3(258.73,175.26)
LED_SATA_DIAG_OUT#: length 78.6
  TOP w0.102: U46.A10 192,68.56 v3(192.09,68.65) ; v3(230.14,104.77) 229.49,104.12 v1(229.24,104.12) 225.2,104.12 223.96,105.35 D62.1
  IN3 w0.127: v3(230.14,104.77) 229.72,104.35 229.72,90.01 228.18,88.47 228.18,79.01 219.78,70.6 219.78,69.93 219.22,69.37 216.43,69.37 214.38,67.33 208.12,67.33 207.52,67.92 198.78,67.92 197.75,68.95 193.75,68.95 193.62,69.08 192.52,69.08 v3(192.09,68.65)
LED_WWAN_OUT#: length 18.5
  TOP w0.102: v3(278.93,181.98) v1(278.21,181.26) Q77.3 278.21,177.74 277.5,177.03 R719.1
  BOTTOM w0.102: v3(278.93,181.98) 278.89,182.02 278.89,186.93 277.56,188.27 JMINI1.42
LG_3V: length 6.4
  TOP w1.016: 205.68,34.41 v1(201.75,34.41) 201.6,34.41 200.98,35.03 200.98,36.5
LG_5V: length 5.1
  TOP w1.016: 203.39,43.36 203.39,41.52 202.63,40.76 201.36,40.76 200.73,40.12
  vias: v1(200.98,39.42)
LG_+1.05VSP: length 11.7
  TOP w0.102: v1(166.3,103.39) 164.96,102.06 v3(164.96,100.07)
  IN2 w1.016: 173.48,97.65 171.96,97.65 169.99,99.62 166.44,99.62
  vias: v3(165.55,100.07) v3(174.42,97.21) v3(175.01,97.21)
LGATE1: length 8.4
  TOP w0.102: v3(124.75,140.83) v2(124.17,140.83)
  IN2 w1.016: 124.59,138.99 124.59,138.42 127.57,135.44 127.57,132.45
  vias: v3(124.75,140.25) v3(127.31,131.24) v3(127.89,131.24)
LGATE1_VGA: length 8.3
  IN1 w1.016: 22.99,160.96 24.26,159.69 24.26,154.04
  BOTTOM w0.102: v3(23.26,161.92) 23.26,162.47 v1(23.05,162.68)
  vias: v3(22.67,161.92) v3(24.2,152.72) v3(24.2,152.14)
LGATE2: length 8.7
  TOP w0.102: v2(121.93,141.01) 122.09,141.16 v3(123.26,141.16)
  IN4 w1.016: 123.06,138.99 123.06,131.63
  vias: v3(123.26,140.58) v3(123.28,130.5) v3(123.28,129.91)
LGATE2_VGA: length 17.9
  IN2 w1.016: 22.8,154.23 20.77,156.26 18.37,156.26 15.89,158.74 14.35,158.74 13.34,159.76 13.34,161.53 12.32,162.55 10.1,162.55
  BOTTOM w0.102: v3(9.08,162.99) 9.08,163.31 v1(9.34,163.57)
  vias: v3(8.5,162.99) v3(23.05,152.72) v3(23.05,152.14)
LID_CL#: length 123.5
  TOP w0.102: v3(243.4,112.95) 242.65,112.2 JSF1.2 228.13,112.2 227.92,112.41 U58.2 ; R807.1 v3(181.93,57.78) 181.93,57.53 v2(181.6,57.2)
  IN3 w0.127: v3(243.4,112.95) 243.4,111.06 233.59,101.25 233.59,86.53 234.5,85.62 234.5,84.45 234.19,84.13 234.19,81.97 235.33,80.83 235.33,73.95 230.82,69.44 230.82,68.04 226.03,63.25 218.08,63.25 216.99,62.16 185.34,62.16 184.8,61.61 184.8,60.64 v3(181.93,57.78)
LID_CL_SIO#: length 22.1
  TOP w0.102: v3(182.76,60.49) 182.82,60.43 C716.1 R807.2 ; v3(182.5,63.93) 182.5,63.81 182.87,63.44 U46.B54 ; v3(177.48,62.77) 177.23,63.02 RP19.1
  IN4 w0.102: v3(182.5,63.93) 182.75,63.68 182.75,62.8 183.26,62.29 183.26,61 v3(182.76,60.49)
  BOTTOM w0.102: v3(177.48,62.77) v1(179.19,61.06) 179.76,60.49 v3(182.76,60.49)
LOM_ACTLED_YEL#: length 30.7
  TOP w0.102: v3(234.19,169.67) 234.19,169.04 v1(235.48,167.74) 236.12,167.11 236.12,166.27 236.22,166.17 236.53,165.86 236.7,165.68 U31.26 ; v3(254.53,176.23) 254.31,176.46 253.68,176.46 253.26,176.89 U32.15
  IN2 w0.127: v3(254.53,176.23) 253.44,175.14 242.79,175.14 238.11,170.46 234.97,170.46 v3(234.19,169.67)
LOM_SPD10LED_GRN#: length 36.9
  TOP w0.102: v3(234.81,169.67) 234.81,169 236.35,167.46 236.35,166.36 236.62,166.08 U31.25 ; v3(255.74,176.29) 255.74,175.86 256.41,175.19 256.41,174.4 v1(256.55,174.26) 256.83,173.98 U15.2 ; v3(243.65,174.59) 243.65,176.71 245.31,178.37 U32.42
  IN2 w0.127: v3(255.74,176.29) 254.04,174.59 v3(243.65,174.59) 242.6,174.59 238.21,170.2 235.34,170.2 v3(234.81,169.67)
LOM_SPD100LED_ORG#: length 36
  TOP w0.102: U32.16 253.76,177.02 254.08,176.7 v3(256.21,176.7) 256.43,176.48 v1(256.43,175.87) 256.85,175.45 256.85,174.81 257.02,174.63 U15.1 ; U31.27 236.73,165.28 234.25,167.76 v3(234.25,168.2)
  IN2 w0.127: v3(256.21,176.7) 256.21,176.17 254.21,174.17 242.54,174.17 236.57,168.2 v3(234.25,168.2)
LPC_LAD0: length 244.9
  TOP w0.102: U46.A27 184.62,73.88 v3(184.46,74.03) ; U39.26 215.91,108.2 216.71,109.01 218.48,109.01 220.79,111.31 v3(220.79,111.31) 220.79,112.4 218.82,114.37 218.82,114.95 v1(217.35,116.43) 214.76,119.01 213.02,119.01 210.61,121.43 210.61,122.51 201.55,131.57 201.55,135.65 v3(202.2,136.3) ; U51.A30 215.73,81.54 215.9,81.71 v3(215.9,81.91)
  IN2 w0.127: v3(220.79,111.31) 220.74,111.31 220.31,110.89 220.31,110.39 219.04,109.12 219.04,103.32 217.24,101.51 217.24,82.95 216.63,82.35 216.35,82.35 v3(215.9,81.91)
  IN3 w0.127: v3(202.2,136.3) 201.06,137.44 183.59,137.44 182.55,136.4 179.54,136.4 v3(179.39,136.55) ; v3(263.98,165.99) 263.56,165.57 262.49,165.57 261.86,164.95 261.86,161.34 257.92,157.4 252.3,157.4 251.94,157.05 251.94,156.09 250.37,154.52 250.37,153.16 250.67,152.86 250.67,151 249.95,150.27 249.95,146.52 247.68,144.26 247.68,141.44 239.32,133.08 239.32,131.48 238.61,130.77 238.61,124.29 232.99,118.67 229.93,118.67 227.37,116.11 222.84,116.11 221.24,114.5 221.24,111.76 v3(220.79,111.31) ; v3(215.9,81.91) 214.25,83.56 205.64,83.56 204.69,82.61 204.69,82.27 203.79,81.37 202.31,81.37 200.92,79.97 200.92,79.17 198.48,76.74 195.54,76.74 195.16,76.36 186.67,76.36 186.27,75.96 185.51,75.96 185.05,75.5 185.05,74.61 v3(184.46,74.03)
  BOTTOM w0.089: 177.22,136.2 177.1,136.2 177,136.3 176.02,136.3 175.86,136.13 UH1.A20
  BOTTOM w0.102: JMINI3.16 276.57,179.75 276.54,179.72 275.7,179.72 274.99,180.42 271.16,180.42 269.5,178.76 269.48,178.74 269.48,176.44 268.7,175.65 268.7,172.41 264.38,168.09 264.38,166.4 v3(263.98,165.99) ; v3(179.39,136.55) 179.03,136.2 177.22,136.2
LPC_LAD1: length 246.8
  TOP w0.102: v3(185.96,74.73) 185.96,74.73 185.12,73.88 U46.A26 ; U51.B32 213.72,81.79 v3(213.62,81.89) ; v1(219.14,111.18) 218.35,111.18 v3(218.16,110.99) 216.96,109.78 215.2,109.78 213.94,108.52 213.94,108.17 213.96,108.15 U39.23
  IN2 w0.127: 218.12,110.99 v3(218.16,110.99) ; 218.12,110.99 217.2,110.07 217.2,103.99 215.24,102.03 215.24,89.22 214.83,88.82 214.83,87.49 213.92,86.57 213.92,83.7 214.03,83.58 214.03,82.29 213.64,81.89 v3(213.62,81.89) ; 218.12,110.99 217.68,111.43 217.68,112.94 217.17,113.44 217.17,115.69 215.9,116.96 214.07,116.96 209.21,121.82 209.21,123.24 208.57,123.87 208.57,126.97 207.1,128.45 207.1,134.66 v3(206.83,134.93)
  IN3 w0.127: v3(206.83,134.93) 206.41,135.35 200.9,135.35 199.06,137.19 183.7,137.19 182.64,136.13 178.53,136.13 v3(178.19,135.79) ; v3(185.96,74.73) 186.5,75.27 186.5,75.83 186.77,76.1 195.26,76.1 195.64,76.48 198.59,76.48 201.17,79.06 201.17,79.87 202.42,81.12 203.9,81.12 204.95,82.17 204.95,82.51 205.74,83.3 212.28,83.3 212.6,82.99 212.6,81.98 212.6,81.97 212.92,81.65 213.37,81.65 v3(213.62,81.89) ; v3(218.16,110.99) 218.17,110.99 218.58,111.4 218.58,113.41 222.39,117.21 226.91,117.21 229.38,119.69 232.5,119.69 237.54,124.73 237.54,132.88 242.29,137.63 242.29,141.6 243.23,142.55 243.23,150.07 245.55,152.39 246.68,152.39 250.93,156.64 250.93,159.03 253.81,161.91 253.81,164.64 255.28,166.11 259.8,166.11 260.94,167.25 263.3,167.25 v3(263.98,166.58)
  BOTTOM w0.089: UH1.C20 174.94,136.09 175.38,136.09 175.67,135.8 175.91,135.8 176.12,136.02 176.97,136.02 176.97,136.01 177.04,136.01 177.14,135.91 177.22,135.91
  BOTTOM w0.102: 177.22,135.91 178.08,135.91 v3(178.19,135.79) ; v3(263.98,166.58) 263.98,168.12 268.47,172.61 268.47,175.75 269.24,176.52 269.24,178.87 271.02,180.65 276.5,180.65 276.59,180.55 JMINI3.14
LPC_LAD2: length 247.6
  TOP w0.102: U39.20 212.01,109.38 213.19,110.56 216.2,110.56 217.63,111.99 220.02,111.99 v3(220.09,112.07) 220.09,112.64 218.49,114.24 218.49,114.81 214.63,118.67 v1(213.35,118.67) 213.04,118.67 210.38,121.34 210.38,122.42 201.14,131.65 v3(201.14,134.17) ; v3(216.49,82.79) 216.03,82.34 215.76,82.34 215.46,82.04 U51.A31 ; U46.B26 185.87,72.13 185.96,72.03 185.96,71.56 v3(186.36,71.16)
  IN2 w0.127: v3(220.09,112.07) 219.85,111.83 219.85,110.29 218.79,109.22 218.79,103.42 216.98,101.61 216.98,83.29 v3(216.49,82.79)
  IN3 w0.127: v3(216.49,82.79) 217.07,82.79 217.53,82.33 217.53,81.69 216.81,80.98 215.04,80.98 214.25,80.19 212.87,80.19 212.23,79.56 207.52,79.56 206.82,80.25 205.36,80.25 204.52,79.42 204.52,78.61 203.89,77.97 202.61,77.97 199.82,75.17 198.36,75.17 197.42,74.24 197.42,74.04 196.49,73.11 190.57,73.11 190.18,72.72 187.61,72.72 186.88,72 186.88,71.55 186.48,71.16 v3(186.36,71.16) ; v3(220.09,112.07) 220.82,112.79 220.82,114.44 222.73,116.36 227.26,116.36 229.83,118.93 232.88,118.93 238.36,124.4 238.36,130.88 239.07,131.59 239.07,133.18 247.43,141.55 247.43,144.36 249.65,146.58 249.65,154.15 251.69,156.2 251.69,157.15 252.19,157.66 257.81,157.66 261.61,161.45 261.61,165.58 262.02,165.99 v3(263.16,165.99) ; v3(201.14,134.17) 198.63,136.68 183.96,136.68 182.86,135.58 182.65,135.58 182.65,135.58 180.3,135.58 179.58,134.85 177.64,134.85 v3(177.27,135.22)
  BOTTOM w0.089: UH1.A18 175.92,135.32 176.26,135.65 176.44,135.65 176.61,135.49 176.99,135.49 177.22,135.25
  BOTTOM w0.102: v3(177.27,135.22) 177.25,135.24 177.23,135.24 177.22,135.25 ; v3(263.16,165.99) 263.57,166.4 263.57,168.21 268.24,172.87 268.24,175.84 269.01,176.62 269.01,179.01 270.88,180.88 275.77,180.88 276.24,181.35 JMINI3.12
LPC_LAD3: length 247.7
  TOP w0.102: v3(263.16,166.58) 263.16,167.09 v1(263.06,167.2) ; v3(215.77,111.05) 215.69,110.96 212.75,110.96 210.06,108.27 U39.17 ; U51.B33 213.81,82.29 v3(213.62,82.49) ; v3(186.46,71.74) 186.37,71.84 U46.B25
  IN2 w0.127: v3(213.62,82.49) 213.62,82.79 212.51,83.9 212.51,86.22 213.69,87.4 213.69,89.52 214.15,89.97 214.15,95.78 214.54,96.17 214.54,107.6 215.81,108.86 215.81,111.02 v3(215.77,111.05) 215.77,111.12 214.12,112.77 214.12,116.55 208.95,121.72 208.95,123.13 208.32,123.77 208.32,126.87 206.85,128.34 206.85,134.05 206.24,134.66 v3(206.24,134.93)
  IN3 w0.127: v3(177.85,135.31) 178.42,135.31 178.93,135.83 182.75,135.83 183.86,136.93 198.95,136.93 200.96,134.93 v3(206.24,134.93) ; v3(186.46,71.74) 186.46,72.4 187.03,72.98 190.08,72.98 191.89,74.79 196.12,74.79 196.29,74.63 197.45,74.63 198.25,75.43 199.66,75.43 201.73,77.5 201.73,79.29 202.35,79.91 204.66,79.91 205.26,80.51 207.08,80.51 207.71,81.14 213.62,81.14 214.12,81.65 214.12,82.1 213.73,82.49 v3(213.62,82.49) ; v3(263.16,166.58) 262.74,167 261.05,167 259.91,165.85 255.38,165.85 254.07,164.53 254.07,161.8 251.18,158.92 251.18,156.53 248.39,153.74 248.39,152.66 249.14,151.91 249.14,146.79 246.92,144.57 246.92,141.9 237.85,132.82 237.85,124.67 232.61,119.43 229.49,119.43 227.02,116.96 222.49,116.96 218.84,113.3 218.84,111 218.4,110.57 216.26,110.57 v3(215.77,111.05)
  BOTTOM w0.089: 177.22,135.63 177.17,135.68 177.13,135.68 177.08,135.73 177.07,135.73 177.05,135.75 176.66,135.75 176.57,135.84 176.19,135.84 175.98,135.63 175.67,135.63 175.36,135.32 174.9,135.32 UH1.C18
  BOTTOM w0.102: JMINI3.10 276.26,182.15 275.35,181.24 275.22,181.1 270.74,181.1 268.78,179.15 268.78,176.71 268.01,175.94 268.01,173.13 263.16,168.28 v3(263.16,166.58) ; v3(177.85,135.31) 177.54,135.63 177.22,135.63
