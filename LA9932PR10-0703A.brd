# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDBIA1_0: length 19.2
  BOTTOM w0.089: UV6.D2 69.03,107.22 69.03,107.75 69.4,108.13 69.92,108.13 70.01,108.23 ; UV1.C15 69.88,123.9 69.88,123.27 69.98,123.17 69.98,122.15 70.38,121.75
  BOTTOM w0.13: 70.38,121.75 70.38,119.86 71,119.23 71,117.71 70.19,116.9 v1(70.19,112.32) 70.19,108.41 70.01,108.23
DDBIA1_1: length 24.6
  TOP w0.089: UV3.P13 v3(59.46,107.26)
  IN1 w0.127: v3(66.83,119.73) 66.47,119.37 66.47,115.21 65.1,113.84 65.1,112.47 63.12,110.49 63.12,108.71 62.87,108.45 59.3,108.45 59.29,108.45 59.25,108.45 58.93,108.13 58.93,107.79 v3(59.46,107.26)
  BOTTOM w0.089: 65.79,122.32 65.58,122.52 65.58,123.15 65.68,123.25 65.68,124.7 UV1.E9
  BOTTOM w0.1: v3(66.83,119.73) 65.79,120.77 65.79,122.32
DDBIA1_2: length 50.3
  TOP w0.089: UV3.D2 v3(68.26,98.46)
  IN1 w0.127: v3(61.14,122.39) 60.94,122.19 57.98,122.19 53.92,118.13 53.92,101.98 53.56,101.62 53.56,99.51 55.48,97.59 55.48,96.66 56.71,95.43 66.61,95.43 67.06,95.88 67.06,97.08 67.24,97.27 67.63,97.27 67.87,97.51 67.87,97.89 68.26,98.29 v3(68.26,98.46)
  BOTTOM w0.089: UV1.C5 62.48,123.9 62.48,123.27 62.25,123.04 61.79,123.04 v3(61.14,122.39)
DDBIA1_3: length 41.7
  BOTTOM w0.089: UV1.H4 61.48,127.1 60.32,127.1 60.09,126.86 59.63,126.86 ; UV6.P13 60.26,98.46 60.26,97.97 59.93,97.63 58.3,97.63
  BOTTOM w0.13: 58.3,97.63 58.27,97.6 56.75,97.6 v1(52.39,101.97) 51.91,102.45 51.91,119.28 58.48,125.84 58.48,125.99 59.36,126.86 59.63,126.86
DDR3_DRAMRST#_CPU: length 84.2
  TOP w0.102: RD24.1 98.95,24.92 QD9.3 99.57,25.71 100.01,26.15 RD4.2 98.12,26.77 97.63,27.26 97.63,28.47 98.49,29.33 98.49,42.3 101.87,45.67 v1(106.17,45.67) 108.29,45.67 110.11,47.49 110.11,52.87 104.57,58.41 96.01,58.41 v3(95.58,58.84)
  IN2 w0.089: v3(112.47,77.2) 111.95,76.68 111.95,73.63
  IN2 w0.127: 111.95,73.63 97.16,58.84 v3(95.58,58.84)
  BOTTOM w0.089: JCPU1.AN3 112.94,77.67 v3(112.47,77.2)
DDR3_DRAMRST#_R: length 16.3
  TOP w0.102: v3(101.03,25.07) 101.44,25.07 101.82,25.45 v1(101.82,25.64) RD25.2
  IN2 w0.127: v3(101.03,25.07) 100.14,24.18 v3(100.14,15.41)
  BOTTOM w0.102: JDIMM2.30 v3(100.14,15.41) ; v3(101.03,25.07) 100.9,25.07 100.14,25.84 JDIMM1.30
DDR_A_BS0: length 70.4
  IN4 w0.089: 130.02,73.63 129.97,73.68 129.97,74.53 129.89,74.62 129.77,74.62 129.67,74.72 129.67,74.87 129.77,74.97 129.99,74.97 130.1,75.08 130.1,75.22 129.99,75.33 129.46,75.33 129.35,75.43 129.35,75.58 129.46,75.68 129.89,75.68 129.97,75.77 129.97,78.47 129.85,78.6 129.27,78.6 128.66,79.21 128.08,79.21 127.95,79.33 127.95,80.44 128.08,80.57 128.68,80.57 128.81,80.45 128.81,80.27 128.68,80.14 v3(128.47,80.14)
  IN4 w0.165: v3(126.22,39.85) 126.22,40.07 126.09,40.2 125.41,40.2 125.29,40.32 125.29,41.06 125.41,41.19 126.2,41.19 126.37,41.36 126.37,41.69 126.2,41.85 125.41,41.85 125.29,41.98 125.29,42.47 125.41,42.6 125.67,42.6 125.8,42.73 125.8,43.49 125.92,43.61 126.33,43.61 126.46,43.49 126.46,42.73 126.92,42.26 127.1,42.26 127.77,42.93 127.77,43.11 126.71,44.17 126.71,44.4 126.94,44.64 127.18,44.64 128.24,43.58 128.42,43.58 128.71,43.86 128.71,44.04 127.64,45.11 127.64,45.34 127.88,45.57 128.11,45.57 129.17,44.51 129.35,44.51 129.64,44.8 129.64,44.98 128.58,46.04 128.58,46.27 128.81,46.51 129.05,46.51 129.56,45.99 129.74,45.99 130.03,46.28 130.03,46.46 129.51,46.97 129.51,47.21 130.02,47.71 130.02,73.63
  BOTTOM w0.089: v3(128.47,80.14) 128.06,79.73 JCPU1.V5
  BOTTOM w0.165: JDIMM1.109 126.24,36.75 126.38,36.89 126.83,36.89 126.94,37.01 126.94,37.51 126.7,37.76 126.7,39.22 126.92,39.43 127.2,39.43 127.3,39.54 127.3,40.41 127.2,40.51 126.75,40.51 126.22,39.99 v3(126.22,39.85)
DDR_A_BS1: length 73
  IN4 w0.089: 132.31,73.63 132.31,74.63 131.06,75.88 131.06,79.43 130.92,79.57 129.6,79.57 129.47,79.45 v3(129.47,79.2)
  IN4 w0.165: v3(126.32,31.65) 126.68,31.65 126.81,31.53 126.81,30.75 126.94,30.63 127.74,30.63 127.87,30.75 127.87,32.08 127.74,32.21 127.04,32.21 126.87,32.38 126.87,32.71 127.04,32.87 127.74,32.87 127.87,33 127.87,33.5 127.74,33.63 126.87,33.63 126.74,33.76 126.74,34.16 126.87,34.29 127.74,34.29 127.87,34.42 127.87,34.82 127.74,34.95 126.38,34.95 126.25,35.08 126.25,35.48 126.38,35.61 127.74,35.61 127.87,35.74 127.87,36.14 127.74,36.27 126.33,36.27 126.2,36.4 126.2,36.8 126.33,36.93 127.74,36.93 127.87,37.06 127.87,37.46 127.74,37.59 126.84,37.59 126.71,37.72 126.71,38.13 126.84,38.25 127.74,38.25 127.87,38.38 127.87,38.85 127.74,38.98 127.62,38.98 127.49,39.11 127.49,41.25 131.09,44.84 131.09,63.05 132.31,64.27 132.31,73.63
  BOTTOM w0.089: v3(129.47,79.2) JCPU1.U5
  BOTTOM w0.165: JDIMM1.108 125.94,28.93 125.75,29.12 125.75,31.09 v3(126.32,31.65)
DDR_A_BS2: length 67.8
  IN4 w0.089: v3(122.47,76.2) 121.99,75.72 121.99,73.63
  IN4 w0.165: v3(116.26,33.18) 116.26,33.32 115.27,34.31 115.27,40.95 115.71,41.38 115.71,47.35 115.37,47.68 115.37,62.93 115.79,63.35 120.79,63.35 120.92,63.48 120.92,64.1 120.79,64.23 117.23,64.23 117.11,64.36 117.11,64.76 117.23,64.89 120.79,64.89 120.92,65.02 120.92,65.42 120.79,65.55 118.55,65.55 118.43,65.68 118.43,66.08 118.55,66.21 121.87,66.21 121.99,66.34 121.99,66.74 121.87,66.87 120.84,66.87 120.72,67 120.72,67.4 120.84,67.53 121.87,67.53 121.99,67.66 121.99,73.63
  BOTTOM w0.089: JCPU1.AD1 122,75.73 v3(122.47,76.2)
  BOTTOM w0.165: v3(116.26,33.18) 117.24,34.16 JDIMM1.79
DDR_A_CAS#: length 64.9
  IN4 w0.089: v3(129.47,82.2) 129.35,82.2 129.22,82.07 129.22,81.76 129.35,81.63 132.74,81.63 132.87,81.51 132.87,75 133.79,74.08 133.79,73.63
  IN4 w0.165: 133.79,73.63 133.79,63.19 133.59,62.99 133.59,60.51 133.76,60.34 134.24,60.34 134.41,60.16 134.41,59.83 134.25,59.67 133.72,59.67 133.59,59.54 133.59,59.14 133.72,59.01 134.25,59.01 134.41,58.84 134.41,58.51 134.25,58.35 133.72,58.35 133.59,58.22 133.59,57.81 133.72,57.69 134.25,57.69 134.41,57.52 134.41,57.19 134.25,57.03 133.72,57.03 133.59,56.9 133.59,53.07 133.43,52.91 132.73,52.91 132.61,52.78 132.61,52.38 132.73,52.25 134.29,52.25 134.41,52.12 134.41,51.71 134.29,51.59 132.73,51.59 132.61,51.46 132.61,51.05 132.73,50.93 134.29,50.93 134.41,50.8 134.41,50.39 134.29,50.27 132.77,50.27 132.61,50.1 132.61,44.2 129.43,41.02 129.43,38.83 v3(128.94,38.33)
  BOTTOM w0.089: v3(129.47,82.2) JCPU1.U8
  BOTTOM w0.165: v3(128.94,38.33) 128.29,37.68 128.29,36.51 128.04,36.26 JDIMM1.115
DDR_A_D0: length 74
  IN4 w0.102: v3(110.47,89.2) 109.85,88.58 108.71,88.58 101.82,81.7 101.82,80.13 101.7,80 100.13,80 98.3,78.17 98.3,77.81 98.14,77.65 97.83,77.65 97.7,77.52 97.7,77.22 97.83,77.09 98.05,77.09 98.15,76.99 98.15,76.68 98.05,76.58 97.83,76.58 97.7,76.45 97.7,76.2 97.83,76.07 98.05,76.07 98.15,75.97 98.15,75.67 98.05,75.57 97.83,75.57 97.7,75.44 97.7,75.18 97.83,75.06 98.05,75.06 98.15,74.96 98.15,74.65 98.05,74.55 97.83,74.55 97.7,74.42 97.7,74.07 97.83,73.94 98.55,73.94 98.68,73.81 98.68,73.56 98.55,73.43 97.83,73.43 97.7,73.3 97.7,73.05 97.83,72.92 98.45,72.92 98.58,72.8 98.58,72.54 98.45,72.41 97.83,72.41 97.7,72.29 97.7,57.28 97.43,57 97.43,56.85 97.67,56.61 97.67,56.43 97.47,56.22 97.29,56.22 97.14,56.36 96.97,56.36 96.78,56.18 96.78,56 96.95,55.84 96.95,55.7 96.73,55.48 96.59,55.48 96.38,55.69 96.2,55.69 96.02,55.51 96.02,55.33 96.23,55.13 96.23,54.98 96.01,54.77 95.87,54.77 95.62,55.01 95.44,55.01 95.26,54.83 95.26,54.65 95.51,54.41 95.51,54.26 95.29,54.05 95.15,54.05 94.9,54.3 94.72,54.3 94.54,54.12 94.54,53.94 94.79,53.69 94.79,53.54 94.57,53.33 94.43,53.33 94.18,53.58 94,53.58 93.82,53.4 93.82,53.22 94.07,52.97 94.07,52.83 93.55,52.3 93.55,42.67 91.47,40.59 91.47,38.28 v3(92.18,37.57)
  BOTTOM w0.089: v3(110.47,89.2) 110.94,89.67 JCPU1.AR15
  BOTTOM w0.102: v3(92.18,37.57) 92.64,37.11 JDIMM1.5
DDR_A_D1: length 73.2
  IN4 w0.102: v3(109.47,88.2) 109.45,88.18 108.74,88.18 102.94,82.38 102.94,81.8 102.84,81.7 102.26,81.7 102.13,81.57 102.13,81.32 102.26,81.19 102.82,81.19 102.94,81.06 102.94,80.14 102.5,79.7 100.62,79.7 99.55,78.62 98.45,77.53 98.45,74.47 99.19,73.73 99.19,72.91 99.25,72.85 99.89,72.85 100.01,72.72 100.01,72.46 99.89,72.34 99.38,72.34 99.25,72.21 99.25,71.96 99.38,71.83 99.89,71.83 100.01,71.7 100.01,71.45 99.89,71.32 98.13,71.32 98.01,71.19 98.01,70.94 98.13,70.81 99.62,70.81 99.75,70.69 99.75,70.43 99.62,70.31 98.13,70.31 98.01,70.18 98.01,69.83 98.13,69.71 98.83,69.71 98.96,69.58 98.96,69.33 98.83,69.2 98.24,69.2 98.01,68.97 98.01,56.33 93.85,52.18 93.85,42.54 91.78,40.47 91.78,39.23 91.92,39.09 v3(92.18,39.09)
  BOTTOM w0.089: JCPU1.AT14 109.94,88.67 v3(109.47,88.2)
  BOTTOM w0.102: JDIMM1.7 93.24,38.04 v3(92.18,39.09)
DDR_A_D2: length 78.1
  IN4 w0.102: v3(113.47,88.2) 113.47,87.98 113.17,87.68 112.41,87.68 112.06,87.33 112.06,86.87 111.77,86.58 111.31,86.58 111.06,86.33 111.06,85.87 110.77,85.58 109.31,85.58 108.55,84.82 108.55,84.73 109.09,84.2 109.09,84.02 108.89,83.81 108.71,83.81 108.25,84.28 108.01,84.28 107.83,84.1 107.83,83.92 108.31,83.44 108.31,83.29 108.09,83.08 107.95,83.08 107.47,83.56 107.29,83.56 107.11,83.38 107.11,83.2 107.59,82.72 107.59,82.58 107.37,82.36 107.23,82.36 106.75,82.84 106.57,82.84 106.39,82.66 106.39,82.48 106.87,82 106.87,81.86 106.76,81.75 106.76,74.09 100.15,67.48 100.15,55.44 96.18,51.46 96.18,41.8 95.38,41 95.38,40.75 95.32,40.69 95.07,40.69 94.93,40.55 94.93,40.29 95.03,40.19 95.33,40.19 95.46,40.06 95.46,39.8 95.33,39.68 95.03,39.68 94.93,39.58 94.93,39.27 95.03,39.17 95.34,39.17 95.44,39.07 95.44,38.76 95.34,38.66 95.03,38.66 94.93,38.56 94.93,38.26 95.03,38.15 95.34,38.15 95.44,38.05 95.44,34.66 95.32,34.53 94.81,34.53 94.68,34.66 94.68,37.46 94.57,37.57 v3(94.22,37.57)
  BOTTOM w0.089: JCPU1.AM14 113.94,88.67 v3(113.47,88.2)
  BOTTOM w0.102: JDIMM1.15 95.64,36.73 94.8,37.57 v3(94.22,37.57)
DDR_A_D3: length 77.2
  IN4 w0.102: v3(112.47,88.2) 112.47,88.03 111.86,87.41 111.86,87.04 111.63,86.81 111.26,86.81 110.86,86.41 110.86,86.05 110.61,85.8 109.1,85.8 105.98,82.68 105.98,82.2 106.11,82.07 106.3,82.07 106.43,81.94 106.43,81.69 106.3,81.56 104.97,81.56 104.84,81.43 104.84,81.18 104.97,81.05 106.33,81.05 106.46,80.93 106.46,80.67 106.33,80.55 104.97,80.55 104.84,80.42 104.84,80.16 104.97,80.04 106.33,80.04 106.46,79.91 106.46,79.66 106.33,79.53 105.12,79.53 104.99,79.4 104.99,79.15 105.12,79.02 106.33,79.02 106.46,78.89 106.46,78.64 106.33,78.51 105.83,78.51 105.73,78.41 105.73,78.11 105.83,78.01 106.33,78.01 106.46,77.88 106.46,77.62 106.33,77.5 105.83,77.5 105.73,77.4 105.73,77.09 105.83,76.99 106.33,76.99 106.46,76.86 106.46,76.61 106.33,76.48 105.83,76.48 105.73,76.38 105.73,76.08 105.83,75.97 106.33,75.97 106.46,75.85 106.46,75.59 106.33,75.47 105.83,75.47 105.73,75.36 105.73,75.06 105.83,74.96 106.33,74.96 106.46,74.83 106.46,74.58 106.33,74.45 105.83,74.45 105.73,74.35 105.73,73.49 99.85,67.61 99.85,55.57 95.87,51.59 95.87,41.93 94.62,40.67 94.62,39.3 94.41,39.09 v3(94.22,39.09)
  BOTTOM w0.089: JCPU1.AN14 112.94,88.67 v3(112.47,88.2)
  BOTTOM w0.102: JDIMM1.17 96.24,36.59 95.9,36.93 95.9,37.48 94.29,39.09 v3(94.22,39.09)
DDR_A_D4: length 73.2
  IN4 w0.102: v3(92.06,30.89) 91.78,30.89 91.65,31.02 91.65,34.32 91.75,34.42 91.95,34.42 92.08,34.55 92.08,34.8 91.95,34.93 91.75,34.93 91.65,35.03 91.65,35.31 91.75,35.42 92.07,35.42 92.2,35.54 92.2,35.8 92.07,35.92 91.75,35.92 91.65,36.03 91.65,36.77 91.17,37.25 91.17,40.72 93.24,42.8 93.24,53.25 97.4,57.4 97.4,77.7 108.89,89.2 v3(109.47,89.2)
  BOTTOM w0.089: JCPU1.AT15 109.94,89.67 v3(109.47,89.2)
  BOTTOM w0.102: v3(92.06,30.89) 91.55,30.38 91.55,28.94 92.34,28.15 JDIMM1.4
DDR_A_D5: length 74.9
  IN4 w0.102: v3(92.06,29.37) 91.35,30.08 91.35,36.64 90.86,37.12 90.86,40.89 92.91,42.93 92.91,53.35 97.09,57.53 97.09,77.83 108.84,89.58 110.63,89.58 110.85,89.36 110.85,88.97 110.47,88.59 v3(110.47,88.2)
  BOTTOM w0.089: JCPU1.AR14 110.94,88.67 v3(110.47,88.2)
  BOTTOM w0.102: JDIMM1.6 92.94,28.49 v3(92.06,29.37)
DDR_A_D6: length 77.4
  IN4 w0.102: v3(112.47,89.2) 112.47,89.03 111.85,88.41 111.85,87.98 111.68,87.81 111.26,87.81 110.87,87.43 110.87,87.03 110.64,86.8 109.1,86.8 104.17,81.87 104.17,78.82 105.12,77.88 105.12,74.76 104.71,74.35 104.71,74.09 104.97,73.84 104.97,73.59 104.7,73.32 104.55,73.32 104.19,73.68 104.05,73.68 103.83,73.46 103.83,73.32 104.19,72.96 104.19,72.82 103.98,72.6 103.83,72.6 103.47,72.96 103.33,72.96 103.11,72.75 103.11,72.6 103.47,72.24 103.47,72.1 103.26,71.88 103.11,71.88 102.75,72.24 102.61,72.24 102.39,72.03 102.39,71.88 102.75,71.52 102.75,71.38 99.24,67.86 99.24,55.82 95.2,51.79 95.2,42.15 93.5,40.45 93.5,33.49 94.42,32.58 94.42,29.8 v3(94.85,29.37)
  BOTTOM w0.089: v3(112.47,89.2) 112.94,89.67 JCPU1.AN15
  BOTTOM w0.102: JDIMM1.16 95.94,28.28 v3(94.85,29.37)
DDR_A_D7: length 78.5
  IN4 w0.102: v3(113.47,89.2) 112.94,88.67 112.4,88.67 112.07,88.34 112.07,87.92 111.74,87.58 111.31,87.58 111.07,87.34 111.07,86.92 110.76,86.6 109.33,86.6 104.48,81.75 104.48,79.23 105.43,78.29 105.43,73.62 99.54,67.74 99.54,55.69 95.51,51.66 95.51,42.02 93.81,40.32 93.81,36.25 93.91,36.15 94.26,36.15 94.36,36.05 94.36,35.74 94.26,35.64 93.91,35.64 93.81,35.54 93.81,35.23 93.91,35.13 94.26,35.13 94.36,35.03 94.36,34.73 94.26,34.62 93.91,34.62 93.81,34.52 93.81,33.62 93.94,33.49 94.81,33.49 94.87,33.56 94.87,34.03 95,34.15 95.33,34.15 95.46,34.03 95.46,31.5 94.85,30.89 v3(94.85,30.89)
  BOTTOM w0.089: JCPU1.AM15 113.94,89.67 v3(113.47,89.2)
  BOTTOM w0.102: v3(94.85,30.89) 95.99,29.75 95.99,29.11 96.54,28.57 JDIMM1.18
DDR_A_D8: length 69.1
  IN4 w0.102: v3(99.68,32.42) 101.22,32.42 101.35,32.54 101.35,32.95 101.22,33.07 100.27,33.07 100.14,33.2 100.14,34.22 100.01,34.35 99.31,34.35 98.6,35.05 98.6,36.67 99.23,37.29 99.23,50.33 103.86,54.96 103.86,61.73 103.99,61.85 104.57,61.85 104.67,61.95 104.67,62.26 104.57,62.36 103.99,62.36 103.86,62.49 103.86,62.74 103.99,62.87 104.57,62.87 104.67,62.97 104.67,67.62 109.72,72.66 109.72,75.11 109.68,75.15 109.68,76.49 110.09,76.9 110.09,80.36 110.33,80.59 110.75,80.59 111.06,80.9 111.06,81.38 111.25,81.58 111.7,81.58 112.08,81.97 112.08,82.52 112.25,82.69 113.67,82.69 113.79,82.82 113.79,83.07 113.67,83.2 v3(113.47,83.2)
  BOTTOM w0.089: v3(113.47,83.2) 113.94,83.67 JCPU1.AM9
  BOTTOM w0.102: v3(99.68,32.42) 98.89,32.42 97.44,33.87 JDIMM1.21
DDR_A_D9: length 68.2
  IN4 w0.102: v3(99.68,33.94) 99.68,33.71 99.55,33.58 99.06,33.58 98.93,33.71 98.93,34.13 98.81,34.26 97.47,34.26 97.35,34.39 97.35,34.64 97.47,34.77 98.13,34.77 98.3,34.93 98.3,35.21 98.17,35.33 97.41,35.33 97.28,35.46 97.28,35.72 97.41,35.84 98.17,35.84 98.3,35.97 98.3,36.22 98.17,36.35 97.41,36.35 97.28,36.48 97.28,36.73 97.41,36.86 98.24,36.86 98.36,36.99 98.36,37.24 98.24,37.37 97.87,37.37 97.74,37.49 97.74,37.75 97.87,37.87 98.79,37.87 98.92,38 98.92,38.22 98.79,38.34 98.58,38.34 98.45,38.47 98.45,38.71 98.58,38.83 98.79,38.83 98.92,38.96 98.92,50.45 103.56,55.09 103.56,62.87 104.37,63.68 104.37,67.93 109.41,72.97 109.41,75 109.48,75.06 109.48,76.57 109.89,76.98 109.89,80.44 110.24,80.8 110.67,80.8 110.85,80.98 110.85,81.47 111.17,81.78 111.61,81.78 111.88,82.05 111.88,82.61 v3(112.47,83.2)
  BOTTOM w0.089: v3(112.47,83.2) 112.94,83.67 JCPU1.AN9
  BOTTOM w0.102: JDIMM1.23 98.04,34.22 98.31,33.95 99.67,33.95 v3(99.68,33.94)
DDR_A_D10: length 67.7
  IN4 w0.102: v3(113.47,82.2) 113.36,82.2 112.77,81.61 112.35,81.61 112.09,81.36 112.09,80.93 111.74,80.58 111.31,80.58 111.09,80.36 111.09,76.93 110.7,76.54 110.31,76.54 110.09,76.32 110.09,75.6 110.33,75.36 110.33,72.41 105.28,67.36 105.28,56.34 104.58,55.63 104.58,54.07 102.19,51.68 102.19,50.31 101.25,49.37 101.25,47.91 100.29,46.96 100.29,45.41 100.17,45.28 99.94,45.28 99.84,45.18 99.84,44.88 99.94,44.77 100.17,44.77 100.29,44.65 100.29,44.39 100.17,44.27 99.94,44.27 99.84,44.17 99.84,43.86 99.94,43.76 100.17,43.76 100.29,43.63 100.29,43.38 100.17,43.25 99.94,43.25 99.84,43.15 99.84,42.84 99.94,42.74 100.17,42.74 100.29,42.62 100.29,42.36 100.17,42.23 99.94,42.23 99.84,42.13 99.84,41.83 99.94,41.73 100.17,41.73 100.29,41.6 100.29,41.35 100.17,41.22 99.94,41.22 99.84,41.12 99.84,40.81 99.94,40.71 100.17,40.71 100.29,40.58 100.29,40.24 100.51,40.02 100.51,39.16 100.41,39.06 100.24,39.06 100.14,38.95 100.14,38.65 100.24,38.55 100.41,38.55 100.51,38.45 100.51,35.18 100.39,35.05 99.04,35.05 98.91,35.18 98.91,35.52 99.04,35.65 99.72,35.65 99.82,35.75 99.82,36.06 99.72,36.16 99.04,36.16 98.91,36.29 98.91,36.54 99.04,36.67 99.72,36.67 99.82,36.77 99.82,37.44 99.7,37.57 v3(99.68,37.57)
  BOTTOM w0.089: v3(113.47,82.2) 113.94,82.67 JCPU1.AM8
  BOTTOM w0.102: JDIMM1.33 101.04,36.8 100.27,37.57 v3(99.68,37.57)
DDR_A_D11: length 67.5
  IN4 w0.102: v3(99.68,39.09) 100.08,39.5 100.08,40.02 99.53,40.58 99.53,48.05 99.66,48.18 100.81,48.18 100.94,48.3 100.94,48.56 100.81,48.69 99.66,48.69 99.53,48.81 99.53,49.07 99.66,49.19 100.81,49.19 100.94,49.32 100.94,49.57 100.81,49.7 99.66,49.7 99.53,49.83 99.53,50.08 99.66,50.21 101.65,50.21 101.88,50.44 101.88,51.8 104.27,54.2 104.27,56.25 104.4,56.38 104.85,56.38 104.98,56.51 104.98,56.82 104.88,56.92 104.31,56.92 104.21,57.02 104.21,57.33 104.31,57.43 104.88,57.43 104.98,57.53 104.98,57.84 104.88,57.94 104.31,57.94 104.21,58.04 104.21,58.34 104.31,58.45 104.88,58.45 104.98,58.55 104.98,58.85 104.88,58.95 104.31,58.95 104.21,59.05 104.21,59.36 104.31,59.46 104.88,59.46 104.98,59.56 104.98,59.85 104.88,59.95 104.37,59.95 104.27,60.05 104.27,60.36 104.37,60.46 104.88,60.46 104.98,60.56 104.98,60.87 104.88,60.97 104.4,60.97 104.27,61.1 104.27,61.35 104.4,61.48 104.88,61.48 104.98,61.58 104.98,67.49 110.02,72.53 110.02,75.16 109.89,75.3 109.89,76.41 110.23,76.75 110.62,76.75 110.89,77.02 110.89,80.44 111.23,80.78 111.65,80.78 111.89,81.02 111.89,81.48 112.47,82.07 v3(112.47,82.2)
  BOTTOM w0.089: JCPU1.AN8 112.94,82.67 v3(112.47,82.2)
  BOTTOM w0.102: v3(99.68,39.09) 100.98,37.79 100.98,37.29 101.64,36.63 JDIMM1.35
DDR_A_D12: length 66.8
  IN4 w0.102: v3(97.39,29.37) 96.33,29.37 96.2,29.5 96.2,29.8 96.33,29.92 96.86,29.92 96.98,30.05 96.98,30.39 96.86,30.52 96.1,30.52 95.97,30.65 95.97,40.87 96.69,41.59 96.69,51.25 100.66,55.23 100.66,67.27 107.27,73.88 107.27,81.53 109.34,83.6 110.07,83.6 v3(110.47,83.2)
  BOTTOM w0.089: JCPU1.AR9 110.94,83.67 v3(110.47,83.2)
  BOTTOM w0.102: JDIMM1.22 97.74,29.02 v3(97.39,29.37)
DDR_A_D13: length 65.7
  IN4 w0.102: v3(97.39,30.89) 97.32,30.82 96.4,30.82 96.27,30.95 96.27,31.28 96.4,31.41 96.86,31.41 96.98,31.54 96.98,31.79 96.86,31.92 96.4,31.92 96.27,32.04 96.27,32.3 96.4,32.43 96.68,32.43 96.8,32.55 96.8,32.81 96.68,32.93 96.37,32.93 96.27,33.03 96.27,40.74 96.99,41.46 96.99,51.13 100.97,55.1 100.97,67.14 107.57,73.75 107.57,81.27 109.47,83.17 v3(109.47,83.2)
  BOTTOM w0.089: JCPU1.AT9 109.94,83.67 v3(109.47,83.2)
  BOTTOM w0.102: JDIMM1.24 98.34,29.94 v3(97.39,30.89)
DDR_A_D14: length 66.1
  IN4 w0.102: v3(99.68,29.37) 98.59,29.37 98.36,29.6 98.36,32.38 98.08,32.66 97.38,32.66 96.58,33.46 96.58,40.55 97.3,41.27 97.3,51 101.27,54.98 101.27,67 107.88,73.61 107.88,81.14 109.38,82.65 110.01,82.65 110.46,82.2 v3(110.47,82.2)
  BOTTOM w0.089: v3(110.47,82.2) 110.94,82.67 JCPU1.AR8
  BOTTOM w0.102: JDIMM1.34 101.34,28.19 100.16,29.37 v3(99.68,29.37)
DDR_A_D15: length 65.7
  IN4 w0.102: v3(99.68,30.89) 99.19,31.38 99.19,32.99 98.35,33.84 97.41,33.84 96.88,34.36 96.88,40.43 97.69,41.23 97.69,50.96 101.58,54.85 101.58,55.56 101.68,55.66 101.97,55.66 102.07,55.76 102.07,56.07 101.97,56.17 101.68,56.17 101.58,56.27 101.58,57.39 101.7,57.52 102.2,57.52 102.33,57.65 102.33,58.03 102.2,58.16 101.7,58.16 101.58,58.29 101.58,66.88 108.18,73.49 108.18,80.91 v3(109.47,82.2)
  BOTTOM w0.089: v3(109.47,82.2) 109.47,82.26 JCPU1.AT8
  BOTTOM w0.102: v3(99.68,30.89) 99.89,30.89 101.94,28.84 JDIMM1.36
DDR_A_D16: length 66.4
  IN4 w0.102: v3(116.47,83.2) 116.04,83.2 115.66,82.82 115.55,82.82 115.08,82.35 115.08,81.98 114.68,81.59 114.32,81.59 114.08,81.35 114.08,80.98 113.69,80.59 113.32,80.59 113.08,80.35 113.08,76.98 112.65,76.55 112.31,76.55 112.09,76.33 112.09,74.67 111.84,74.42 111.84,71.9 106.71,66.77 106.71,55.75 106,55.04 106,53.48 103.61,51.09 103.61,49.72 102.73,48.84 102.73,40.63 102.45,40.34 102.45,37.61 102.55,37.51 103.6,37.51 103.7,37.41 103.7,37.1 103.6,37 102.55,37 102.45,36.9 102.45,36.6 102.55,36.49 103.35,36.49 103.47,36.37 103.47,36.11 103.35,35.99 102.55,35.99 102.45,35.89 102.45,34.72 102.32,34.6 101.86,34.6 101.73,34.72 v3(101.73,37.57)
  BOTTOM w0.089: JCPU1.AJ9 116.94,83.67 v3(116.47,83.2)
  BOTTOM w0.102: JDIMM1.39 102.84,36.46 v3(101.73,37.57)
DDR_A_D17: length 65.1
  IN4 w0.102: v3(115.47,83.2) 115.47,83.03 114.88,82.43 114.88,82.07 114.6,81.79 114.23,81.79 113.88,81.43 113.88,81.07 113.6,80.79 113.23,80.79 112.88,80.43 112.88,77.07 112.57,76.76 112.23,76.76 111.89,76.42 111.89,74.76 111.53,74.4 111.53,72.03 106.4,66.9 106.4,55.87 105.7,55.17 105.7,53.61 103.3,51.21 103.3,49.85 102.36,48.91 102.36,46.85 102.24,46.72 101.64,46.72 101.51,46.59 101.51,46.34 101.64,46.21 102.24,46.21 102.36,46.08 102.36,45.83 102.24,45.7 101.54,45.7 101.41,45.58 101.41,45.32 101.54,45.19 102.24,45.19 102.36,45.07 102.36,44.81 102.24,44.69 101.54,44.69 101.41,44.56 101.41,44.31 101.54,44.18 102.24,44.18 102.36,44.05 102.36,43.8 102.24,43.67 101.54,43.67 101.41,43.54 101.41,43.29 101.54,43.16 102.24,43.16 102.36,43.04 102.36,42.76 102.26,42.65 101.6,42.65 101.47,42.53 101.47,42.27 101.6,42.15 102.26,42.15 102.36,42.05 102.36,41.74 102.26,41.64 101.6,41.64 101.47,41.51 101.47,41.26 101.6,41.13 102.26,41.13 102.36,41.03 102.36,40.72 102.26,40.62 102.07,40.62 101.97,40.52 101.97,40.19 102.14,40.02 102.14,39.5 v3(101.73,39.09)
  BOTTOM w0.089: JCPU1.AK9 115.94,83.67 v3(115.47,83.2)
  BOTTOM w0.102: JDIMM1.41 103.44,36.68 102.43,37.69 102.43,38.4 v3(101.73,39.09)
DDR_A_D18: length 64.5
  IN4 w0.102: v3(116.47,80.2) 116.09,79.82 116.09,76.93 115.74,76.58 115.31,76.58 115.09,76.36 115.09,72.12 108.85,65.88 108.85,54.85 108.15,54.15 108.15,51.23 107.15,50.23 107.15,48.28 105.97,47.1 105.97,36.57 105.85,36.44 105.6,36.44 105.48,36.31 105.48,36.06 105.6,35.93 106.36,35.93 106.49,35.81 106.49,35.55 106.36,35.42 105.67,35.42 105.54,35.3 105.54,35.04 105.67,34.92 106.4,34.92 106.53,34.79 106.53,33.14 106.4,33.01 106.11,33.01 105.98,33.14 105.98,34.28 105.86,34.41 105.09,34.41 104.96,34.53 v3(104.96,37.57)
  BOTTOM w0.089: v3(116.47,80.2) 116.94,80.67 JCPU1.AJ6
  BOTTOM w0.102: v3(104.96,37.57) 105.72,37.57 106.44,36.85 JDIMM1.51
DDR_A_D19: length 64.1
  IN4 w0.102: v3(115.47,80.2) 115.89,79.78 115.89,77.02 115.65,76.78 115.23,76.78 114.89,76.44 114.89,74.62 114.75,74.48 114.75,72.21 108.55,66.01 108.55,54.98 107.84,54.28 107.84,51.36 106.85,50.36 106.85,48.41 105.67,47.23 105.67,46 105.54,45.88 104.66,45.88 104.57,45.79 104.57,45.5 104.7,45.37 105.58,45.37 105.67,45.28 105.67,44.99 105.54,44.86 104.66,44.86 104.57,44.77 104.57,44.48 104.7,44.35 105.58,44.35 105.67,44.27 105.67,43.97 105.54,43.85 104.66,43.85 104.57,43.76 104.57,43.46 104.7,43.34 105.58,43.34 105.67,43.25 105.67,42.96 105.54,42.83 104.66,42.83 104.57,42.74 104.57,42.45 104.7,42.32 105.58,42.32 105.67,42.23 105.67,41.94 105.54,41.81 104.66,41.81 104.57,41.73 104.57,41.43 104.7,41.31 105.58,41.31 105.67,41.22 105.67,40.92 105.54,40.8 104.99,40.8 104.9,40.71 104.9,40.42 105.03,40.29 105.54,40.29 105.67,40.16 105.67,39.49 105.37,39.18 105.37,39.17 105.29,39.09 v3(104.96,39.09)
  BOTTOM w0.089: v3(115.47,80.2) 115.94,80.67 JCPU1.AK6
  BOTTOM w0.102: v3(104.96,39.09) 105.45,39.09 105.53,39.01 105.53,38.81 105.66,38.69 106.05,38.69 106.18,38.81 106.18,38.97 106.31,39.09 106.69,39.09 107.04,38.74 JDIMM1.53
DDR_A_D20: length 67.4
  IN4 w0.102: v3(103.69,30.89) 103.06,31.52 103.06,33.78 102.56,34.29 101.63,34.29 101.33,34.59 101.33,40.36 101.11,40.58 101.11,46.62 102.06,47.57 102.06,49.03 103,49.97 103,51.34 105.39,53.73 105.39,55.29 106.1,56 106.1,67.02 111.23,72.15 111.23,75.12 111.09,75.26 111.09,76.36 111.31,76.58 111.76,76.58 112.09,76.91 112.09,80.36 112.32,80.59 112.74,80.59 113.08,80.93 113.08,81.35 113.32,81.59 113.74,81.59 114.08,81.93 114.08,82.35 114.31,82.58 114.74,82.58 115.09,82.93 115.09,83.36 115.32,83.59 115.86,83.59 v3(116.47,84.2)
  BOTTOM w0.089: JCPU1.AJ10 116.94,84.67 v3(116.47,84.2)
  BOTTOM w0.102: JDIMM1.40 103.14,30.34 v3(103.69,30.89)
DDR_A_D21: length 66.1
  IN4 w0.102: v3(103.69,29.37) 102.76,30.3 102.76,32.55 101.02,34.29 101.02,40.23 100.8,40.45 100.8,46.75 101.75,47.7 101.75,49.16 102.69,50.1 102.69,51.47 105.09,53.86 105.09,55.42 105.79,56.12 105.79,67.15 110.92,72.28 110.92,74.9 110.89,74.93 110.89,76.44 111.23,76.78 111.68,76.78 111.89,76.99 111.89,80.44 112.23,80.79 112.65,80.79 112.88,81.02 112.88,81.43 113.23,81.79 113.6,81.79 113.88,82.07 113.88,82.43 114.23,82.78 114.65,82.78 114.89,83.02 114.89,83.61 v3(115.47,84.2)
  BOTTOM w0.089: JCPU1.AK10 115.94,84.67 v3(115.47,84.2)
  BOTTOM w0.102: v3(103.69,29.37) 103.74,29.32 JDIMM1.42
DDR_A_D22: length 65
  IN4 w0.102: v3(104.96,29.37) 105.37,29.78 105.37,30.48 105.49,30.61 105.67,30.61 105.79,30.73 105.79,30.99 105.67,31.12 105.49,31.12 105.37,31.24 105.37,31.5 105.49,31.62 105.6,31.62 105.73,31.75 105.73,32.05 105.6,32.18 104.69,32.18 104.59,32.28 104.59,32.58 104.69,32.69 105.26,32.69 105.37,32.79 105.37,33.27 105.24,33.39 104.68,33.39 104.55,33.52 104.55,41.02 104.27,41.31 104.27,46.06 104.4,46.18 105.22,46.18 105.36,46.33 105.36,47.36 106.54,48.53 106.54,50.49 107.54,51.48 107.54,54.4 108.24,55.11 108.24,66.13 114.39,72.28 114.39,74.74 114.09,75.04 114.09,76.36 114.33,76.6 114.76,76.6 115.07,76.91 115.07,80.34 115.53,80.79 116.07,80.79 v3(116.47,81.2)
  BOTTOM w0.089: JCPU1.AJ7 116.94,81.67 v3(116.47,81.2)
  BOTTOM w0.102: JDIMM1.50 106.14,28.19 v3(104.96,29.37)
DDR_A_D23: length 64.6
  IN4 w0.102: v3(115.47,81.2) 115.47,81.03 114.87,80.42 114.87,77 114.67,76.8 114.25,76.8 113.89,76.44 113.89,74.96 114.09,74.76 114.09,72.41 107.94,66.26 107.94,55.23 107.23,54.53 107.23,51.61 106.24,50.61 106.24,48.66 105.06,47.48 105.06,46.63 104.92,46.49 104.09,46.49 103.96,46.36 103.96,41.18 104.25,40.89 104.25,35.85 104.12,35.73 103.51,35.73 103.38,35.6 103.38,35.35 103.51,35.22 104.12,35.22 104.25,35.09 104.25,34.84 104.12,34.71 103.44,34.71 103.32,34.58 103.32,34.33 103.44,34.2 104.12,34.2 104.25,34.08 104.25,31.6 v3(104.96,30.89)
  BOTTOM w0.089: JCPU1.AK7 115.94,81.67 v3(115.47,81.2)
  BOTTOM w0.102: v3(104.96,30.89) 105.68,30.17 105.68,29.35 106.74,28.29 JDIMM1.52
DDR_A_D24: length 59.5
  IN4 w0.102: v3(119.47,78.2) 118.87,77.6 118.33,77.6 118.09,77.36 118.09,76.99 117.68,76.58 117.31,76.58 117.09,76.36 117.09,74.76 116.51,74.18 116.51,71.53 110.28,65.29 110.28,54.26 109.57,53.56 109.57,45.06 109.44,44.93 107.5,44.93 107.4,44.83 107.4,44.53 107.5,44.43 109.22,44.43 109.35,44.3 109.35,44.05 109.22,43.92 107.5,43.92 107.4,43.82 107.4,43.51 107.5,43.41 108.83,43.41 108.95,43.28 108.95,43.03 108.83,42.9 107.5,42.9 107.4,42.8 107.4,42.5 107.5,42.39 107.85,42.39 107.98,42.27 107.98,42.01 107.85,41.89 107.5,41.89 107.4,41.79 107.4,41.48 107.5,41.38 107.8,41.38 107.93,41.25 107.93,41 107.8,40.87 107.5,40.87 107.4,40.77 107.4,40.46 107.5,40.36 107.8,40.36 107.93,40.24 107.93,37.7 107.8,37.57 v3(107.5,37.57)
  BOTTOM w0.089: v3(119.47,78.2) 119.94,78.67 JCPU1.AF4
  BOTTOM w0.102: JDIMM1.57 108.24,36.83 v3(107.5,37.57)
DDR_A_D25: length 60.8
  IN4 w0.102: v3(119.47,79.2) 119.95,79.2 120.08,79.07 120.08,78.71 119.95,78.58 119.05,78.58 118.92,78.45 118.92,77.94 118.78,77.8 118.24,77.8 117.89,77.44 117.89,77.08 117.59,76.78 117.23,76.78 116.89,76.44 116.89,74.84 116.21,74.16 116.21,71.65 109.97,65.42 109.97,54.39 109.27,53.69 109.27,48.41 109.14,48.29 108.74,48.29 108.61,48.16 108.61,47.91 108.74,47.78 109.14,47.78 109.27,47.65 109.27,47.4 109.14,47.27 108.55,47.27 108.42,47.14 108.42,46.89 108.55,46.76 109.14,46.76 109.27,46.64 109.27,46.38 109.14,46.26 107.74,46.26 107.61,46.38 107.61,46.62 107.48,46.75 107.22,46.75 107.09,46.62 107.09,45.87 107.22,45.75 109.14,45.75 109.27,45.62 109.27,45.37 109.14,45.24 107.22,45.24 107.09,45.11 107.09,39.5 v3(107.5,39.09)
  BOTTOM w0.089: JCPU1.AF5 119.94,79.67 v3(119.47,79.2)
  BOTTOM w0.102: JDIMM1.59 108.84,38 107.75,39.09 v3(107.5,39.09)
DDR_A_D26: length 56.4
  IN4 w0.102: v3(119.47,75.2) 119.3,75.2 119.04,74.94 119.04,70.87 112.42,64.25 112.42,53.37 111.72,52.67 111.72,40.9 111.59,40.77 110.25,40.77 110.15,40.67 110.15,40.36 110.25,40.26 111.59,40.26 111.72,40.13 111.72,35.3 111.59,35.17 111.25,35.17 111.13,35.3 111.13,38.96 111,39.09 110.64,39.09 v3(110.64,39.09)
  BOTTOM w0.089: v3(119.47,75.2) 119.94,75.67 JCPU1.AF1
  BOTTOM w0.102: v3(110.64,39.09) 110.06,38.52 110.06,37.1 110.32,36.84 110.76,36.84 111.24,36.37 JDIMM1.67
DDR_A_D27: length 56.8
  IN4 w0.102: v3(110.64,37.57) 110.64,34.99 110.76,34.86 111.59,34.86 111.72,34.74 111.72,34.43 111.59,34.31 109.94,34.31 109.81,34.43 109.81,40.95 109.94,41.07 111.29,41.07 111.41,41.2 111.41,41.45 111.29,41.58 111.04,41.58 110.91,41.71 110.91,41.96 111.04,42.09 111.29,42.09 111.41,42.22 111.41,52.8 112.12,53.5 112.12,64.38 118.74,71 118.74,74.93 118.88,75.07 118.88,75.61 v3(119.47,76.2)
  BOTTOM w0.089: v3(119.47,76.2) 119.94,76.67 JCPU1.AF2
  BOTTOM w0.102: v3(110.64,37.57) 111.84,36.36 JDIMM1.69
DDR_A_D28: length 58.7
  IN4 w0.102: v3(107.5,30.89) 107.93,31.32 107.93,36.27 107.8,36.4 107.33,36.4 106.79,36.94 106.79,46.77 108.96,48.94 108.96,53.81 109.67,54.52 109.67,65.54 115.9,71.78 115.9,74.46 116.09,74.64 116.09,76.36 116.31,76.58 116.74,76.58 117.09,76.93 117.09,77.36 117.31,77.58 117.74,77.58 118.36,78.2 v3(118.47,78.2)
  BOTTOM w0.089: JCPU1.AG4 118.94,78.67 v3(118.47,78.2)
  BOTTOM w0.102: JDIMM1.56 107.94,27.92 106.95,28.91 106.95,30.35 v3(107.5,30.89)
DDR_A_D29: length 59.7
  IN4 w0.102: v3(107.5,29.37) 106.83,29.37 106.73,29.47 106.73,29.8 107.05,30.11 107.05,35.99 106.48,36.56 106.48,46.89 107.66,48.07 107.66,50.02 108.66,51.02 108.66,53.94 109.36,54.64 109.36,65.67 115.6,71.91 115.6,74.73 115.85,74.99 115.85,76.41 116.23,76.78 116.65,76.78 116.89,77.02 116.89,77.44 117.23,77.78 117.65,77.78 117.98,78.11 117.98,78.71 v3(118.47,79.2)
  BOTTOM w0.089: v3(118.47,79.2) 118.94,79.67 JCPU1.AG5
  BOTTOM w0.102: v3(107.5,29.37) 107.9,28.97 107.91,28.97 108.54,28.34 JDIMM1.58
DDR_A_D30: length 55.1
  IN4 w0.102: v3(110.65,29.37) 111.08,29.79 111.08,33.27 110.93,33.42 109.61,33.42 109.49,33.55 109.49,41.25 109.61,41.38 110.48,41.38 110.61,41.51 110.61,42.26 110.73,42.39 110.98,42.39 111.11,42.52 111.11,52.92 111.81,53.63 111.81,64.51 118.43,71.13 118.43,75.16 v3(118.47,75.2)
  BOTTOM w0.089: JCPU1.AG1 118.94,75.67 v3(118.47,75.2)
  BOTTOM w0.102: JDIMM1.68 111.54,28.48 v3(110.65,29.37)
DDR_A_D31: length 55.9
  IN4 w0.102: v3(118.47,76.2) 118.47,75.74 118.09,75.36 118.09,71.22 111.51,64.63 111.51,53.75 110.8,53.05 110.8,43 110.3,42.5 110.3,41.87 110.11,41.68 109.49,41.68 109.35,41.54 109.16,41.36 109.16,33.24 109.29,33.12 110.12,33.12 110.21,33.02 110.21,31.07 110.39,30.89 v3(110.65,30.89)
  BOTTOM w0.089: JCPU1.AG2 118.94,76.67 v3(118.47,76.2)
  BOTTOM w0.102: JDIMM1.70 112.14,29.4 v3(110.65,30.89)
DDR_A_D32: length 52
  IN4 w0.102: v3(133.64,39.09) 133.99,39.09 134.11,39.21 134.11,40.81 137.86,44.56 137.86,63.58 137.96,63.68 138.46,63.68 138.56,63.78 138.56,64.09 138.46,64.19 137.96,64.19 137.86,64.29 137.86,64.6 137.96,64.7 138.46,64.7 138.56,64.8 138.56,65.11 138.46,65.21 137.96,65.21 137.86,65.31 137.86,65.61 137.96,65.72 138.46,65.72 138.56,65.82 138.56,66.12 138.46,66.22 137.96,66.22 137.86,66.32 137.86,66.63 137.96,66.73 138.46,66.73 138.56,66.83 138.56,67.14 138.46,67.24 137.96,67.24 137.86,67.34 137.86,67.65 137.96,67.75 138.46,67.75 138.56,67.85 138.56,68.15 138.46,68.26 137.96,68.26 137.86,68.36 137.86,68.66 137.96,68.76 138.46,68.76 138.56,68.86 138.56,69.17 138.46,69.27 137.96,69.27 137.86,69.37 137.86,74.35 137.48,74.73 137.47,74.73 v3(137.47,75.2)
  BOTTOM w0.089: v3(137.47,75.2) JCPU1.J1
  BOTTOM w0.102: v3(133.64,39.09) 132.56,39.09 132.24,38.78 132.24,38.29 132.37,38.16 132.84,38.16 132.96,38.04 132.96,37.68 132.84,37.55 132.37,37.55 132.24,37.43 JDIMM1.129
DDR_A_D33: length 53.3
  IN4 w0.102: v3(137.47,76.2) 137.35,76.2 137.23,76.07 137.23,75.75 137.35,75.62 137.73,75.62 137.86,75.49 137.86,74.76 138.17,74.46 138.17,69.99 138.92,69.24 138.92,63.34 138.81,63.24 138.28,63.24 138.18,63.14 138.18,62.83 138.28,62.73 138.81,62.73 138.92,62.63 138.92,62.32 138.81,62.22 138.28,62.22 138.18,62.12 138.18,61.82 138.28,61.71 138.81,61.71 138.92,61.61 138.92,61.31 138.81,61.21 138.28,61.21 138.18,61.1 138.18,60.8 138.28,60.7 138.81,60.7 138.92,60.6 138.92,60.29 138.81,60.19 138.28,60.19 138.18,60.09 138.18,59.78 138.28,59.68 138.81,59.68 138.92,59.58 138.92,59.28 138.81,59.17 138.28,59.17 138.18,59.07 138.18,58.77 138.28,58.67 138.81,58.67 138.92,58.56 138.92,58.26 138.81,58.16 138.28,58.16 138.18,58.06 138.18,44.41 134.44,40.67 134.44,38.69 134.34,38.59 134.15,38.59 134.04,38.48 134.04,38.19 134.15,38.08 134.34,38.08 134.44,37.98 134.44,37.37 134.27,37.2 133.81,37.2 133.64,37.37 v3(133.64,37.57)
  BOTTOM w0.089: v3(137.47,76.2) JCPU1.J2
  BOTTOM w0.102: v3(133.64,37.57) 132.84,36.77 JDIMM1.131
DDR_A_D34: length 56.4
  IN4 w0.102: v3(137.47,79.2) 138.07,78.6 138.71,78.6 138.87,78.44 138.87,77.92 139.21,77.59 139.63,77.59 139.87,77.35 139.87,75.92 140.26,75.53 140.26,75.35 140.62,74.99 140.62,71.01 141.37,70.26 141.37,47.5 141.24,47.37 140.76,47.37 140.63,47.25 140.63,46.99 140.76,46.87 141.92,46.87 142.05,46.74 142.05,46.49 141.92,46.36 140.76,46.36 140.63,46.23 140.63,45.98 140.76,45.85 141.94,45.85 142.06,45.72 142.06,45.39 141.94,45.27 140.76,45.27 140.63,45.14 140.63,44.76 140.73,44.66 141.46,44.66 141.58,44.53 141.58,44.28 141.46,44.15 140.73,44.15 140.63,44.05 140.63,43.32 138.07,40.76 138.07,39.17 137.99,39.09 v3(137.61,39.09)
  BOTTOM w0.089: v3(137.47,79.2) JCPU1.J5
  BOTTOM w0.102: JDIMM1.141 135.84,36.77 136.54,37.48 136.54,38.02 v3(137.61,39.09)
DDR_A_D35: length 55.7
  IN4 w0.102: v3(137.61,37.57) 138.02,37.98 138.02,38.69 138.37,39.04 138.37,40.63 142.37,44.63 142.37,47.32 142.27,47.42 141.84,47.42 141.73,47.52 141.73,47.82 141.84,47.93 142.27,47.93 142.37,48.03 142.37,48.33 142.27,48.43 141.84,48.43 141.73,48.53 141.73,48.84 141.84,48.94 142.27,48.94 142.37,49.04 142.37,49.35 142.27,49.45 141.84,49.45 141.73,49.55 141.73,49.86 141.84,49.96 142.27,49.96 142.37,50.06 142.37,50.36 142.27,50.47 141.84,50.47 141.73,50.57 141.73,50.87 141.84,50.97 142.27,50.97 142.37,51.07 142.37,51.38 142.27,51.48 141.84,51.48 141.73,51.58 141.73,51.89 141.84,51.99 142.27,51.99 142.37,52.09 142.37,52.4 142.27,52.5 141.84,52.5 141.73,52.6 141.73,52.9 141.84,53.01 142.27,53.01 142.37,53.11 142.37,53.41 142.27,53.51 141.84,53.51 141.73,53.61 141.73,70.33 140.92,71.14 140.92,74.98 140.46,75.44 140.46,75.61 140.07,76 140.07,77.43 139.72,77.79 139.29,77.79 139.07,78.01 139.07,79.11 138.98,79.2 v3(138.47,79.2)
  BOTTOM w0.089: v3(138.47,79.2) JCPU1.H5
  BOTTOM w0.102: v3(137.61,37.57) 136.44,36.39 JDIMM1.143
DDR_A_D36: length 53.2
  IN4 w0.102: v3(138.47,76.2) 138.07,75.8 138.07,74.84 138.47,74.44 138.47,70.12 139.22,69.37 139.22,58.07 138.48,57.33 138.48,44.29 134.77,40.57 134.77,31.41 v3(134.25,30.89)
  BOTTOM w0.089: v3(138.47,76.2) JCPU1.H2
  BOTTOM w0.102: v3(134.25,30.89) 132.54,29.18 JDIMM1.130
DDR_A_D37: length 51.9
  IN4 w0.102: v3(138.47,75.2) 138.47,75.07 138.78,74.76 138.78,70.25 139.53,69.5 139.53,57.94 138.79,57.2 138.79,44.09 135.1,40.4 135.1,30.22 v3(134.25,29.37)
  BOTTOM w0.089: v3(138.47,75.2) JCPU1.H1
  BOTTOM w0.102: v3(134.25,29.37) 133.15,28.27 133.14,28.27 JDIMM1.132
DDR_A_D38: length 55.9
  IN4 w0.102: v3(135.77,30.89) 136.18,31.3 136.18,35.77 136.83,36.43 136.83,40.39 140.02,43.58 140.02,47.58 140.76,48.32 140.76,70.01 140.01,70.76 140.01,75.03 139.85,75.18 139.85,75.36 139.32,75.89 139.32,76.52 138.87,76.98 138.87,77.35 138.62,77.6 138.07,77.6 v3(137.47,78.2)
  BOTTOM w0.089: v3(137.47,78.2) JCPU1.J4
  BOTTOM w0.102: v3(135.77,30.89) 135.21,30.33 135.21,28.73 135.54,28.4 JDIMM1.140
DDR_A_D39: length 55.2
  IN4 w0.102: v3(138.47,78.2) 138.47,78.03 139.07,77.43 139.07,77.06 139.52,76.61 139.52,75.97 140.06,75.44 140.06,75.27 140.31,75.01 140.31,70.88 141.06,70.13 141.06,48.19 140.32,47.45 140.32,43.45 137.14,40.27 137.14,36.3 136.48,35.65 136.48,30.08 v3(135.77,29.37)
  BOTTOM w0.089: v3(138.47,78.2) JCPU1.H4
  BOTTOM w0.102: JDIMM1.142 136.14,29 v3(135.77,29.37)
DDR_A_D40: length 56.6
  IN4 w0.102: v3(140.47,77.2) 140.47,76.89 140.89,76.47 140.89,75.6 141.73,74.75 141.73,71.47 142.55,70.66 142.55,64.75 142.67,64.62 143.08,64.62 143.18,64.52 143.18,64.22 143.08,64.11 142.67,64.11 142.55,63.99 142.55,63.73 142.67,63.61 143.08,63.61 143.18,63.5 143.18,63.23 143.05,63.1 142.67,63.1 142.55,62.97 142.55,62.72 142.67,62.59 143.05,62.59 143.18,62.46 143.18,62.21 143.05,62.08 142.65,62.08 142.55,61.98 142.55,61.68 142.65,61.57 143.05,61.57 143.18,61.45 143.18,61.19 143.05,61.07 142.65,61.07 142.55,60.96 142.55,60.66 142.65,60.56 143.05,60.56 143.18,60.43 143.18,60.18 143.05,60.05 142.65,60.05 142.55,59.95 142.55,59.64 142.65,59.54 143.05,59.54 143.18,59.42 143.18,59.16 143.05,59.03 142.65,59.03 142.55,58.93 142.55,58.63 142.65,58.53 143.05,58.53 143.18,58.4 143.18,58.15 143.05,58.02 142.65,58.02 142.55,57.92 142.55,57.61 142.65,57.51 143.05,57.51 143.18,57.38 143.18,57.13 143.05,57 142.65,57 142.55,56.9 142.55,56.6 142.65,56.49 143.05,56.49 143.18,56.37 143.18,56.11 143.05,55.99 142.65,55.99 142.55,55.88 142.55,55.58 142.65,55.48 143.05,55.48 143.18,55.35 143.18,55.07 143.08,54.97 142.66,54.97 142.56,54.87 142.56,54.56 142.66,54.46 143.08,54.46 143.18,54.36 143.18,44.3 139.18,40.3 139.18,39.55 v3(139.64,39.09)
  BOTTOM w0.089: JCPU1.F2 140,76.73 v3(140.47,77.2)
  BOTTOM w0.102: v3(139.64,39.09) 138.58,38.03 138.58,37.61 137.64,36.67 JDIMM1.147
DDR_A_D41: length 55.9
  IN4 w0.102: v3(140.47,76.2) 140.66,76 140.66,75.52 141.43,74.75 141.43,71.35 142.24,70.54 142.24,54.28 142.88,53.65 142.88,44.42 138.88,40.42 138.88,38.83 138.53,38.48 138.53,37.47 138.4,37.34 138.11,37.34 138.01,37.24 138.01,36.94 138.11,36.84 138.4,36.84 138.53,36.71 138.53,36.45 138.4,36.33 137.77,36.33 137.65,36.2 137.65,35.95 137.77,35.82 138.4,35.82 138.53,35.69 138.53,35.42 138.4,35.3 137.77,35.3 137.65,35.17 137.65,34.76 137.77,34.63 139,34.63 139.13,34.76 139.13,37.51 139.19,37.57 v3(139.64,37.57)
  BOTTOM w0.089: v3(140.47,76.2) 140,75.73 JCPU1.F1
  BOTTOM w0.102: v3(139.64,37.57) 139.12,37.57 138.24,36.69 JDIMM1.149
DDR_A_D42: length 56.5
  IN4 w0.102: v3(142.47,77.2) 142.64,77.2 143.26,76.59 143.68,76.59 143.99,76.27 143.99,75.87 143.6,75.48 143.6,72.22 144.46,71.35 144.46,70.86 144.59,70.73 145.09,70.73 145.21,70.6 145.21,70.28 145.09,70.15 144.51,70.15 144.39,70.03 144.39,69.77 144.51,69.65 145.72,69.65 145.85,69.52 145.85,69.26 145.72,69.14 144.5,69.14 144.4,69.04 144.4,68.73 144.5,68.63 145.72,68.63 145.85,68.5 145.85,68.25 145.72,68.12 144.5,68.12 144.4,68.02 144.4,67.71 144.5,67.61 145.72,67.61 145.85,67.49 145.85,67.23 145.72,67.11 144.5,67.11 144.4,67 144.4,66.7 144.5,66.6 144.91,66.6 145.04,66.47 145.04,66.22 144.91,66.09 144.73,66.09 144.6,65.96 144.6,65.71 144.73,65.58 144.92,65.58 145.02,65.48 145.02,43.53 141.7,40.21 141.7,39.5 v3(142.1,39.09)
  BOTTOM w0.089: JCPU1.D2 142,76.73 v3(142.47,77.2)
  BOTTOM w0.102: JDIMM1.157 140.64,37.63 v3(142.1,39.09)
DDR_A_D43: length 57.3
  IN4 w0.102: v3(142.1,37.57) 142.43,37.57 142.51,37.65 142.51,40.59 145.35,43.43 145.35,59.3 145.45,59.4 145.87,59.4 145.98,59.5 145.98,59.8 145.87,59.9 145.45,59.9 145.35,60.01 145.35,60.31 145.45,60.41 146.03,60.41 146.15,60.54 146.15,60.79 146.03,60.92 145.45,60.92 145.35,61.02 145.35,61.33 145.45,61.43 146.03,61.43 146.15,61.56 146.15,61.81 146.03,61.94 145.45,61.94 145.35,62.04 145.35,62.34 145.45,62.44 146.03,62.44 146.15,62.57 146.15,62.83 146.03,62.95 145.45,62.95 145.35,63.05 145.35,63.36 145.45,63.46 146.03,63.46 146.15,63.59 146.15,63.84 146.03,63.97 145.45,63.97 145.35,64.07 145.35,64.38 145.45,64.48 146.03,64.48 146.15,64.6 146.15,64.86 146.03,64.98 145.45,64.98 145.35,65.09 145.35,65.39 145.45,65.49 146,65.49 146.15,65.65 146.15,65.88 146.03,66 145.47,66 145.34,66.13 145.34,66.39 145.47,66.51 146.03,66.51 146.15,66.64 146.15,70.09 144.08,72.17 144.08,75.64 144.2,75.76 144.2,76.36 143.77,76.79 143.34,76.79 143.09,77.04 143.09,77.57 142.47,78.19 v3(142.47,78.2)
  BOTTOM w0.089: JCPU1.D3 142,77.73 v3(142.47,78.2)
  BOTTOM w0.102: JDIMM1.159 141.24,37.22 141.59,37.57 v3(142.1,37.57)
DDR_A_D44: length 54.4
  IN4 w0.102: v3(142.47,76.2) 142.34,76.07 142.34,71.73 143.16,70.92 143.16,65.41 143.79,64.77 143.79,44.04 140.35,40.6 140.35,35.12 138.96,33.73 138.96,31.56 138.86,31.46 138.64,31.46 138.52,31.33 138.52,31.08 138.64,30.95 138.88,30.95 139,30.82 139,29.5 138.88,29.37 v3(137.8,29.37)
  BOTTOM w0.089: v3(142.47,76.2) 142,75.73 JCPU1.D1
  BOTTOM w0.102: v3(137.8,29.37) 137.34,28.9 JDIMM1.146
DDR_A_D45: length 58
  IN4 w0.102: v3(140.47,78.2) 140.8,77.86 140.8,77.38 141.09,77.1 141.09,76.02 142.04,75.07 142.04,71.6 142.85,70.79 142.85,65.28 143.49,64.65 143.49,44.17 140.05,40.73 140.05,35.25 138.21,33.41 138.21,32.69 138.11,32.59 137.2,32.59 137.1,32.49 137.1,32.19 137.2,32.09 138.11,32.09 138.21,31.98 138.21,31.02 138.08,30.89 v3(137.8,30.89)
  BOTTOM w0.089: v3(140.47,78.2) 140,77.73 JCPU1.F3
  BOTTOM w0.102: v3(137.8,30.89) 138.39,30.31 138.39,28.61 137.94,28.17 JDIMM1.148
DDR_A_D46: length 56.4
  IN4 w0.102: v3(143.47,78.2) 143.87,77.8 143.87,76.97 144.48,76.36 144.48,75.76 144.38,75.66 144.38,72.29 146.46,70.22 146.46,59.53 145.66,58.73 145.66,43.3 142.81,40.46 142.81,36.49 142.71,36.39 141.77,36.39 141.58,36.2 141.58,31.41 v3(142.1,30.89)
  BOTTOM w0.089: v3(143.47,78.2) 143,77.73 JCPU1.C3
  BOTTOM w0.102: JDIMM1.158 140.94,29.73 v3(142.1,30.89)
DDR_A_D47: length 55.2
  IN4 w0.102: v3(142.1,29.37) 142.51,29.78 142.51,35.76 143.12,36.37 143.12,40.33 145.96,43.18 145.96,58.6 146.76,59.4 146.76,70.35 144.69,72.42 144.69,76.44 144.07,77.06 144.07,77.8 v3(144.47,78.2)
  BOTTOM w0.089: JCPU1.B3 144,77.73 v3(144.47,78.2)
  BOTTOM w0.102: v3(142.1,29.37) 141.54,28.81 JDIMM1.160
DDR_A_D48: length 59.4
  IN4 w0.102: v3(144.47,80.2) 144.47,80.02 145.11,79.39 145.11,78.97 146.11,77.97 146.11,73.01 148.19,70.94 148.19,51.6 148.08,51.5 147.49,51.5 147.39,51.4 147.39,51.1 147.49,50.99 148.08,50.99 148.19,50.89 148.19,50.59 148.08,50.49 147.49,50.49 147.39,50.38 147.39,50.08 147.49,49.98 148.08,49.98 148.19,49.88 148.19,49.57 148.08,49.47 147.49,49.47 147.39,49.37 147.39,49.06 147.49,48.96 148.08,48.96 148.19,48.86 148.19,48.56 148.08,48.45 147.49,48.45 147.39,48.35 147.39,48.05 147.49,47.95 148.08,47.95 148.19,47.84 148.19,47.54 148.08,47.44 147.49,47.44 147.39,47.34 147.39,47.03 147.49,46.93 148.08,46.93 148.19,46.83 148.19,46.52 148.08,46.42 147.49,46.42 147.39,46.32 147.39,42.59 145.56,40.76 145.56,38.73 145.43,38.6 145.1,38.6 144.8,38.91 v3(144.8,39.09)
  BOTTOM w0.089: JCPU1.B5 144,79.73 v3(144.47,80.2)
  BOTTOM w0.102: v3(144.8,39.09) 144.56,39.09 144.43,39.22 144.43,39.59 144.3,39.71 143.94,39.71 143.81,39.59 143.81,37.68 142.44,36.31 JDIMM1.163
DDR_A_D49: length 61.2
  IN4 w0.102: v3(141.47,81.2) 142.07,80.6 142.81,80.6 142.94,80.47 142.94,80.02 143.15,79.81 144.4,79.81 144.91,79.3 144.91,78.88 145.8,77.98 145.8,72.89 147.88,70.81 147.88,58.52 147.64,58.28 147.23,58.28 147.08,58.14 147.08,57.73 147.18,57.63 147.73,57.63 147.83,57.53 147.83,57.22 147.73,57.12 147.18,57.12 147.08,57.02 147.08,56.72 147.18,56.61 147.73,56.61 147.83,56.51 147.83,56.21 147.73,56.11 147.18,56.11 147.08,56.01 147.08,55.7 147.18,55.6 147.73,55.6 147.83,55.5 147.83,55.19 147.73,55.09 147.18,55.09 147.08,54.99 147.08,54.68 147.18,54.58 147.73,54.58 147.83,54.48 147.83,54.18 147.73,54.07 147.18,54.07 147.08,53.97 147.08,53.67 147.18,53.57 147.73,53.57 147.83,53.47 147.83,53.16 147.73,53.06 147.18,53.06 147.08,52.96 147.08,52.65 147.18,52.55 147.73,52.55 147.83,52.45 147.83,52.14 147.73,52.04 147.18,52.04 147.08,51.94 147.08,42.71 144.24,39.87 144.24,37.71 144.38,37.57 v3(144.8,37.57)
  BOTTOM w0.089: v3(141.47,81.2) 141,80.73 JCPU1.E6
  BOTTOM w0.102: v3(144.8,37.57) 144.23,37.57 143.04,36.38 JDIMM1.165
DDR_A_D50: length 59
  IN4 w0.102: v3(147.34,39.09) 147.89,39.65 147.89,40.81 149.93,42.84 149.93,52.89 149.83,52.99 149.52,52.99 149.42,53.09 149.42,53.39 149.52,53.5 149.83,53.5 149.93,53.6 149.93,53.9 149.83,54 149.52,54 149.42,54.1 149.42,54.41 149.52,54.51 149.83,54.51 149.93,54.61 149.93,54.92 149.83,55.02 149.52,55.02 149.42,55.12 149.42,55.43 149.52,55.53 149.83,55.53 149.93,55.63 149.93,55.93 149.83,56.04 149.52,56.04 149.42,56.14 149.42,56.44 149.52,56.54 149.83,56.54 149.93,56.64 149.93,56.95 149.83,57.05 149.52,57.05 149.42,57.15 149.42,57.46 149.52,57.56 149.83,57.56 149.93,57.66 149.93,57.97 149.83,58.07 149.52,58.07 149.42,58.17 149.42,58.47 149.52,58.58 149.83,58.58 149.93,58.68 149.93,58.99 149.8,59.12 149.54,59.12 149.42,59.25 149.42,59.5 149.54,59.63 149.8,59.63 149.93,59.75 149.93,60.01 149.8,60.14 149.54,60.14 149.42,60.26 149.42,60.52 149.54,60.64 149.8,60.64 149.93,60.77 149.93,61.02 149.8,61.15 149.52,61.15 149.42,61.25 149.42,61.56 149.52,61.66 149.8,61.66 149.93,61.79 149.93,62.04 149.8,62.17 149.54,62.17 149.42,62.29 149.42,70.85 149.42,70.85 149.42,71.45 147.34,73.52 147.34,78.84 146.24,79.94 146.24,80.08 145.84,80.48 145.54,80.48 145.47,80.4 v3(145.47,80.2)
  BOTTOM w0.089: JCPU1.A5 145,79.73 v3(145.47,80.2)
  BOTTOM w0.102: v3(147.34,39.09) 147.34,39.33 147.21,39.46 146.7,39.46 146.58,39.33 146.58,38.67 146.7,38.55 146.77,38.55 146.89,38.42 146.89,37.97 146.77,37.85 146.56,37.85 146.44,37.72 146.44,37.5 146.56,37.38 146.65,37.38 146.78,37.25 146.78,37.01 146.65,36.88 146.17,36.88 146.04,36.75 JDIMM1.175
DDR_A_D51: length 60.9
  IN4 w0.102: v3(142.47,81.2) 142.47,81.73 142.56,81.82 145.65,81.82 148.26,79.21 148.26,73.9 150.33,71.83 150.33,62.93 150.85,62.42 150.85,42.46 148.81,40.43 148.81,37.43 146.17,34.79 v3(146.17,32.49)
  BOTTOM w0.089: v3(142.47,81.2) 142,80.73 JCPU1.D6
  BOTTOM w0.102: JDIMM1.177 146.64,32.96 v3(146.17,32.49)
DDR_A_D52: length 59.8
  IN4 w0.102: v3(144.8,30.89) 144.08,30.89 143.93,31.04 143.93,40 146.78,42.84 146.78,58.26 147.58,59.06 147.58,70.68 145.5,72.76 145.5,78 144.69,78.8 144.08,78.8 143.96,78.93 143.96,79.39 143.74,79.61 143.06,79.61 v3(142.47,80.2)
  BOTTOM w0.089: JCPU1.D5 142,79.73 v3(142.47,80.2)
  BOTTOM w0.102: JDIMM1.164 142.74,28.84 v3(144.8,30.89)
DDR_A_D53: length 60.4
  IN4 w0.102: v3(144.8,29.37) 144.09,29.37 143.63,29.84 143.63,40.12 146.47,42.97 146.47,58.39 147.27,59.19 147.27,70.56 145.2,72.63 145.2,78.01 144.61,78.6 143.53,78.6 142.99,79.14 142.99,79.22 142.56,79.65 142.02,79.65 v3(141.47,80.2)
  BOTTOM w0.089: JCPU1.E5 141,79.73 v3(141.47,80.2)
  BOTTOM w0.102: v3(144.8,29.37) 144.32,29.37 143.34,28.39 JDIMM1.166
DDR_A_D54: length 60.3
  IN4 w0.102: v3(144.47,81.2) 144.86,81.2 145.26,80.8 145.81,80.8 147.65,78.96 147.65,73.65 149.72,71.57 149.72,62.68 150.24,62.17 150.24,42.72 148.2,40.68 148.2,38.62 145.46,35.88 145.46,29.87 145.94,29.39 v3(146.17,29.39)
  BOTTOM w0.089: v3(144.47,81.2) 144,80.73 JCPU1.B6
  BOTTOM w0.102: JDIMM1.174 145.74,28.96 v3(146.17,29.39)
DDR_A_D55: length 59.6
  IN4 w0.102: v3(146.17,30.91) 145.77,31.32 145.77,34.82 148.5,37.56 148.5,40.55 150.54,42.59 150.54,62.29 150.03,62.81 150.03,71.7 147.95,73.78 147.95,79.09 145.84,81.2 v3(145.47,81.2)
  BOTTOM w0.089: v3(145.47,81.2) 145,80.73 JCPU1.A6
  BOTTOM w0.102: JDIMM1.176 146.34,28.67 146.7,29.03 146.7,30.38 v3(146.17,30.91)
DDR_A_D56: length 70.3
  IN4 w0.102: v3(150.03,39.09) 150.43,39.5 150.43,40.47 151.96,42 151.96,62.88 151.45,63.4 151.45,72.46 149.37,74.53 149.37,80.19 149.25,80.32 148.97,80.32 148.85,80.45 148.85,83.32 148.72,83.45 148.36,83.45 148.26,83.35 148.26,81.59 148.13,81.46 147.88,81.46 147.75,81.59 147.75,83.35 147.65,83.45 147.35,83.45 147.25,83.35 147.25,82.58 147.14,82.48 146.84,82.48 146.74,82.58 146.74,83.35 146.64,83.45 145.27,83.45 144.91,83.81 144.32,83.81 144.07,84.06 144.07,84.42 143.69,84.8 143.3,84.8 143.07,85.03 143.07,85.48 142.88,85.67 142.88,86.5 142.75,86.63 140.96,86.63 140.83,86.76 140.83,87.07 140.96,87.2 v3(141.47,87.2)
  BOTTOM w0.089: v3(141.47,87.2) 141,86.73 JCPU1.E12
  BOTTOM w0.102: JDIMM1.181 147.84,36.72 147.97,36.84 148.47,36.84 148.6,36.97 148.6,38.97 148.72,39.09 148.96,39.09 149.09,38.97 149.09,38.77 149.22,38.65 149.5,38.65 149.63,38.77 149.63,38.97 149.75,39.09 v3(150.03,39.09)
DDR_A_D57: length 70.7
  IN4 w0.102: v3(150.03,37.57) 150.81,38.35 150.81,40.42 152.27,41.87 152.27,63.01 151.75,63.52 151.75,72.69 150.58,73.87 150.47,73.87 149.68,74.66 149.68,78.1 149.81,78.22 150.62,78.22 150.75,78.35 150.75,78.74 150.65,78.85 149.9,78.85 149.8,78.95 149.8,79.25 149.9,79.35 151.13,79.35 151.26,79.48 151.26,79.73 151.13,79.86 149.9,79.86 149.8,79.96 149.8,80.27 149.9,80.37 150.65,80.37 150.75,80.47 150.75,80.78 150.65,80.88 149.28,80.88 149.15,81 149.15,81.26 149.28,81.39 150.56,81.39 150.69,81.51 150.69,81.78 150.56,81.91 149.44,81.91 149.31,82.03 149.31,82.29 149.41,82.39 149.74,82.39 149.86,82.52 149.86,82.78 149.74,82.9 149.41,82.9 149.31,83 149.31,83.33 148.82,83.82 145.31,83.82 144.87,84.26 144.87,84.34 144.61,84.6 144.46,84.6 143.87,85.19 143.87,85.34 143.61,85.6 143.42,85.6 143.08,85.93 143.08,86.59 v3(142.47,87.2)
  BOTTOM w0.089: v3(142.47,87.2) 142,86.73 JCPU1.D12
  BOTTOM w0.102: v3(150.03,37.57) 149.78,37.57 148.44,36.23 JDIMM1.183
DDR_A_D58: length 70.6
  IN4 w0.102: v3(152.57,39.09) 153.01,39.09 153.1,39 153.1,35.36 153.23,35.23 153.68,35.23 153.8,35.36 153.8,71.5 156.76,74.46 156.76,77.66 153.74,80.69 153.74,81.28 148.02,87 146.25,87 145.87,86.61 145.1,86.61 144.68,86.2 v3(144.47,86.2)
  BOTTOM w0.089: v3(144.47,86.2) 144,85.73 JCPU1.B11
  BOTTOM w0.102: JDIMM1.191 150.84,37.36 v3(152.57,39.09)
DDR_A_D59: length 69.5
  IN4 w0.102: v3(152.57,37.57) 152.57,37.32 152.44,37.19 152.17,37.19 152.05,37.32 152.05,39.91 152.45,40.31 152.82,40.31 152.95,40.19 152.95,39.99 153.08,39.87 153.37,39.87 153.5,39.99 153.5,71.62 156.46,74.58 156.46,77.54 152.34,81.65 152.34,82.04 149.07,85.31 148.95,85.31 148.85,85.41 148.85,85.73 148.73,85.86 148.47,85.86 148.35,85.73 148.35,85.44 148.22,85.31 147.96,85.31 147.84,85.44 147.84,86.57 147.71,86.69 147.46,86.69 147.33,86.57 147.33,85.44 147.2,85.31 146.95,85.31 146.82,85.44 146.82,86.57 146.69,86.69 146.44,86.69 146.31,86.57 146.31,85.27 146.19,85.14 145.99,85.14 145.86,85.27 145.86,85.52 145.73,85.65 145.23,85.65 145.1,85.78 145.1,86.07 145.23,86.2 v3(145.47,86.2)
  BOTTOM w0.089: v3(145.47,86.2) 145,85.73 JCPU1.A11
  BOTTOM w0.102: JDIMM1.193 151.44,36.44 v3(152.57,37.57)
