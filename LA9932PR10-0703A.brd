# Allegro board LA9932PR10-0703A.brd (continued)
## Nets (continued)
FB: PR533.2 PR537.2 PR543.2 PU500.8
FB2/VSEN: PR529.2 PU500.9
FB_+1.05VSP: PR306.2 PR307.2 PU300.4
FB_PCIE: PC668.2 PR683.2 PR684.1 PU602.6
FB_VGA: PC613.2 PR639.1 PR640.1 PR642.2 PR644.1 PU600.8
FC_G6: JCPU1.G6 RC68.1 RC69.2
FDI_CSYNC: JCPU1.H29 UH1.AL39
FDI_CTX_PRX_N0: JCPU1.P33 UH1.AJ35
FDI_CTX_PRX_N1: JCPU1.N32 UH1.AL35
FDI_CTX_PRX_P0: JCPU1.R33 UH1.AJ36
FDI_CTX_PRX_P1: JCPU1.P32 UH1.AL36
FDI_INT: JCPU1.J29 UH1.AL40
FDI_IREF: RH96.2 UH1.AT45
FDI_RCOMP: RH99.2 UH1.AR44
FFS_INT2: Q29.2 U88.9 UH1.AN4
FFS_INT2_Q: JSATA1.18 Q29.3 R506.2
FFS_PCH_INT: RH106.2 UH1.M15
FWP#: R872.2 R879.2 U51.B65
GFX_CLK_REQ#: QH3.1 RPH18.4 RV52.1 UH1.AF6
GFX_CLK_REQ#_R: RV52.2 UV1.N7
GFX_MEM_VTT_EN: CV129.1 QV1.4 QV2.1 RV67.2 RV80.1
GPIO_PSID_SELECT: PU1.6 U46.A6
GPU_HOT#: CV358.1 PR633.2 QV8.1 RV76.2 RV103.2 UV1.T9
GPU_JTAG_TCK: RV88.2 UV1.L3
GPU_JTAG_TDI: RPV1.3 UV1.L5
GPU_JTAG_TDO: RPV1.4 UV1.K4
GPU_JTAG_TMS: RPV1.2 UV1.L1
GPU_JTAG_TRSTB: RPV1.1 UV1.L6
GPU_PSI#: PR631.1 UV1.U6
GPU_PWR_LEVEL: RV76.1 U46.A52
GPU_SMBCLK: RP14.5 U51.B49
GPU_SMBDAT: RP14.6 U51.B48
GPU_THERMAL_INT: RV53.1 UV1.R6
GPU_VID0: PR610.2 PR628.1 PU600.32
GPU_VID1: PR608.1 PR625.1 PU600.33
GPU_VID2: PR605.2 PR621.1 PU600.34
GPU_VID3: PR604.1 PR618.1 PU600.35
GPU_VID4: PR602.1 PR620.1 PU600.36
GPU_VID_0: PR628.2 UV1.P2
GPU_VID_1: PR625.2 UV1.M4
GPU_VID_2: PR621.2 UV1.N1
GPU_VID_3: PR618.2 UV1.P8
GPU_VID_4: PR620.2 UV1.P7
GREEN_CRT: JIO1.5 U6.25
GREEN_DOCK: JDOCK1.59 U6.24
H_CATERR#: JCPU1.AN32 RC28.2
H_CPU_RSVD: JCPU1.G26 RC82.1
H_CPU_SVIDALRT#: JCPU1.AM28 RC88.1
H_CPU_TESTLO: JCPU1.W34 RC80.1
H_CPUPWRGD: RC20.1 RC33.1 UH1.AV3
H_CPUPWRGD_XDP: JXDP1.10 RC20.2
H_PM_SYNC: JCPU1.AT28 UH1.AY3
H_PROCHOT#: PC510.1 PQ805.3 PR524.1 PR724.2 Q47.1 QV8.3 R1180.2 RC29.2 RC30.1
H_PROCHOT#_R: JCPU1.AM30 RC30.2
H_THERMTRIP#: Q4.3 RC27.2 RC31.1
H_THERMTRIP#_R: JCPU1.AM35 RC31.2
HDD_DET#: JSATA1.12 RH11.1 RPH20.6 UH1.AT1
HDD_FALL_INT: R503.2 RH106.1 U88.11
HDMI_BUF: R79.2 R81.1 U19.14
HDMI_CEC: JHDMI1.13 R73.2
HDMI_EQ: R80.2 R82.1 U19.17
HDMI_HPD_SINK: JHDMI1.19 U19.28
HDMI_ISET: R85.2 R87.1 U19.34
HDMI_PRE: R86.2 R88.1 U19.16
HDMI_SCL_SINK: JHDMI1.15 R69.2 U19.32
HDMI_SDA_SINK: JHDMI1.16 R70.2 U19.33
HDMIB_PCH_HPD: R75.1 U19.3 UH1.K40
HOST_DEB_TX: JDEG2.8 R853.1
HOST_DEBUG_RX: RP7.7 U51.B46
HOST_DEBUG_TX: C595.1 JMINI2.16 R853.2 RP12.2 U51.B44
HSYNC: RH94.2 UH1.N42
HSYNC_BUF: JIO1.6 U6.20
HSYNC_DOCK: JDOCK1.65 U6.19
HW_GPS_DISABLE2#: JMINI1.51 RP2.8 U46.B34
I2S_BCLK: R1668.2 U74.16
I2S_DO: R1097.2 U74.17
I2S_MCLK: R1654.2 U74.15
ICLK_IREF: RH163.1 UH1.AM45
IMON: PC500.2 PR521.1 PU500.4
IMVP_PWRGD: PR519.1 PU500.3 U46.A62
IMVP_VR_ON: PR511.1 U46.B66
INT_SPK_L+: C973.1 L702.1 U74.40
INT_SPK_L-: C974.1 L703.1 U74.41
INT_SPK_R+: C975.1 L704.1 U74.44
INT_SPK_R-: C976.1 L705.1 U74.43
INT_SPKL_L+: JSPK1.1 L702.2
INT_SPKL_L-: JSPK1.2 L703.2
INT_SPKR_R+: JSPK1.3 L704.2
INT_SPKR_R-: JSPK1.4 L705.2
INTRUDER#: RH43.2 UH1.A8
IRQ_SERIRQ: RPH18.2 U39.27 U46.B21 U51.A28 UH1.AL11
ISEN1: PC539.2 PR553.2 PR555.1 PU500.12
ISEN1_VGA: PC616.1 PR652.2 PR656.1 PU600.11
ISEN2: PC540.2 PR538.2 PR546.1 PU500.11
ISEN2_VGA: PC615.1 PR623.2 PR626.1 PU600.10
ISUM-_VGA: PR659.1 PU600.14
ISUMN: PC528.1 PC539.1 PC540.1 PC547.1 PH501.1 PR535.1 PR544.2 PR545.1 PR548.1 PR549.1 PR556.2
ISUMP: PC528.2 PC529.2 PC538.2 PR536.1 PR549.2 PR551.2 PR552.1 PR558.1 PU500.15
JTAG_CLK: JDEG2.4 RP11.3 U51.B56
JTAG_RST#: C735.1 JTAG1.1 R836.1 RP16.2 U51.A57
JTAG_TDI: JDEG2.2 RP11.1 U51.A51
JTAG_TDO: JDEG2.5 RP11.4 U51.B55
JTAG_TMS: JDEG2.3 RP11.2 U51.A53
KB_DET#: JKB1.1 RPH15.3 UH1.U12
LAN_ACTLED_YEL#: Q325.1 U32.17
LAN_ACTLED_YEL#_Q: Q325.6 R1166.1
LAN_DISABLE#_R: R549.2 R555.2 R557.1 U31.3 U46.B47
LAN_SMBCLK: R551.1 RH174.2 UH1.U8
LAN_SMBCLK_R: R551.2 U31.28
LAN_SMBDATA: R552.1 RH175.2 UH1.R7
LAN_SMBDATA_R: R552.2 U31.31
LAN_TEST_EN: R561.1 U31.30
LAN_TX0+: R3770.1 U31.13
LAN_TX0+R: R3770.2 U32.12
LAN_TX0-: R3769.1 U31.14
LAN_TX0-R: R3769.2 U32.11
LAN_TX1+: R3768.1 U31.17
LAN_TX1+R: R3768.2 U32.10
LAN_TX1-: R3767.1 U31.18
LAN_TX1-R: R3767.2 U32.9
LAN_TX2+: R3766.1 U31.20
LAN_TX2+R: R3766.2 U32.7
LAN_TX2-: R3765.1 U31.21
LAN_TX2-R: R3765.2 U32.6
LAN_TX3+: R3764.1 U31.23
LAN_TX3+R: R3764.2 U32.3
LAN_TX3-: R3763.1 U31.24
LAN_TX3-R: R3763.2 U32.2
LANCLK_REQ#: R1187.1 RH20.1 RPH18.3 UH1.AF1
LANCLK_REQ#_R: R1187.2 U31.48
LANWAKE#: R558.2 R566.1 RH196.2 U31.2 U51.B27
LAT_ON_SW#: RP15.4 U51.B63
LCD_CBL_DET#: JLVDS1.40 RPH6.1 UH1.G17
LCD_EDID_CLK: JLVDS1.35 R160.2 U27.46
LCD_EDID_DATA: JLVDS1.34 R159.2 U27.45
LCD_ENVDD_CVT: D7.2 U27.20
LCD_SMBCLK: R418.2 U51.B5
LCD_SMBDAT: R420.2 U51.A4
LCD_TST: JLVDS1.36 RP19.4 U46.A36
LCD_VCC_TEST_EN: D7.3 U46.A40
LED_10_GRN#: Q326.3 U32.41
LED_10_GRN#_Q: Q326.1 R1653.1
LED_100_ORG#: Q325.4 U32.18
LED_100_ORG#_Q: Q325.3 R1167.1
LED_SATA_DIAG_OUT#: D62.1 U46.A10
LED_WWAN_OUT#: JMINI1.42 Q77.3 R719.1
LG_3V: PQ103.4 PU100.11
LG_5V: PQ104.4 PU100.15
LG_+1.05VSP: PQ303.4 PU300.6
LGATE1: PQ512.4 PU500.21
LGATE1_VGA: PQ601.4 PU600.23
LGATE2: PQ508.4 PU500.24
LGATE2_VGA: PQ600.4 PU600.26
LID_CL#: JSF1.2 R807.1 U58.2
LID_CL_SIO#: C716.1 R807.2 RP19.1 U46.B54
LOM_ACTLED_YEL#: U31.26 U32.15
LOM_SPD10LED_GRN#: U15.2 U31.25 U32.42
LOM_SPD100LED_ORG#: U15.1 U31.27 U32.16
LPC_LAD0: JMINI3.16 U39.26 U46.A27 U51.A30 UH1.A20
LPC_LAD1: JMINI3.14 U39.23 U46.A26 U51.B32 UH1.C20
LPC_LAD2: JMINI3.12 U39.20 U46.B26 U51.A31 UH1.A18
LPC_LAD3: JMINI3.10 U39.17 U46.B25 U51.B33 UH1.C18
LPC_LDRQ0#: T87.1(TP-1) UH1.D21
LPC_LDRQ1#: U46.A22 UH1.G20
LPC_LFRAME#: JMINI3.8 U39.22 U46.A21 U51.B31 UH1.B21
LX_PCIE: PC667.1 PL603.1 PU602.1 PU602.2 PU602.3
M_CLK_DDR0: JCPU1.V4 JDIMM1.101
M_CLK_DDR1: JCPU1.V3 JDIMM1.102
M_CLK_DDR2: JCPU1.AA4 JDIMM2.101
M_CLK_DDR3: JCPU1.AA3 JDIMM2.102
M_CLK_DDR#0: JCPU1.U4 JDIMM1.103
M_CLK_DDR#1: JCPU1.U3 JDIMM1.104
M_CLK_DDR#2: JCPU1.Y4 JDIMM2.103
M_CLK_DDR#3: JCPU1.Y3 JDIMM2.104
M_ODT0: JCPU1.M8 JDIMM1.116
M_ODT1: JCPU1.L7 JDIMM1.120
M_ODT2: JCPU1.R4 JDIMM2.116
M_ODT3: JCPU1.R3 JDIMM2.120
MAA0_0: UV1.K17 UV4.H4 UV5.K4
MAA0_1: UV1.J20 UV4.H5 UV5.K5
MAA0_2: UV1.H23 UV4.H11 UV5.K11
MAA0_3: UV1.G23 UV4.H10 UV5.K10
MAA0_4: UV1.G24 UV4.K11 UV5.H11
MAA0_5: UV1.H24 UV4.K10 UV5.H10
MAA0_6: UV1.J19 UV4.K5 UV5.H5
MAA0_7: UV1.K19 UV4.K4 UV5.H4
MAA0_8: UV1.G20 UV4.J5 UV5.J5
MAA1_0: UV1.J14 UV3.K4 UV6.H4
MAA1_1: UV1.K14 UV3.K5 UV6.H5
MAA1_2: UV1.J11 UV3.K11 UV6.H11
MAA1_3: UV1.J13 UV3.K10 UV6.H10
MAA1_4: UV1.H11 UV3.H11 UV6.K11
MAA1_5: UV1.G11 UV3.H10 UV6.K10
MAA1_6: UV1.J16 UV3.H5 UV6.K5
MAA1_7: UV1.L15 UV3.H4 UV6.K4
MAA1_8: UV1.G14 UV3.J5 UV6.J5
MASK_BASE_LEDS#: Q74.2 Q83.2 Q83.5 Q84.2 Q100.2 U58.4
MASK_SATA_LED#: Q74.5 U46.B9
MCARD_MISC_PWREN: R733.1 U46.B53 U145.5
MCARD_PCIE_SATA#: RH16.1 RH224.2 RH226.1 U46.B3 UH1.AN2
MCARD_WWAN_PWREN: R726.1 U46.B42 U145.3
ME_FWP: R793.1 RH45.1 U46.A8
ME_RESET#: RH70.1 RH93.2 UC3.2
ME_SUS_PWR_ACK: RH75.2 RH107.1 U51.A8
ME_SUS_PWR_ACK_R: RH91.1 RH107.2 UH1.J4
MEC_XTAL1: C743.1 U51.A61 Y6.1
MEC_XTAL2: C741.1 R1068.2 Y6.2
MEC_XTAL2_R: R1068.1 U51.A62
MEM_SMBCLK: QH4.6 RPH12.3 UH1.R10
MEM_SMBDATA: QH4.3 RPH12.4 UH1.U11
MIIC_SCL0: R105.1 R106.2 U27.48
MIIC_SDA0: R107.1 R108.2 U27.47
MINI1CLK_REQ#: JMINI1.7 RPH21.5 UH1.AB1
MINI2CLK_REQ#: JMINI2.7 RPH8.2 UH1.AA2
MINI3CLK_REQ#: JMINI3.7 RPH3.1 UH1.T3
MMICLK_REQ#: RH22.1 RPH20.5 U38.17 UH1.AF3
MOD_MD: JSATA2.11 Q76.4 Q123.4 RP18.7
MOD_SATA_PCIE#_DET: JSATA2.31 Q123.2 RP18.6 U46.A42
MODC_EN: Q76.2 R512.1 U37.3 U46.B7
MODC_EN#: Q76.5 Q76.6 R517.2
MODULE_BATT_PRES#: PR727.2 U46.B15
MSCLK: JDEG2.6 JMINI2.19 RP12.1 U51.B43
MSDATA: JDEG2.7 JMINI2.14 R706.2 R850.2 RP17.6 U51.A40
MULTIO_0: R1700.2 U38.18
NB_LAN_TX0+: JLOM1.1 T156.24
NB_LAN_TX0-: JLOM1.2 T156.23
NB_LAN_TX1+: JLOM1.3 T156.20
NB_LAN_TX1-: JLOM1.6 T156.19
NB_LAN_TX2+: JLOM1.4 T156.18
NB_LAN_TX2-: JLOM1.5 T156.17
NB_LAN_TX3+: JLOM1.7 T156.14
NB_LAN_TX3-: JLOM1.8 T156.13
NB_PSID: PJPDC1.5 PL4.2
NB_PSID_TS5A63157: PR11.1 PR12.2 PU1.3
NTC: PR525.2 PU500.6
NTC_VGA: PH600.2 PU600.5
OP_5V: PC725.1 PR745.2 PU701.8
OZ_LDO_EN: R894.2 U38.14
OZ_PE_REXT: R677.2 U38.4
P33ALW: PR868.1 PU800.18
P33ALW2: PR862.2 PU800.9
PANEL_BKEN_CVT: R1139.1 U27.44 U54.1
PANEL_BKEN_EC: D10.3 U46.A35
PANEL_BKEN_PCH: U54.2 UH1.K36
PANEL_HDD_LED: JLVDS1.8 Q81.3
PBAT_PRES#: PD7.1 PQ812.1 PR6.2 PRP2.1 PU804.1 U46.B40
PBAT_SMBCLK: PRP2.3 RP14.7 U51.A56
PBAT_SMBDAT: PRP2.2 RP14.8 U51.B59
PCH_ALW_ON: RP9.6 U51.A23 U146.3
PCH_AZ_BITCLK: RPH10.8 UH1.B25
PCH_AZ_CODEC_BITCLK: R1076.1 RPH10.1 U74.6
PCH_AZ_CODEC_RST#: R39.1 RPH10.3 U74.11
PCH_AZ_CODEC_SDIN0: R1096.1 UH1.L22
PCH_AZ_CODEC_SDOUT: RPH10.2 U74.5
PCH_AZ_CODEC_SYNC: RPH10.4 U74.10
PCH_AZ_RST#: RPH10.6 UH1.C24
PCH_AZ_SDIN0_R: R1096.2 U74.8
PCH_AZ_SDOUT: RH35.2 RH45.2 RPH10.7 UH1.A24
PCH_AZ_SYNC: RPH10.5 UH1.A22
PCH_BATLOW#: RH112.2 UH1.K7
PCH_CL_CLK1: JMINI2.45 UH1.AF11
PCH_CL_DATA1: JMINI2.47 UH1.AF10
PCH_CL_RST1#: R707.2 UH1.AF7
PCH_CLK_BIASREF: RH165.1 UH1.AN44
PCH_CRT_BLU: RPH17.6 U6.5 UH1.T45
PCH_CRT_DDC_CLK: RH88.2 U6.10 UH1.M43
PCH_CRT_DDC_DAT: RH89.2 U6.9 UH1.M45
PCH_CRT_GRN: RPH17.7 U6.2 UH1.U44
PCH_CRT_HSYNC: RH94.1 U6.6
PCH_CRT_RED: RPH17.8 U6.1 UH1.V45
PCH_CRT_VSYNC: RH95.1 U6.7
PCH_DDPB_CTRLCLK: RH255.2 U19.38 UH1.R40
PCH_DDPB_CTRLDATA: RH256.2 U19.39 UH1.R39
PCH_DDPC_CTRLCLK: RP1.8 U20.12 UH1.R35
PCH_DDPC_CTRLDATA: RP1.7 U20.9 UH1.R36
PCH_DDPD_CTRLCLK: RP1.6 U23.12 UH1.N40
PCH_DDPD_CTRLDATA: RP1.5 U23.9 UH1.N38
PCH_DPWROK: R802.1 RH79.1 RH120.2 UH1.L13
PCH_GPIO06: RPH19.2 UH1.A14
PCH_GPIO07: RPH6.4 UH1.G15
PCH_GPIO15: RPH15.1 UH1.AB11
PCH_GPIO22: R3771.1 RH331.2 RH332.2 UH1.BB4
PCH_GPIO24: RPH15.2 UH1.Y10
PCH_GPIO33: RH40.2 UH1.B17
PCH_GPIO34: RPH14.2 UH1.AN6
PCH_GPIO35: RH25.1 RPH16.1 UH1.AP1
PCH_GPIO36: RH12.1 RH228.1 RH230.1 UH1.AT3
PCH_GPIO37: RH14.1 RH229.2 RH231.1 UH1.AK1
PCH_GPIO49: RH19.1 RH225.1 RH227.1 UH1.AK3
PCH_GPIO55: RH76.1 UH1.AL6
PCH_GPIO69: RPH13.4 UH1.D13
PCH_GPIO70: RPH13.2 UH1.G13
PCH_GPIO71: RPH13.1 UH1.H15
PCH_INTVRMEN: RH5.2 UH1.G10
PCH_JTAG_RST: RH32.2 UH1.AB6
PCH_JTAG_RST_R: JXDP2.54 RH32.1
PCH_JTAG_TCK: JXDP2.57 RH47.1 UH1.AB3
PCH_JTAG_TDI: JXDP2.56 RH50.2 RH55.1 UH1.AE2
PCH_JTAG_TDO: JXDP2.52 RH52.2 RH56.1 UH1.AD3
PCH_JTAG_TMS: JXDP2.58 RH48.2 RH54.1 UH1.AD1
PCH_PCIE_IREF: RH188.2 UH1.BE30
PCH_PCIE_RCOMP: RH192.2 UH1.BD29
PCH_PCIE_WAKE#: RH78.2 RH92.2 U51.A44 UH1.K3
PCH_PLTRST#: QH2.2 RH109.2 RH110.2 RH111.2 RH113.2 RH114.2 UC2.2 UH1.Y11 UH3.1 UH3.2
PCH_PLTRST#_BUF: RC60.2 RC64.1 RC67.1 UC2.4
PCH_PLTRST#_EC: JMINI3.17 JMINI3.22 R703.1 R704.1 U39.16 U41.6 U46.B22 U51.B30 UH3.4
PCH_PWRBTN#_XDP: JXDP2.41 RH28.2
PCH_PWROK: RH103.2 UH1.F10
PCH_RI#: RPH1.1 UH1.N4
PCH_RSMRST#: R1623.1 RP17.5 U9.1 U51.B47
PCH_RSMRST#_Q: R1623.2 R1624.1 R1636.2 RH26.1 RH105.1 U9.4
PCH_RSMRST#_R: RH79.2 RH105.2 UH1.J2
PCH_RTCRST#: CH7.2 CMOS1.2 JAPS1.9 RH44.2 UH1.D9
PCH_RTCX1: RH38.2 RH39.1 UH1.B5
PCH_RTCX1_R: CH4.2 RH38.1 YH1.1
PCH_RTCX2: CH5.2 RH39.2 UH1.B4 YH1.2
PCH_SATA_MOD_EN#: QH2.3 U51.B36
PCH_SMB_ALERT#: RPH21.6 UH1.N7
PCH_SPI_CLK: JSPI1.8 RH181.2 UH1.AJ11
PCH_SPI_CS0#: JSPI1.10 RH182.2 UH1.AJ7
PCH_SPI_CS1#: JSPI1.2 RH177.2 UH1.AL7
PCH_SPI_DIN: JSPI1.6 RH179.2 UH1.AH3
PCH_SPI_DO: JSPI1.4 RH178.2 UH1.AH1
PCH_SPI_DO2: JSPI1.12 RH183.2 UH1.AJ4
PCH_SPI_DO3: JSPI1.14 RH184.2 UH1.AJ2
PCH_TD_IREF: RH176.1 UH1.AY43
PCH_THRMTRIP#_R: CH17.1 RH206.2 UH1.AV1
PCH_TP25: RH53.2 UH1.F8
PCI_5048: RH158.1 UH1.D44
PCI_DOCK: RH162.1 UH1.B42
PCI_LOOPBACKOUT: RH164.1 UH1.A40
PCI_MEC: RH160.1 UH1.E44
PCI_PIRQA#: RPH4.1 UH1.H20
PCI_PIRQB#: RPH4.2 UH1.L20
PCI_PIRQC#: RPH4.3 UH1.K17
PCI_PIRQD#: RPH4.4 UH1.M20
PCI_TPM_TCM: RH155.2 UH1.C40
PCIE_B+: PC660.1 PC680.1 PJP609.1 PU602.8 PU602.9 PU602.10
PCIE_PRX_EMBTX_N4: JSATA2.19 UH1.AT33
PCIE_PRX_EMBTX_P4: JSATA2.18 UH1.AR33
PCIE_PRX_EXPTX_N7: JEXP1.15 UH1.AT40
PCIE_PRX_EXPTX_P7: JEXP1.17 UH1.AT39
PCIE_PRX_GLANTX_N2: C459.2 UH1.AT31
PCIE_PRX_GLANTX_N2_C: C459.1 U31.39
PCIE_PRX_GLANTX_P2: C458.2 UH1.AR31
PCIE_PRX_GLANTX_P2_C: C458.1 U31.38
PCIE_PRX_MMITX_N8: C571.1 UH1.AN38
PCIE_PRX_MMITX_N8_C: C571.2 U38.8
PCIE_PRX_MMITX_P8: C569.1 UH1.AN39
PCIE_PRX_MMITX_P8_C: C569.2 U38.7
PCIE_PRX_WLANTX_N3: JMINI2.23 UH1.AW33
PCIE_PRX_WLANTX_P3: JMINI2.25 UH1.AY33
PCIE_PRX_WPANTX_N6: JMINI3.23 UH1.AY38
PCIE_PRX_WPANTX_P6: JMINI3.25 UH1.AW38
PCIE_PTX_EMBRX_N4: C408.2 UH1.BE36
PCIE_PTX_EMBRX_N4_C: C408.1 JSATA2.23
PCIE_PTX_EMBRX_P4: C409.2 UH1.BC36
PCIE_PTX_EMBRX_P4_C: C409.1 JSATA2.22
PCIE_PTX_EXPRX_N7: JEXP1.21 UH1.BE40
PCIE_PTX_EXPRX_P7: JEXP1.23 UH1.BC40
PCIE_PTX_GLANRX_N2: C461.1 UH1.BD33
PCIE_PTX_GLANRX_N2_C: C461.2 U31.42
PCIE_PTX_GLANRX_P2: C460.1 UH1.BB33
PCIE_PTX_GLANRX_P2_C: C460.2 U31.41
PCIE_PTX_MMIRX_N8: C568.1 UH1.BD42
PCIE_PTX_MMIRX_N8_C: C568.2 U38.5
PCIE_PTX_MMIRX_P8: C567.1 UH1.BD41
PCIE_PTX_MMIRX_P8_C: C567.2 U38.6
PCIE_PTX_WLANRX_N3: C596.1 UH1.BE34
PCIE_PTX_WLANRX_N3_C: C596.2 JMINI2.31
PCIE_PTX_WLANRX_P3: C598.1 UH1.BC34
PCIE_PTX_WLANRX_P3_C: C598.2 JMINI2.33
PCIE_PTX_WPANRX_N6: C617.1 UH1.BC38
PCIE_PTX_WPANRX_N6_C: C617.2 JMINI3.31
PCIE_PTX_WPANRX_P6: C618.1 UH1.BE38
PCIE_PTX_WPANRX_P6_C: C618.2 JMINI3.33
PCIE_SATA_PRX_WANTX_N4: JMINI1.25 UH1.BD13
PCIE_SATA_PRX_WANTX_P4: JMINI1.23 UH1.BB13
PCIE_SATA_PTX_WANRX_N4: C417.2 UH1.AV15
PCIE_SATA_PTX_WANRX_N4_C: C417.1 JMINI1.31
PCIE_SATA_PTX_WANRX_P4: C416.2 UH1.AW15
PCIE_SATA_PTX_WANRX_P4_C: C416.1 JMINI1.33
PCIE_WAKE#: JEXP1.14 JMINI1.1 JMINI2.1 JMINI3.1 JSATA2.27 RP7.8 U38.16 U51.B38
PCIECLKRQ6#: RPH8.1 UH1.AE4
PCLK_80H: JMINI3.19 RH159.1
PECI_EC: JCPU1.AR27 R952.2
PECI_EC_R: C290.1 R952.1 U51.A48
PEG_B_CLKRQ#: RPH8.3 UH1.U4
PEG_COMP: JCPU1.E23 RC1.2
PEG_CRX_GTX_C_N0: CV2.1 UV1.AG31
PEG_CRX_GTX_C_N1: CV3.1 UV1.AF28
PEG_CRX_GTX_C_N2: CV6.1 UV1.AF26
PEG_CRX_GTX_C_N3: CV8.1 UV1.AD26
PEG_CRX_GTX_C_N4: CV10.1 UV1.AB25
PEG_CRX_GTX_C_N5: CV12.1 UV1.Y24
PEG_CRX_GTX_C_N6: CV15.1 UV1.AB26
PEG_CRX_GTX_C_N7: CV17.1 UV1.Y26
PEG_CRX_GTX_C_P0: CV1.1 UV1.AH30
PEG_CRX_GTX_C_P1: CV4.1 UV1.AG29
PEG_CRX_GTX_C_P2: CV5.1 UV1.AF27
PEG_CRX_GTX_C_P3: CV7.1 UV1.AD27
PEG_CRX_GTX_C_P4: CV9.1 UV1.AC25
PEG_CRX_GTX_C_P5: CV11.1 UV1.Y23
PEG_CRX_GTX_C_P6: CV14.1 UV1.AB27
PEG_CRX_GTX_C_P7: CV16.1 UV1.Y27
PEG_CRX_GTX_N0: CV2.2 JCPU1.M29
PEG_CRX_GTX_N1: CV3.2 JCPU1.K28
PEG_CRX_GTX_N2: CV6.2 JCPU1.M31
PEG_CRX_GTX_N3: CV8.2 JCPU1.L30
PEG_CRX_GTX_N4: CV10.2 JCPU1.M33
PEG_CRX_GTX_N5: CV12.2 JCPU1.L32
PEG_CRX_GTX_N6: CV15.2 JCPU1.M35
PEG_CRX_GTX_N7: CV17.2 JCPU1.L34
PEG_CRX_GTX_P0: CV1.2 JCPU1.L29
PEG_CRX_GTX_P1: CV4.2 JCPU1.L28
PEG_CRX_GTX_P2: CV5.2 JCPU1.L31
PEG_CRX_GTX_P3: CV7.2 JCPU1.K30
PEG_CRX_GTX_P4: CV9.2 JCPU1.L33
PEG_CRX_GTX_P5: CV11.2 JCPU1.K32
PEG_CRX_GTX_P6: CV14.2 JCPU1.L35
PEG_CRX_GTX_P7: CV16.2 JCPU1.K34
PEG_CTX_GRX_C_N0: CC2.2 JCPU1.H35
PEG_CTX_GRX_C_N1: CC4.2 JCPU1.H34
PEG_CTX_GRX_C_N2: CC6.2 JCPU1.J33
PEG_CTX_GRX_C_N3: CC8.2 JCPU1.H32
PEG_CTX_GRX_C_N4: CC10.2 JCPU1.J31
PEG_CTX_GRX_C_N5: CC12.2 JCPU1.G30
PEG_CTX_GRX_C_N6: CC14.2 JCPU1.C33
PEG_CTX_GRX_C_N7: CC16.2 JCPU1.B32
PEG_CTX_GRX_C_P0: CC1.2 JCPU1.J35
PEG_CTX_GRX_C_P1: CC3.2 JCPU1.G34
PEG_CTX_GRX_C_P2: CC5.2 JCPU1.H33
PEG_CTX_GRX_C_P3: CC7.2 JCPU1.G32
PEG_CTX_GRX_C_P4: CC9.2 JCPU1.H31
PEG_CTX_GRX_C_P5: CC11.2 JCPU1.H30
PEG_CTX_GRX_C_P6: CC13.2 JCPU1.B33
PEG_CTX_GRX_C_P7: CC15.2 JCPU1.A32
PEG_CTX_GRX_N0: CC2.1 UV1.AE31
PEG_CTX_GRX_N1: CC4.1 UV1.AD28
PEG_CTX_GRX_N2: CC6.1 UV1.AC31
PEG_CTX_GRX_N3: CC8.1 UV1.AB28
PEG_CTX_GRX_N4: CC10.1 UV1.AA31
PEG_CTX_GRX_N5: CC12.1 UV1.Y28
PEG_CTX_GRX_N6: CC14.1 UV1.W31
PEG_CTX_GRX_N7: CC16.1 UV1.V28
PEG_CTX_GRX_P0: CC1.1 UV1.AF30
PEG_CTX_GRX_P1: CC3.1 UV1.AE29
PEG_CTX_GRX_P2: CC5.1 UV1.AD30
PEG_CTX_GRX_P3: CC7.1 UV1.AC29
PEG_CTX_GRX_P4: CC9.1 UV1.AB30
PEG_CTX_GRX_P5: CC11.1 UV1.AA29
PEG_CTX_GRX_P6: CC13.1 UV1.Y30
PEG_CTX_GRX_P7: CC15.1 UV1.W29
PH2_VGA: PC605.2 PQ600.3 PU600.28
PHASE1: PC542.2 PC543.1 PL503.2 PQ509.1 PQ509.2 PQ509.3 PQ512.5 PR552.2 PR553.1 PU500.20
PHASE1_VGA: PC623.2 PC631.1 PL601.2 PQ601.5 PQ601.6 PQ601.7 PR651.1 PR652.1 PU600.21
PHASE2: PC522.2 PC524.1 PL502.2 PQ505.1 PQ505.2 PQ505.3 PQ508.5 PR536.2 PR538.1 PU500.25
PHASE2_VGA: PC607.1 PL600.2 PQ600.5 PQ600.6 PQ600.7 PR619.1 PR623.1
PLTRST_EMB#: JSATA2.28 RH113.1
PLTRST_GPU#: RH114.1 UV14.2
PLTRST_LAN#: RH111.1 U31.36
PLTRST_MMI#: RH110.1 U38.15
PLTRST_USH#: JUSH1.6 RH109.1
PM_APWROK: RH87.1 U51.A9 UH2.2
PM_APWROK_R: RH87.2 UH1.AB7 UH2.4
PM_DRAM_PWRGD: RC13.2 RH104.1
PM_DRAM_PWRGD_A: RC12.2 RC13.1 UC1.2
PM_DRAM_PWRGD_CPU: JCPU1.AC10 QC5.3 RC10.1
PM_DRAM_PWRGD_R: RH104.2 UH1.H3
PM_LANPHY_ENABLE: R555.1 RPH21.8 UH1.K13
POWER_SW#_MB: C721.1 C1558.1 JAPS1.11 R811.2 SW1.2 SW1.4
POWER_SW_IN#: C722.1 R811.1 RP15.3 U51.B67
PROCHOT#_EC: Q47.2 R812.2 R1179.2 R1180.1 U51.A46
PROCHOT_GATE: PU704.2 RP4.8 U46.A50
PS2_CLK_TS: JKB1.2 JTP1.7
PS2_DAT_TS: JKB1.3 JTP1.6
PS_0: CV357.1 RV243.1 RV244.2 UV1.AC19
PS_1: CV342.1 RV237.2 RV238.1 UV1.AD19
PS_2: CV340.1 RV239.2 RV240.1 UV1.AE17
PS_3: CV341.1 RV241.2 RV242.1 UV1.AE20
PS_ID: PU1.4 U51.A55
PSATA_PRX_DTX_N0_C: C385.2 UH1.BC8
PSATA_PRX_DTX_P0_C: C386.2 UH1.BE8
PSATA_PTX_DRX_N0_C: C384.2 UH1.AW8
PSATA_PTX_DRX_P0_C: C383.2 UH1.AY8
PSID_DISABLE#: PR16.2 U46.A37
PWR_SRC_ON: C297.2 Q21.3 R422.2 R423.1
PWRSHARE_EN#: Q48.1 R816.1 U48.4
PX_EN: RV48.2 UV1.AB16
RASA0#: UV1.G22 UV4.G3 UV5.L3
RASA1#: UV1.G17 UV3.L3 UV6.G3
RED_CRT: JIO1.3 U6.27
RED_DOCK: JDOCK1.53 U6.26
REGCTL_PNP10: L29.1 U31.7
REM_DIODE1_N: C8.1 C285.1 Q1.3 U51.B13
REM_DIODE1_P: C8.2 C285.2 Q1.1 Q1.2 U51.A13
REM_DIODE2_N: C9.2 C283.1 Q2.3 U51.B14
REM_DIODE2_P: C9.1 C283.2 Q2.1 Q2.2 U51.A14
REM_DIODE4_N: C16.1 C286.1 Q3.3 U51.A16
REM_DIODE4_P: C16.2 C286.2 Q3.1 Q3.2 U51.B17
RES_BIAS: R562.1 U31.12
RESET_OUT#: R843.2 RC69.1 RH27.1 RH85.1 RH103.1 U51.B39
RESET_OUT#_R: JXDP2.46 RH27.2
RF_+1.05VSP: PR305.1 PU300.5
RING2: R1146.1 R3732.1 U74.28
RING2_L: C1557.1 D81.2 JHP1.3 R3732.2
RSMRST#: R1622.1 R1630.1 U8.3 U9.2
RSMRST#_XDP: JXDP2.39 RH26.2
RTN_VGA: PC630.2 PR657.2 PU600.13
RUN_ON: PR406.1 Q52.2 R717.1 RP6.1 U37.5 U46.A11 U146.5
RUN_ON_ENABLE#: Q45.2 Q52.5 Q52.6 Q70.2 Q71.2 Q72.2 QC1.2 R909.2
RUNPWROK: Q45.1 R3772.1 RC7.2 RP17.8 U50.2 U51.B26
RUNPWROK_AND: QC5.1 RC6.2 RC9.1 RC10.2 RC15.2 RC16.1 UC1.4
RUNPWROK_R: CC138.1 QC5.2 RC5.2 RC7.1 RC103.1 RC104.1 UC1.1
S3_1.35V: PR208.2 PU200.7
S5_1.35V: PC215.1 PR206.2 PR210.2 PU200.8
SATA_ACT#: Q74.4 UH1.AP3
SATA_COMP: RH57.1 UH1.AY5
SATA_IREF: RH51.2 UH1.BD4
SATA_LED: JLED1.4 R934.2
SATA_ODD_PRX_DTX_N1: C405.1 JSATA2.5
SATA_ODD_PRX_DTX_N1_C: C405.2 UH1.BC10
SATA_ODD_PRX_DTX_P1: C404.1 JSATA2.6
SATA_ODD_PRX_DTX_P1_C: C404.2 UH1.BE10
SATA_ODD_PTX_DRX_N1: C406.1 JSATA2.3
SATA_ODD_PTX_DRX_N1_C: C406.2 UH1.AV10
SATA_ODD_PTX_DRX_P1: C407.1 JSATA2.2
SATA_ODD_PTX_DRX_P1_C: C407.2 UH1.AW10
SATA_PRX_DKTX_N2: C698.2 JDOCK1.56
SATA_PRX_DKTX_N2_C: C698.1 UH1.BB9
SATA_PRX_DKTX_P2: C697.2 JDOCK1.54
SATA_PRX_DKTX_P2_C: C697.1 UH1.BD9
SATA_PRX_DTX_N0: C385.1 JSATA1.5
SATA_PRX_DTX_P0: C386.1 JSATA1.6
SATA_PTX_DKRX_N2: C700.1 JDOCK1.62
SATA_PTX_DKRX_N2_C: C700.2 UH1.AY13
SATA_PTX_DKRX_P2: C699.1 JDOCK1.60
SATA_PTX_DKRX_P2_C: C699.2 UH1.AW13
SATA_PTX_DRX_N0: C384.1 JSATA1.3
SATA_PTX_DRX_P0: C383.1 JSATA1.2
SB#: R153.2 R1626.2 U2.8
SD_CD#: C802.2 JSD1.17 R3884.1 U38.21
SD_CLK: JSD1.5 R676.2
SD_CLK_R: R676.1 U38.43
SD_CMD: JSD1.2 U38.45
SD_D0_RCLK_P_MMC_D0: JSD1.7 LE5.3 RE28.2
SD_D0_RCLKR_P: LE5.4 RE28.1 U38.30 U38.38
SD_D1_RCLK_N: JSD1.8 LE5.2 RE27.2
SD_D1_RCLKR_N: LE5.1 RE27.1 U38.29 U38.37
SD_D2: JSD1.9 U38.48
SD_D3: JSD1.1 U38.47
SD_UHS2_D0N: JSD1.12 LE4.2 RE25.2
SD_UHS2_D0N_R: LE4.1 RE25.1 U38.34
SD_UHS2_D0P: JSD1.11 LE4.3 RE26.2
SD_UHS2_D0P_R: LE4.4 RE26.1 U38.35
SD_UHS2_D1N: JSD1.15 LE2.3 RE4.2
SD_UHS2_D1N_R: LE2.4 RE4.1 U38.33
SD_UHS2_D1P: JSD1.16 LE2.2 RE3.2
SD_UHS2_D1P_R: LE2.1 RE3.1 U38.32
SD_WPI: JSD1.18 U38.20
SEL: Q59.1 R1614.1 U2.4
SIO_14M: RH157.2 UH1.F38
SIO_A20GATE: RPH14.3 U51.A45 UH1.AN10
SIO_EXT_SCI#: RH195.2 RPH16.3 U51.A33
SIO_EXT_SMI#: RH10.1 RPH1.3 U51.A6 UH1.M1
SIO_EXT_WAKE#: RH24.1 RPH9.2 U46.B49 UH1.Y1
SIO_PWRBTN#: RH108.1 U51.B58
SIO_PWRBTN#_R: RC21.1 RH28.1 RH108.2 UH1.K1
SIO_RCIN#: RPH14.4 U51.A27 UH1.AT6
SIO_SLP_A#: JAPS1.6 PR303.1 U46.B63 UH1.F3 UH2.1
SIO_SLP_LAN#: RH80.2 U46.A5 U57.5 UH1.G5
SIO_SLP_S3#: JAPS1.2 PR403.1 PR607.1 R153.1 R734.1 U46.B65 UH1.H1
SIO_SLP_S4#: JAPS1.5 PR206.1 U46.A61 UH1.C6
SIO_SLP_S5#: JAPS1.4 U51.A18 UH1.Y7
SIO_SLP_SUS#: U46.B6 UH1.F1
SIO_SLP_WLAN#: U46.A14 UH1.D2
SLEEVE: Q330.3 R1145.1 R3731.1 U74.29
SLICE_BAT_ON: PQ806.5 PR850.2 PR890.2 PU801.2 PU807.1 RP5.1 U46.A31
SLICE_BAT_PRES#: JDOCK1.141 JDOCK1.143 PD820.1 PQ807.5 PQ827.2 PR26.1 PR882.1 PU800.21 PU801.1 PU805.1 PU808.1 RP3.6 U46.B33
SLICE_PERF_EN: PR881.2 PR883.1 PR884.2 PR885.2 U51.B37
SLP_ME_CSW_DEV#: RH222.1 RH223.1 U46.B58 UH1.AD11
SM_RCOMP0: JCPU1.AP3 RC58.1
SM_RCOMP1: JCPU1.AR3 RC61.1
SM_RCOMP2: JCPU1.AP2 RC63.1
SML1_SMBCLK: RPH12.2 U51.B6 UH1.K6
SML1_SMBDATA: RPH12.1 U51.A5 UH1.N11
SNUB_1.05V: PC309.2 PR304.1
SNUB_1.5VSP: PC407.2 PR401.1
SNUB_1.35V: PC212.2 PR202.1
SNUB_3V: PC116.2 PR109.1
SNUB_5V: PC119.2 PR112.1
SNUB_CHARGER: PC715.2 PR721.2
SNUB_GPU_P1: PC631.2 PR653.1
SNUB_GPU_P2: PC607.2 PR622.1
SNUB_PCIE: PC667.2 PR680.1
SNUB_V1: PC543.2 PR554.1
SNUB_V2: PC524.2 PR541.1
SOFT_START_GC: PR23.2 PU800.2
SP_TPM_LPC_EN: R772.2 R1169.1 U46.B56
SP_TPM_LPC_EN_R: R1169.2 R1667.2 R3771.2 U39.28
SPI_CLK32: RPH7.3 U53.6
SPI_CLK64: RPH7.1 U52.6
SPI_DIN32: RPH11.6 U53.2
SPI_DIN64: RPH11.8 U52.2
SPI_DO32: R901.1 U53.5
SPI_DO64: RPH7.2 U52.5
SPI_PCH_CLK: JSPI1.7 RH181.1 RPH7.6 RPH7.8
SPI_PCH_CS0#: JSPI1.9 R7.1 RH182.1
SPI_PCH_CS0#_R: R7.2 U52.1
SPI_PCH_CS1#: JSPI1.1 R936.1 RH177.1
SPI_PCH_CS1#_R: R936.2 U53.1
SPI_PCH_DIN: JSPI1.5 RH179.1 RPH11.1 RPH11.3
SPI_PCH_DO: JSPI1.3 R901.2 RH178.1 RPH7.7
SPI_PCH_DO2: JSPI1.11 RH183.1 RPH11.2 RPH11.4
SPI_PCH_DO2_32: R3665.2 RH186.1 RPH11.5 U53.3
SPI_PCH_DO2_64: R3664.2 RH180.1 RPH11.7 U52.3
SPI_PCH_DO3: JSPI1.13 R3669.2 RH184.1 RPH7.5
SPI_PCH_DO3_32: R3666.2 RPH7.4 U53.7
SPI_PCH_DO3_64: R3668.2 R3669.1 U52.7
SPI_WP#_SEL: RH180.2 RH186.2 U46.A12
SPKR: C1559.1 R1119.2 RH34.2 UH1.AL10
SRN: PC722.2 PC723.1 PR716.2 PR719.2
SRP: PC721.2 PC722.1 PR716.3 PR718.2
SRTCRST#: CH6.2 ME1.2 RH42.2 UH1.B9
STSTART_DCBLOCK_GC: PR811.2 PU800.16
SUS_ON: PR210.1 R1607.1 RP6.4 U46.B60
SUS_STAT#/LPCPD#: R1667.1 RH73.2 UH1.U7
SUSACK#: RH101.1 U46.A58
SUSACK#_R: RH91.2 RH101.2 UH1.R6
SUSCLK: T68.1(TP-1) UH1.Y6
SW1: PC111.2 PC119.1 PL102.1 PQ102.1 PQ102.2 PQ102.3 PQ104.5 PU100.18
SW2: PC112.1 PC116.1 PL101.2 PQ101.1 PQ101.2 PQ101.3 PQ103.5 PU100.8
SW_1.35V: PC206.1 PC212.1 PL201.2 PQ201.1 PQ201.2 PQ201.3 PQ203.5 PU200.16
SW_+1.05VSP: PC306.1 PC309.1 PL301.1 PQ301.1 PQ301.2 PQ301.3 PQ303.5 PU300.8
SW_LAN_TX0+: R575.1 U32.24
SW_LAN_TX0+_R: C500.1 R575.2 T156.1
SW_LAN_TX0-: R576.1 U32.25
SW_LAN_TX0-_R: C500.2 R576.2 T156.2
SW_LAN_TX1+: R577.1 U32.28
SW_LAN_TX1+_R: C501.1 R577.2 T156.5
SW_LAN_TX1-: R578.1 U32.29
SW_LAN_TX1-_R: C501.2 R578.2 T156.6
SW_LAN_TX2+: T156.7 U32.33
SW_LAN_TX2-: T156.8 U32.34
SW_LAN_TX3+: T156.11 U32.37
SW_LAN_TX3-: T156.12 U32.38
SYS_LED_MASK#: Q84.5 Q325.2 Q325.5 Q326.2 RP18.5 U46.B48 U58.1
SYS_PWROK: RC24.1 RH85.2 RH102.1 U46.B57
SYS_PWROK_R: RH102.2 UH1.AD7
SYS_PWROK_XDP: JXDP1.13 RC11.2 RC24.2
SYS_RESET#: C1554.1 JAPS1.13 RH66.2 UC3.4 UH1.AM1
SYSPWR_PRES: R874.1 RP16.4 U51.A59
SYSTEM_ID: C742.1 R871.2 U51.A10
TEMP_ALERT#: R738.2 RPH21.7 UH1.H6
TEMP_ALERT#_R: R738.1 U46.B11
TESTEN: RV41.1 RV49.1 UV1.K7
THERMATRIP2#: C18.1 Q4.1 R51.2 U51.B34
THERMATRIP3#: CV57.1 QV7.1 R52.1 U51.A2
THERMTRIP_VGA: RV47.1 RV77.1 RV104.2 UV1.M2
THSEL_STRAP: R1069.1 U51.B29
TMDSB_CPU_CLK: C352.2 JCPU1.V31
TMDSB_CPU_CLK#: C353.2 JCPU1.U31
TMDSB_CPU_N0: C350.2 JCPU1.U29
TMDSB_CPU_N1: C346.2 JCPU1.T30
TMDSB_CPU_N2: C348.2 JCPU1.T28
TMDSB_CPU_P0: C351.2 JCPU1.V29
TMDSB_CPU_P1: C347.2 JCPU1.U30
TMDSB_CPU_P2: C349.2 JCPU1.U28
TMDSE_CON_CLK: CE5.1 JHDMI1.10 L1.3 R63.2
TMDSE_CON_CLK#: CE7.1 JHDMI1.12 L1.2 R62.2
TMDSE_CON_N0: CE16.1 JHDMI1.9 L2.2 R68.2
TMDSE_CON_N1: CE18.1 JHDMI1.6 L3.2 R74.2
TMDSE_CON_N2: CE14.1 JHDMI1.3 L4.2 R78.2
TMDSE_CON_P0: CE17.1 JHDMI1.7 L2.3 R64.2
TMDSE_CON_P1: CE13.1 JHDMI1.4 L3.3 R71.2
TMDSE_CON_P2: CE15.1 JHDMI1.1 L4.3 R77.2
TMDSE_CPU_CLK#_C: C353.1 U19.10
TMDSE_CPU_CLK_C: C352.1 U19.9
TMDSE_CPU_N0_C: C350.1 U19.2
TMDSE_CPU_N1_C: C346.1 U19.5
TMDSE_CPU_N2_C: C348.1 U19.7
TMDSE_CPU_P0_C: C351.1 U19.1
TMDSE_CPU_P1_C: C347.1 U19.4
TMDSE_CPU_P2_C: C349.1 U19.6
TMDSE_RP_CLK: L1.4 R63.1 U19.22
TMDSE_RP_CLK#: L1.1 R62.1 U19.21
TMDSE_RP_N0: L2.1 R68.1 U19.29
TMDSE_RP_N1: L3.1 R74.1 U19.26
TMDSE_RP_N2: L4.1 R78.1 U19.24
TMDSE_RP_P0: L2.4 R64.1 U19.30
TMDSE_RP_P1: L3.4 R71.1 U19.27
TMDSE_RP_P2: L4.4 R77.1 U19.25
TOUCH_SCREEN_PD#: Q24.2 RP2.6 U46.B55
TP_CLK: JTP1.2 R3736.2
TP_DATA: JTP1.3 R3735.2
TP_LAN_JTAG_TCK: R546.2 U31.35
TP_LAN_JTAG_TDI: T142.1(TP-1) U31.32
TP_LAN_JTAG_TDO: T143.1(TP-1) U31.34
TP_LAN_JTAG_TMS: R545.2 U31.33
TPM_ID0: RPH16.2 UH1.AT7
TPM_ID1: RPH14.1 UH1.AM3
TRIP_+1.05VSP: PR302.2 PU300.2
TS_FDO: RV111.2 UV1.R5
UG_3V: PQ101.4 PU100.10
UG_5V: PQ102.4 PU100.16
UG_+1.05VSP: PQ301.4 PU300.9
UGATE1: PQ509.4 PU500.19
UGATE1_VGA: PQ601.2 PU600.20
UGATE2: PQ505.4 PU500.26
UGATE2_VGA: PQ600.2 PU600.29
UIM_CLK: C630.1 JMINI1.12 JSIM1.3
UIM_DATA: C629.1 JMINI1.10 JSIM1.7
UIM_RESET: C631.1 JMINI1.14 JSIM1.2
USB3RN1: L95.4 R1605.1 UH1.AR26
USB3RN1_D-: D78.5 D78.6 JUSB1.5 L95.3 R1605.2
USB3RN2: L108.4 R3696.1 UH1.AW26
USB3RN2_D-: D88.1 D88.9 JUSB2.5 L108.3 R3696.2
USB3RN3: JDOCK1.84 UH1.AW31
USB3RN5: L111.4 R3722.1 UH1.AW29
USB3RN5_D-: D91.1 D91.9 JUSB3.5 L111.3 R3722.2
USB3RN6: JIO1.29 UH1.AR29
USB3RP1: L95.1 R1604.1 UH1.AP26
USB3RP1_D+: D78.4 D78.7 JUSB1.6 L95.2 R1604.2
USB3RP2: L108.1 R3691.1 UH1.AV26
USB3RP2_D+: D88.2 D88.8 JUSB2.6 L108.2 R3691.2
USB3RP3: JDOCK1.86 UH1.AY31
USB3RP5: L111.1 R3721.1 UH1.AV29
USB3RP5_D+: D91.2 D91.8 JUSB3.6 L111.2 R3721.2
USB3RP6: JIO1.31 UH1.AP29
USB3TN1: C1533.1 UH1.BE24
USB3TN1_C: C1533.2 L96.4 R1606.1
USB3TN1_D-: D78.2 D78.8 JUSB1.8 L96.3 R1606.2
USB3TN2: C1518.1 UH1.BD25
USB3TN2_C: C1518.2 L109.4 R3698.1
USB3TN2_D-: D88.4 D88.7 JUSB2.8 L109.3 R3698.2
USB3TN3: JDOCK1.90 UH1.BE32
USB3TN5: C419.1 UH1.BE26
USB3TN5_C: C419.2 L112.4 R3728.1
USB3TN5_D-: D91.4 D91.7 JUSB3.8 L112.3 R3728.2
USB3TN6: JIO1.35 UH1.BD27
USB3TP1: C1534.1 UH1.BD23
USB3TP1_C: C1534.2 L96.1 R1603.1
USB3TP1_D+: D78.1 D78.9 JUSB1.9 L96.2 R1603.2
USB3TP2: C1519.1 UH1.BC24
USB3TP2_C: C1519.2 L109.1 R3697.1
USB3TP2_D+: D88.5 D88.6 JUSB2.9 L109.2 R3697.2
USB3TP3: JDOCK1.92 UH1.BC32
USB3TP5: C418.1 UH1.BC26
USB3TP5_C: C418.2 L112.1 R3727.1
USB3TP5_D+: D91.5 D91.6 JUSB3.9 L112.2 R3727.2
USB3TP6: JIO1.37 UH1.BE28
USB30_EN: Q123.5 Q123.6 R515.2
USB30_SMI#: Q123.3 RP19.2 UH1.C22
USB_MCARD1_DET#: JMINI2.40 RP20.8 UH1.A10
USB_OC0#: R3773.2 RH3.1 RPH3.2 U48.5 U91.5 UH1.P3
USB_OC1#: R3773.1 RH4.1 RPH9.1 U93.5 UH1.V1
USB_OC2#: RH6.1 RPH8.4 UH1.U2
USB_OC3#: RH7.1 RPH3.3 UH1.P1
USB_OC4#: JIO1.28 RH8.1 RPH1.4 UH1.M3
USB_OC5#: RH9.1 RPH3.4 UH1.T1
USB_OC6#: RH17.1 RPH1.2 UH1.N2
USB_PWR_SHR_EN#: Q59.2 R806.2 R1626.1 RP4.5 U46.B10
USB_PWR_SHR_VBUS_EN: Q48.2 RP3.8 U2.1 U46.B50
USB_SIDE_EN#: JIO1.38 RP2.7 U46.A33
USBP0+: U2.6 UH1.D37
USBP0-: U2.7 UH1.B37
USBP0_D+: L51.4 R740.1 U2.3
USBP0_D-: L51.1 R736.1 U2.2
USBP0_R_D+: D72.2 JUSB1.3 L51.3 R740.2
USBP0_R_D-: D72.3 JUSB1.2 L51.2 R736.2
USBP1+: L107.1 R3690.1 UH1.C38
USBP1-: L107.4 R3689.1 UH1.A38
USBP1_D+: D89.3 JUSB2.3 L107.2 R3690.2
USBP1_D-: D89.2 JUSB2.2 L107.3 R3689.2
USBP2+: L110.1 R3710.1 UH1.C36
USBP2-: L110.4 R3711.1 UH1.A36
USBP2_D+: D90.2 JUSB3.3 L110.2 R3710.2
USBP2_D-: D90.3 JUSB3.2 L110.3 R3711.2
USBP3+: JDOCK1.72 UH1.C34
USBP3-: JDOCK1.74 UH1.A34
USBP4+: JMINI2.38 UH1.D33
USBP4-: JMINI2.36 UH1.B33
USBP5+: JMINI1.38 UH1.G31
USBP5-: JMINI1.36 UH1.F31
USBP6+: L99.4 R1672.2 UH1.L31
USBP6-: L99.1 R1673.2 UH1.K31
USBP6_R_D+: JDOCK1.66 L99.3 R1672.1
USBP6_R_D-: JDOCK1.68 L99.2 R1673.1
USBP7+: JUSH1.18 UH1.H29
USBP7-: JUSH1.19 UH1.G29
USBP8+: JMINI3.38 UH1.C32
USBP8-: JMINI3.36 UH1.A32
USBP9+: JIO1.32 UH1.C30
USBP9-: JIO1.34 UH1.A30
USBP10+: JEXP1.5 UH1.D29
USBP10-: JEXP1.3 UH1.B29
USBP12+: L10.4 R427.1 UH1.F26
USBP12-: L10.1 R428.1 UH1.G26
USBP12_D+: JCAM1.2 L10.3 R427.2
USBP12_D-: JCAM1.3 L10.2 R428.2
USBP13+: L11.1 R432.1 UH1.G24
USBP13-: L11.4 R433.1 UH1.F24
USBP13_D+: D86.2 JTCH1.5 L11.2 R432.2
USBP13_D-: D86.3 JTCH1.4 L11.3 R433.2
USBRBIAS: RH187.1 UH1.K24 UH1.K26
USH_DET#: JUSH1.1 RH202.1 UH1.F13
USH_PWR_ON: R1620.1 U46.A18
USH_PWR_STATE#: JUSH1.5 R1640.1 U46.A34
USH_SMBCLK: JUSH1.16 R589.2 U51.A50
USH_SMBDAT: JUSH1.15 R585.2 U51.B53
V_SYS: PC716.2 PU700.7 R392.2
V_SYS_R: R392.1 U51.B61
VCI_IN3#: RP15.1 U51.B68
VCORE_NTC: PH500.1 PR525.1 PR528.1
VCORE_VDDP: PC509.2 PR520.1 PU500.22 PU500.23
VCP: PR710.1 PR728.1 U51.A12
VCT_LAN_R1: R152.2 U31.6
VGA_ID: R800.2 R803.1 U46.B59
VGA_THERMDN: C287.1 U51.A15 UV1.T2
VGA_THERMDP: C287.2 U51.B16 UV1.T4
VID0: PR612.2 PU600.31
VID6: PR615.1 PU600.37
VIDALERT_N: PR503.1 PU500.32 RC87.2 RC88.2
VIDSCLK: JCPU1.AM29 PR504.1 PU500.1
VIDSOUT: JCPU1.AL28 PR500.1 PU500.31 RC90.2
VLDOIN_1.35V: PJP201.2 PU200.19
VOL_DOWN#: JMDIA1.4 R887.2
VOL_MUTE#: JMDIA1.3 R884.2
VOL_UP#: JMDIA1.5 R888.2
VR_HOT#: PR524.2 PU500.5
VR_ON: PR511.2 PU500.2
VSEN_VGA: PC612.2 PC624.1 PR640.2 PR650.2 PU600.12
VSET_5075: C284.1 R407.1 U51.A17
VSUM+_VGA: PC626.1 PC627.1 PR619.2 PR648.1 PR651.2 PR655.1 PU600.15
VSUM-_VGA: PC615.2 PC616.2 PC626.2 PC627.2 PC632.1 PH601.2 PR624.2 PR654.2 PR655.2 PR659.2
VSYNC: RH95.2 UH1.N44
VSYNC_BUF: JIO1.4 U6.18
VSYNC_DOCK: JDOCK1.67 U6.17
VW_VGA: PC611.1 PR638.1 PU600.6
WCKA0_0: UV1.E32 UV4.D4 UV5.P4
WCKA0_1: UV1.A21 UV4.P4 UV5.D4
WCKA0B_0: UV1.E30 UV4.D5 UV5.P5
WCKA0B_1: UV1.C21 UV4.P5 UV5.D5
WCKA1_0: UV1.E13 UV3.P4 UV6.D4
WCKA1_1: UV1.E3 UV3.D4 UV6.P4
WCKA1B_0: UV1.D12 UV3.P5 UV6.D5
WCKA1B_1: UV1.F4 UV3.D5 UV6.P5
WEA0#: UV1.G25 UV4.L12 UV5.G12
WEA1#: UV1.H10 UV3.G12 UV6.L12
WIGIG60GHZ_DIS#: D35.1 R694.1 U46.A1
WIGIG60GHZ_DIS#_R: D35.2 JMINI2.32 R694.2 R725.1
WIGIG_LED#: JMINI2.42 Q124.4 R706.1 RP13.3
WIRELESS_LED#: Q77.1 Q89.1 Q100.3 Q124.3 Q124.6 R937.2 U46.A47
WIRELESS_ON#/OFF: JSF1.4 RP3.5 U46.B13
WLAN_LAN_DISB#: U15.4 U46.A64
WLAN_LED: JLED1.5 R3671.2
WLAN_LED#: JMINI2.44 Q124.1 RP13.2
WLAN_RADIO_DIS#: D31.1 R693.1 U46.A48
WLAN_RADIO_DIS#_R: D31.2 JMINI2.20 R693.2 R3885.1
WWAN_RADIO_DIS#: JMINI1.20 RP3.7 U46.A53
XDP_DBRESET#: C1553.1 JXDP1.18 JXDP2.48 RC35.1 RC52.2 RH66.1 UC3.1
XDP_DBRESET#_R: JCPU1.AP33 RC35.2
XDP_FN0: JXDP2.9 RH3.2
XDP_FN1: JXDP2.11 RH4.2
XDP_FN2: JXDP2.15 RH6.2
XDP_FN3: JXDP2.17 RH7.2
XDP_FN4: JXDP2.27 RH8.2
XDP_FN5: JXDP2.29 RH9.2
XDP_FN6: JXDP2.33 RH17.2
XDP_FN7: JXDP2.35 RH10.2
XDP_FN8: JXDP2.10 RH11.2
XDP_FN9: JXDP2.12 RH13.2
XDP_FN10: JXDP2.16 RH12.2
XDP_FN11: JXDP2.18 RH14.2
XDP_FN12: JXDP2.28 RH16.2
XDP_FN13: JXDP2.30 RH19.2
XDP_FN14: JXDP2.34 RH20.2
XDP_FN15: JXDP2.36 RH22.2
XDP_FN16: JXDP2.4 RH24.2
XDP_FN17: JXDP2.6 RH25.2
XDP_OBS0: JCPU1.AR30 T173.1(TP-1)
XDP_OBS1: JCPU1.AN31 T174.1(TP-1)
XDP_OBS2: JCPU1.AN29 T88.1(TP-1)
XDP_OBS3: JCPU1.AP31 T89.1(TP-1)
XDP_OBS4: JCPU1.AP30 T90.1(TP-1)
XDP_OBS5: JCPU1.AN28 T116.1(TP-1)
XDP_OBS6: JCPU1.AP29 T117.1(TP-1)
XDP_OBS7: JCPU1.AP28 T118.1(TP-1)
XDP_PRDY#: JCPU1.AR29 JXDP1.2
XDP_PREQ#: JCPU1.AT29 JXDP1.1 RC55.2
XDP_RST#_R: JXDP1.17 RC23.2
XDP_TCLK: JCPU1.AM34 JXDP1.26 RC59.2
XDP_TDI: JXDP1.22 RC32.2 RC54.2
XDP_TDI_R: JCPU1.AM31 RC32.1
XDP_TDO: JXDP1.20 RC34.2 RC57.2
XDP_TDO_R: JCPU1.AL33 RC34.1
XDP_TMS: JCPU1.AN33 JXDP1.23 RC53.2
XDP_TRST#: JCPU1.AM33 JXDP1.21 RC62.2
XFR_ID#: JIO1.2 RPH6.3 UH1.F17
XTAL25_IN: RH152.2 UH1.AM43
XTAL25_IN_R: CH14.2 RH152.1 RH153.2 YH2.1
XTAL25_OUT: CH13.2 RH153.1 UH1.AL44 YH2.3
XTALI: C471.2 U31.10 Y3.3
XTALIN: CV95.1 RV100.1 UV1.AM28 YV1.1
XTALO: R1144.2 U31.9
XTALOUT: CV94.1 RV100.2 RV125.1 YV1.3
XTALOUT_R: RV125.2 UV1.AK28
Z2805: R574.1 T156.22
Z2806: R573.1 T156.16
Z2807: R572.1 T156.21
Z2808: R571.1 T156.15
Z4012: PD3.2 PR1.2
Z4304: PBATT1.7 PD2.2 PRP2.6
Z4305: PBATT1.6 PD2.3 PRP2.7
Z4306: PBATT1.5 PD4.2 PRP2.8
ZODD_WAKE#: Q76.3 RP18.8 U46.A59
N115227: PC8.1 PQ4.4 PQ6.4 PR18.2 PR23.1 PR25.1
N115634: PQ6.1 PQ6.2
N392231: PD701.1 PR742.1
N513876: PR718.1 PU700.13
N514008: PR719.1 PU700.12
N743839: PR631.2 PR691.1 PU600.2
N992434: PD7.2 PQ7.1
N992510: PC17.1 PQ7.2 PR26.2
N995059: PQ710.1 PR748.2 PU704.1
N995231: PQ707.5 PU704.4
N995271: PQ707.3 PQ707.6 PR724.1
N1002908: PQ805.5 PQ805.6 PR807.2
N1002948: PD811.2 PR815.2
N1002952: PD811.1 PQ812.6
N1002956: PQ812.2 PQ812.3 PR816.1
N1002964: PR863.1 PU800.19
N1003044: PQ809.4 PR813.1 PR815.1
N1003284: PC807.2 PQ810.4 PR811.1
N1003374: PQ806.3 PR810.2 PR812.2 PU804.2
N1003454: PQ817.1 PR819.1 PU805.2
N1003474: PQ807.2 PQ807.3 PR808.2
N1003522: PD807.1 PQ801.3 PR802.2
N1003526: PQ801.2 PR802.1 PR804.1
N1003966: PD810.1 PD819.1 PQ816.2
N1004028: PQ818.2 PQ819.3 PQ819.6 PR824.1 PR882.2
N1004036: PQ818.1 PR823.1 PU807.2
N1004086: PD818.1 PQ802.1 PQ805.2 PQ806.6 PR801.2
N1004090: PQ802.2 PU801.4
N1004112: PQ812.5 PR890.1
N1004194: PU805.4 PU806.1
N1004236: PR838.1 PU800.28
N1004240: PQ806.2 PU804.4
N1004350: PC811.1 PQ811.4 PR821.1
N1004812: PQ819.2 PR881.1
N1005192: PQ824.5 PR883.2
N1005388: PQ813.5 PR884.1 PR886.1
N1005532: PQ813.2 PQ813.3 PR829.2
N1005544: PQ821.5 PR885.1 PR887.1
N1005606: PQ813.6 PR826.2
N1006752: PQ814.2 PR826.1 PR827.1
N1007864: PQ821.2 PQ821.3 PR849.2
N1007980: PQ822.2 PR839.1 PR840.1
N1008596: PR850.1 PU800.26
N1009306: PD810.3 PU806.4
N1009636: PD813.3 PQ822.1
N1009712: PC809.1 PQ815.1 PQ815.2 PQ815.3 PQ826.1 PQ826.2 PQ826.3 PR818.2
N1009720: PQ823.3 PR863.2 PR869.1
N1009724: PQ823.2 PR869.2 PR870.1
N1009740: PC809.2 PD813.1 PD821.1 PQ815.4 PQ826.4 PR818.1 PR822.1
N1009748: PQ824.6 PR870.2
N1009764: PQ824.2 PQ824.3 PR875.2
N1009998: PD810.2 PU807.4
N1010104: PQ816.1 PR822.2
N1208920: PD815.2 PQ828.1
N16790095: T59.1(TP-1) UH1.C26
N16807572: T58.1(TP-1) UH1.BB2
N16834717: R1607.2 R1620.2 U36.5
N16837387: QV8.2 RV78.2
N16843836: T151.1(TP-1) UV1.AL13
N16843839: T152.1(TP-1) UV1.AJ13
N16845401: T65.1(TP-1) UH1.AW17
N16845569: T67.1(TP-1) UH1.AV17
N16850101: CV86.2 RV45.1
N16850105: CV85.2 RV46.1
N16856615: T108.1(TP-1) UV1.N8
N16856618: T105.1(TP-1) UV1.P10
N16856621: T106.1(TP-1) UV1.P4
N16857314: T57.1(TP-1) UH1.BA2
N16858942: T75.1(TP-1) UH1.AB10
N16878549: T62.1(TP-1) UH1.AV43
N16878550: T63.1(TP-1) UH1.AY45
N16878551: T60.1(TP-1) UH1.AV45
N16878552: T61.1(TP-1) UH1.AW44
N16878560: T64.1(TP-1) UH1.AU42
N16878561: T66.1(TP-1) UH1.AU44
N16976351: T71.1(TP-1) UH1.AD10
N17068457: T76.1(TP-1) UH1.AD39
N17068936: T77.1(TP-1) UH1.AD38
N17103565: C454.1 U146.10
N17103571: C451.1 U146.12
N17103600: T78.1(TP-1) UH1.BA45
N17104124: T79.1(TP-1) UH1.BC45
N17104491: D7.1 R3737.1 U148.3
N17104650: T80.1(TP-1) UH1.BE43
N17105178: T81.1(TP-1) UH1.BE44
N17139830: T82.1(TP-1) UH1.M33
N17139840: T83.1(TP-1) UH1.L33
N17164952: T84.1(TP-1) UH1.BC30
N17164953: T85.1(TP-1) UH1.BB29
N17190484: PQ821.6 PQ827.1 PR839.2
N17195971: PC736.1 PQ707.2 PR723.1 PR725.2 PR727.1 PU701.1
N17205976: JDEG2.1 R864.2
N17220570: RH195.1 UH1.AT8
N17513991: Q330.2 R39.2 R40.2
N17681337: CD46.2 RC108.1
N17682009: CD47.2 RC109.1
N17682019: CD48.2 RC110.1
N17682043: QD9.1 RD2.2 RD4.1 RD25.1
N17734625: C1105.1 R1119.1 R1142.1
N17734631: C1106.1 R1120.1 R1141.1
N17860472: RV108.2 UV4.J13
N18000518: JMINI2.22 R703.2
N18000576: JMINI2.49 R707.1
N18107028: C1551.1 R3761.2
N18289631: JHP1.5 R1100.2 R1676.1
N18386761: RV118.2 UV3.J13
N18505964: JCPU1.AC7 T2.1(TP-1)
N18614557: PC708.2 PR713.1 PR714.1 PU700.6
N18623445: PD820.2 PQ829.2 PR828.2
N18623534: PQ828.2 PQ829.1 PR830.2
N18623732: PQ828.3 PR830.1 PR894.2 PR895.2
N18643940: Q75.1 R934.1
N18690134: CH76.1 RH330.2
N18703943: JCPU1.AG8 T3.1(TP-1)
N18790484: PD821.2 PQ830.1
N18790539: PQ830.2 PR833.1 PR834.2
N18790579: PQ831.1 PR834.1
N18790685: PQ831.2 PU808.4
N18793722: PQ807.6 PR804.2
N18834972: PC726.1 PR726.2 PR730.1 PR731.1 PU701.2
N18878176: PBATT1.3 PD4.3
N18894554: PC542.1 PR550.1
N18894698: PC511.1 PR526.1 PU500.17
N18894707: PR507.2 PU500.28
N18894708: PR512.2 PU500.30
N18894710: PR509.2 PU500.29
N18894766: PC520.2 PR533.1
N18894780: PC527.2 PR543.1
N18894784: PC526.2 PR539.1
N18894855: PC521.1 PR535.2 PU500.14
N18894856: PC521.2 PR545.2
N18894871: PH501.2 PR551.1
N18894872: PC529.1 PC538.1 PR548.2
N18894895: PC518.1 PR530.1 PU500.16
N18898957: PC703.2 PC704.1 PR704.1 PU700.2
N18899027: PC704.2 PC705.1 PR705.1 PU700.1
N18990088: JCPU1.R27 T4.1(TP-1)
N19270300: JCPU1.L27 T40.1(TP-1)
N19270310: JCPU1.K27 T39.1(TP-1)
N19270320: JCPU1.T27 T41.1(TP-1)
N19293545: JCPU1.V27 T42.1(TP-1)
N19348815: JCPU1.N26 T43.1(TP-1)
N19355782: JCPU1.AL27 T44.1(TP-1)
N19359234: JCPU1.AK27 T45.1(TP-1)
N19359738: PR100.2 PR102.2 PU100.4
N19359776: PR118.2 PR119.1 PU100.7
N19359778: PR105.1 PU100.5
N19359887: PR101.2 PR104.2 PU100.2
N19359966: PC111.1 PR107.2
N19360011: PR106.1 PU100.1
N19360218: PC112.2 PR108.1
N19438915: JCPU1.E17 T46.1(TP-1)
N19581764: JCPU1.W32 T48.1(TP-1)
N19581774: JCPU1.AL16 T49.1(TP-1)
N19592461: JCPU1.AL13 T51.1(TP-1)
N21489543: JCPU1.AK33 T56.1(TP-1)
N23050350: JCPU1.AR1 T34.1(TP-1)
N23050352: JCPU1.A2 T33.1(TP-1)
N23050370: JCPU1.K6 T29.1(TP-1)
N23050372: JCPU1.F5 T25.1(TP-1)
N23050374: JCPU1.AM2 T27.1(TP-1)
N23050426: JCPU1.C35 T18.1(TP-1)
N23050428: JCPU1.B35 T20.1(TP-1)
N23050430: JCPU1.A34 T8.1(TP-1)
N23050432: JCPU1.A35 T9.1(TP-1)
N23050450: JCPU1.AT2 T5.1(TP-1)
N23050532: JCPU1.E20 T36.1(TP-1)
N23050534: JCPU1.E21 T35.1(TP-1)
N23050555: JCPU1.E18 T30.1(TP-1)
N23050586: JCPU1.D23 T14.1(TP-1)
N23050714: JCPU1.W30 T26.1(TP-1)
N23050732: JCPU1.W31 T28.1(TP-1)
N23050736: JCPU1.W29 T10.1(TP-1)
N23050738: JCPU1.W28 T15.1(TP-1)
N23050778: JCPU1.P10 T32.1(TP-1)
N23050780: JCPU1.U10 T31.1(TP-1)
N23050887: JCPU1.AL25 T23.1(TP-1)
N23050901: JCPU1.AT1 T11.1(TP-1)
N23050918: JCPU1.AM26 T24.1(TP-1)
N23050938: JCPU1.AR33 T19.1(TP-1)
N23050940: JCPU1.AM27 T22.1(TP-1)
N23050958: JCPU1.B23 T7.1(TP-1)
N23050968: JCPU1.C23 T12.1(TP-1)
N23050970: JCPU1.D24 T13.1(TP-1)
N23051071: JCPU1.AL30 T16.1(TP-1)
N23051073: JCPU1.AL29 T17.1(TP-1)
N23051091: JCPU1.AD10 T6.1(TP-1)
N25368131: RV107.2 UV5.J13
N25669355: RV117.2 UV6.J13
N29179028: R802.2 U46.B18
N30639296: QC1.1 RC15.1
N31479955: R804.1 U46.B19
N35502990: Q29.5 Q29.6 R508.2
N35569138: C470.2 R1144.1 Y3.1
N45129141: Q22.1 R423.2
N46595644: T122.1(TP-1) U46.B14
N48324044: JLOM1.13 R1167.2
N48324090: JLOM1.11 R1653.2
N48705646: PL4.1 PQ1.1 PR10.1 PR13.2
N48705653: PQ1.3 PR10.2 PR12.1
N48705663: PQ2.2 PR13.1 PR15.2
N48705665: PQ1.2 PQ2.1 PR14.2 PR16.1
N48711348: PC522.1 PR534.1
N49342732: Q79.1 R3671.1
N50215889: Q81.1 R938.1
N50225127: Q81.2 Q84.3
N50261142: D59.2 D62.2 Q74.1 Q84.4 R932.2
N51922312: PC612.1 PR639.2
N51922366: PC600.2 PR600.2 PR607.2 PU600.38
N51922430: PR633.1 PU600.4
N51922457: PC617.1 PR645.1 PU600.16
N51922465: PR632.1 PU600.3
N51922471: PC614.2 PR642.1
N51922497: PC608.1 PC610.1 PR635.1 PU600.24 PU600.25
N51922603: PR627.2 PR629.2 PU600.1
N51922671: PH601.1 PR648.2
N51924346: PC618.1 PR643.1 PU600.17
N51924378: PH600.1 PR634.1
N53085144: PC206.2 PR200.1
N53085275: PR205.2 PU200.9
N57652826: JCPU1.AT35 T52.1(TP-1)
N57659725: JCPU1.AR35 T53.1(TP-1)
N57663191: JCPU1.AR32 T54.1(TP-1)
N57663201: JCPU1.AL26 T55.1(TP-1)
N60687816: C289.1 R1629.2 U8.1
N61506560: PR722.1 PU700.11
N63746311: R884.1 U51.B2
N63746359: R888.1 U51.B8
N67887850: D9.1 R429.2 R1137.1 U56.1 U56.2
N70862806: D59.1 Q74.3
N70877887: Q74.6 Q75.2
N70882773: Q79.2 Q100.1
N72304780: T86.1(TP-1) UH1.AY1
N79099120: PC700.2 PQ701.2 PQ702.2 PR702.2
N79099356: PQ703.1 PQ703.3 PR706.2 PR707.2 PR709.1
N79099544: PR717.2 PU700.5
N79100287: PQ701.1 PR701.2
N79100289: PQ702.1 PR701.3
N79100387: PQ700.4 PR700.1
N79108660: PQ709.1 PR730.2
N79108839: PR734.2 PR735.2 PR737.1 PR740.1 PU701.7
N79108872: PC727.1 PR725.1 PR728.2 PU701.3
N79108988: PC729.1 PR732.2 PR734.1 PR738.1 PU701.5
N79109000: PC730.1 PR733.2 PR739.1 PU701.6
N81870153: R65.2 U19.13
N81907121: R72.2 U19.23
N81942445: R76.1 U19.18
N85751870: PC306.2 PR301.2
N89358580: JCPU1.J27 T50.1(TP-1)
N90453832: R100.2 U27.2
N90453843: R101.2 U27.12
N91483552: JLVDS1.10 R3762.1
N91583193: C969.1 U74.31
N91583219: C962.1 U74.37
N91583239: R1642.1 U74.22
N91583289: Q106.3 R1080.2
N91583291: Q106.6 R1079.2
N91583293: C977.1 R1076.2
N91814876: RV36.2 UV1.K25
N92289874: R61.2 U6.8
N106528709: R1702.1 U38.26
N111614398: RV25.2 UV1.N10
N112194115: R887.1 U51.B57
N114027505: RV298.1 UV1.AA22
N114027546: RV296.1 UV1.Y22
N115146002: R1070.1 U51.B1
N116042141: T146.1(TP-1) U46.A44
N116870152: PR736.2 PR744.1 PU703.4
N116874102: PR710.2 PU703.6
N117654516: Q324.1 R1086.2
N118052171: D10.2 U54.4
N118416346: C962.2 U74.35
N119819670: JLOM1.10 R1166.2
N121245733: JMINI1.22 R704.2
N122052446: R657.1 U39.9
N123100505: PR111.2 PU100.19
N124735836: Q4.2 R55.2
N126014010: Q330.5 Q330.6 R1703.2
N126032191: Q24.1 Q32.2 R431.2
N126094999: QV4.1 RV56.1 RV58.1 RV60.2 RV77.2
N126095070: D71.2 RV47.2 RV53.2 RV55.1
N126095126: CV52.1 QV3.2 RV55.2 RV56.2 RV61.2
N126095150: QV4.2 RV57.2 RV59.1
N126095152: QV3.1 RV59.2
N126095187: CV53.1 QV7.2 RV58.2
N126163800: T131.1(TP-1) UV1.A32
N126163802: T132.1(TP-1) UV1.AM1
N126163816: T133.1(TP-1) UV1.AM32
N126182567: CV343.1 RV178.2 RV179.1
N126184618: T147.1(TP-1) U46.A23
N126244783: C445.1 U145.12
N126244789: C450.1 U145.10
N126984883: C437.1 U36.12
N126984889: C435.1 U36.10
N126986648: C438.1 U37.12
N126986654: C436.1 U37.10
N126989335: C444.1 U57.12
N126989341: C448.1 U57.10
N211306270: PC666.1 PU602.7
N211347431: PD813.2 PQ814.1

Pads without a net: FD1 1; FD2 1; FD3 1; FD4 1; H20 1; JAPS1 15 16; JCPU1 A24 A26 A28 A30 AA1 AA2 AC8 AD8 AF9 AG9 B1 B24 B25 B26 B27 B28 B29 B30 B31 C25 C27 C29 C31 D28 D30 D32 D34 E28 E29 E30 E31 E32 E33 E34 E35 F29 F31 F33 F35 L8 L10 M9 M10 P1 P2 P3 R1 U1 U2 V1 V2 Y1 Y2; JDIMM1 77 122 125 198; JDIMM2 77 122 125 198; JEXP1 22; JHDMI1 14; JIO1 9 13 14 25 26; JMDIA1 2; JMINI1 3 5 6 17 19 28 30 32 37 40 44 45 46 47 48 49 53; JMINI2 3 5 6 8 10 12 28 30 48; JMINI3 3 5 6 20 28 30 32 37 40 42 44 45 46 47 48 49 51 54; JSATA1 20 21 22; JSF1 1; JSIM1 4 8 9; JTCH1 3; JTP1 4 8; JUSH1 9 10; JXDP1 4 5 7 14 15 24; JXDP2 3 5 21 22 23 24 42 45 47 55; PQ601 3; PRP2 4 5; PU400 1 4 7; PU500 10; PU600 9 40; PU602 4; PU603 7; PU700 4; PU800 20 30 31 35 36; RP9 1 8; RP12 4 5; RP13 4 5; RP20 3 6; RPH13 3; RPH16 4 5; RPH17 4 5; RPH18 1 8; U19 36; U21 1; U24 1; U27 23 24 33 34; U32 5; U38 19 39 40 44 46; U39 6 7 12 13 14; U41 16 18 19 20; U46 A2 A15 A16 A49 A57 B1 B16 B32 B45 B61 B68; U51 A36 B15; U74 19 20 30 46; U88 2 3; UC2 1; UH1 A28 AB39 AB40 AH43 AH45 AJ10 AJ26 AJ28 AP15 AR13 AR15 AT13 AV36 AW36 BB37 BC12 BC14 BD37 BE12 BE14 C28 F22 F39 F41 G22 H43 H45 K22 Y12 Y35 Y38 Y39; UV1 AA3 AA5 AA6 AB2 AB4 AB7 AB8 AB9 AB11 AB12 AB13 AB22 AB23 AC1 AC3 AC5 AC6 AC7 AC8 AC10 AC11 AC13 AC14 AC16 AC20 AC22 AC23 AD2 AD4 AD7 AD9 AD10 AD11 AD13 AD16 AD20 AD22 AD23 AD24 AE1 AE3 AE5 AE6 AE8 AE9 AE10 AE11 AE13 AE16 AE19 AE22 AE23 AE24 AE25 AE26 AF2 AF4 AF6 AF7 AF8 AF9 AF10 AF11 AF13 AF16 AF17 AF19 AF20 AF22 AF23 AF24 AF25 AG1 AG3 AG5 AG6 AG7 AG8 AG9 AG10 AG11 AG13 AG14 AG15 AG16 AG17 AG18 AG19 AG20 AG21 AG22 AG23 AG24 AG26 AH1 AH3 AH5 AH6 AH8 AH12 AH14 AH16 AH18 AH20 AH22 AH24 AH26 AJ7 AJ9 AJ11 AJ15 AJ17 AJ19 AJ21 AJ23 AJ27 AK1 AK3 AK5 AK6 AK8 AK10 AK12 AK14 AK16 AK18 AK20 AK22 AK24 AL7 AL9 AL11 AL15 AL17 AL19 AL21 AL23 AL25 AM3 AM5 AM6 AM8 AM10 AM12 AM14 AM16 AM18 AM20 AM22 AM24 AM26 J8 J22 J25 K13 K30 L9 L16 L17 L29 L31 M27 M28 M30 N3 N5 N6 N9 N26 N29 N31 P23 P24 P26 P27 P28 P30 R1 R3 R29 R31 T7 T8 T10 T23 T24 T26 T27 T28 T30 U5 U7 U8 U10 U12 U23 U24 U26 U29 U31 V2 V4 V12 V27 V30 W3 W5 W6 W7 W8 W9 W10 W23 W24 Y2 Y4 Y7 Y8 Y9 Y11 Y12; UV3 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV4 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV5 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV6 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 927 vias
v2: diameter 0.406, hole 0.203, TOP to BOTTOM, 196 vias
v3: diameter 0.457, hole 0.203, TOP to BOTTOM, 6595 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 863 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.75V_DDR_VTT_ON: length 35.6
  TOP w0.102: RP6.3 187.01,60.2 v3(186.65,60.56) 187.32,60.56 v1(187.49,60.73) 187.62,60.86 U46.A60
  TOP w0.254: v3(182.2,84.57) 181.75,84.57 PR208.1
  IN1 w0.102: v3(186.65,60.56) 186.48,60.74 186.48,61.93 186.14,62.27 185.28,62.27 184.35,63.2 184.35,64.79 183.85,65.29 181.81,65.29 180.79,66.31 180.79,72.82 180.44,73.16 180.44,74.44 183.74,77.74 183.74,83.29 182.46,84.57 v3(182.2,84.57)
1.05V_A_PWRGD: length 65.7
  TOP w0.102: v3(213.59,79.72) 213.66,79.79 U51.B28
  TOP w0.254: PU300.1 178.04,94.68 178.31,94.41 178.31,93.97 178.18,93.84 PR300.1 v3(177.1,93.09)
  IN2 w0.127: v3(213.59,79.72) 213.59,80.04 214.29,80.74 214.29,83.51 214.78,84 214.78,86.63 215.52,87.37 v3(215.52,88.51)
  IN3 w0.127: v3(215.52,88.51) 215.14,88.51 214.59,87.96 205.92,87.96 203.25,85.3 202.53,85.3 201.36,84.13 199.34,84.13 198.76,83.54 195.81,83.54 194.02,81.75 181.57,81.75 180.41,82.92 180.41,88.06 178.25,90.22 177.23,90.22 176.53,90.92 176.53,92.53 v3(177.1,93.09)
  BOTTOM w0.102: v3(215.52,88.51) v1(216.35,87.68)
1.05V_RUN_ENABLE: length 6.8
  TOP w0.102: v1(156.54,109.85) 156.06,110.33 C773.1
  TOP w0.254: C773.1 R1611.1 156.07,111.95 R930.2 156.96,112.48 156.8,112.64 Q52.3 157.18,112.9 157.75,112.32 158.05,112.32 158.24,112.51 Q63.4
1.5VSP_FB: length 4.4
  TOP w0.102: v1(204.84,52.39) 204.46,52.77 PR405.1
  TOP w0.254: PR402.2 204.45,54.21 203.56,54.21 203.46,54.11 PU400.6 ; PR402.2 PC402.2 ; PR402.2 PR405.1
1.5VSP_LX:
  vias: v1(197.8,58.16)
1.5VSP_VIN: length 3.6
  TOP w0.102: v1(206.63,54.54) 206.63,55.49 206.19,55.93 204.15,55.93
1.35V_B+: length 13.2
  TOP w0.254: PR205.1 181.87,88.64 v3(181.98,88.75)
  BOTTOM w0.254: v3(170.05,90.16) 170.37,89.84 v1(172.02,89.84) 177.67,89.84 178.77,88.75 v3(181.98,88.75)
1.35V_FB: length 5.4
  TOP w0.203: PU200.6 178.73,85.79 178.88,85.64 178.88,84.64 179.07,84.45 v1(179.52,84.45) 180.07,84.45 PR207.2
  TOP w0.254: PR204.1 PC211.1 180.52,83.37 PR207.2
1.35V_SUS_PWRGD: length 172.3
  TOP w0.102: RC9.2 106.19,52.95 RC103.2 107.56,52.58 108.5,51.64 108.5,50.29 v3(108.11,49.9) ; U51.B9 209.68,74.79 v3(209.62,74.86)
  TOP w0.203: v3(179.11,88) 179.11,87.66 178.84,87.39 PU200.10
  TOP w0.254: PR209.2 180.41,89.53 179.11,88.23 v3(179.11,88)
  IN2 w0.127: v3(209.62,74.86) 209.81,74.67 209.81,73.29 210.4,72.69 210.4,71.36 209.58,70.54 204.73,70.54 203.96,69.78 203.96,66.17 200.15,62.36 190.7,62.36 188.91,60.57 188.09,60.57 187.65,60.13 v3(187.65,59.68) 187.28,59.31 182.45,59.31 179.79,61.97 178.99,61.97 178.46,62.49 178.46,63.03 177.95,63.53 177.95,64.91 177.61,65.26 177.61,66.33 176.09,67.85 176.09,70.28 170.54,75.83 170.54,77.58 170.93,77.97 174.83,77.97 179.37,82.52 179.37,87.74 v3(179.11,88)
  BOTTOM w0.102: v3(108.11,49.9) 108.55,50.34 160.86,50.34 165.85,55.32 v1(171.2,55.32) 173.53,55.32 174.77,56.55 183.9,56.55 186.16,58.82 186.78,58.82 v3(187.65,59.68)
3.3V_RUN_GFX_ON: length 77.4
  TOP w0.102: v3(181.15,108.13) 169.99,108.13 166.19,111.93 v2(166.19,112.55) 166.19,113.6 164.96,114.84 QH3.2 ; v3(185.8,61) 185.12,61.69 U46.A55
  IN2 w0.127: v3(185.8,61) 185.79,61 184.4,62.4 181.41,62.4 180.41,63.4 180.41,64.36 178.15,66.61 178.15,66.97 177.2,67.92 177.2,72.22 176.18,73.25 176.18,77.34 180.77,81.94 180.77,90.1 181.7,91.03 181.7,104.62 181.47,104.85 181.47,107.81 v3(181.15,108.13)
3V_5V_EN: length 9.3
  TOP w0.203: v4(196.85,36.12) 197.3,36.12 197.45,36.27 PU100.6 ; PR110.2 196.58,41.46 196.58,40.45 v4(196.92,40.12) 197.3,40.12 197.45,39.97 PU100.20
  TOP w0.254: PC120.1 195.51,41.68 PR110.2
  BOTTOM w0.254: v4(196.85,36.12) 196.92,36.19 v1(196.92,37.63) v4(196.92,40.12)
+0.9V_LAN: length 8.6
  TOP w0.203: U31.11 244.18,165.68 v3(244.29,165.79) ; v3(240.35,160.01) 240.42,160.08 U31.43 ; v3(239.21,168.77) 238.82,168.39 U31.22 ; v3(241.22,167.74) U31.16 ; v3(244.22,164.39) 244.13,164.48 U31.8 ; v3(239.22,159.95) U31.40
  TOP w0.508: C469.1 236.03,158.93 v3(236.86,159.76)
  vias: v2(235.61,170.31) v3(235.55,169.73) v3(236.18,169.73) v3(242.13,159.88) v3(244.4,167.38) v3(244.98,167.39)
+0.675V_DDR_VTT: length 56.8
  TOP w1.016: 169.83,80.41 174.94,80.41 175.77,81.24 175.77,82.11
  IN4 w1.016: 157.35,35.68 157.35,41.6 156.66,42.28 156.66,59.31 163.37,66.01 163.37,76.81 164.5,77.94 165.67,77.94 167.56,79.83
  vias: v2(156.26,34.36) v3(155.2,22.72) v3(155.2,22.11) v3(155.21,15.75) v3(155.23,15.12) v3(155.45,28.18) v3(155.45,27.55) v3(156.47,36.03) v3(156.47,35.42) v3(168.4,80.32) v3(168.78,80.76)
+0.675V_P:
  vias: v1(174.14,84.47)
+1.2V_LDO: length 26.4
  TOP w0.203: U38.10 182.74,25.26 182.17,24.69 182.12,24.69 ; U38.41 186.99,30.46 187.17,30.65 187.17,31.47 187.5,31.8
  TOP w0.508: v3(180.6,22.94) 180.6,22.99 180.99,23.38 C1506.2 180.99,23.56 181.79,24.36 181.79,24.36 182.02,24.58 182.02,24.59 182.12,24.69
  IN2 w0.508: v3(188.9,33.65) 187.77,33.65 186.88,32.76 180.48,32.76 178.55,30.83 178.55,25.47 180.6,23.42 v3(180.6,22.94)
  vias: v1(189.61,33.45)
+1.2V_LDO_OZ: length 8.6
  TOP w0.203: C1508.2 181.98,29.89 182.39,29.89 182.88,29.39 182.88,28.95 182.97,28.86 U38.1 ; v3(190.31,25.52) 190.12,25.52 189.98,25.66 U38.28 ; 191.48,26.84 191.15,26.51 190.34,26.51 189.98,26.86 U38.31 ; U38.36 189.78,28.86 190.34,29.42 191.15,29.42
  TOP w0.508: v3(181.5,31.03) C1508.2
  vias: v1(191.9,28.88) v3(190.29,30.68) v3(190.87,30.68)
+1.2V_OZ_AUX_LDO: length 7.8
  TOP w0.102: 181.17,19.6 181.17,18.57 v1(181.87,17.87)
  TOP w0.203: U38.12 182.95,24.07 182.95,23.87
  TOP w0.508: 181.17,19.6 181.17,20.03 182.02,20.88 182.02,22.32 182.95,23.24 182.95,23.87
+1.5V_CARD: length 33.3
  TOP w0.102: 231.69,59.78 229.83,59.78 v2(229.48,59.43)
  TOP w0.254: U41.13 234.63,59.87 v3(234.7,59.81)
  IN2 w1.016: 224.86,32.44 225.79,33.37 225.79,40.33 224.66,41.46 224.66,50.53 229.59,55.46 229.59,58.25 230.32,58.98
  vias: v3(223.92,32.74) v3(223.89,32.15) v3(231.71,59.05) v3(231.71,58.46)
+1.05V_M: length 2.6
  TOP w0.254: CH29.1 170.73,136.32 171.24,135.82 v3(171.24,135.62)
  TOP w0.508: v3(168.63,135.58) 168.63,135.36 168.59,135.32 CH30.1
  BOTTOM w0.254: UH1.L17 171.48,135.29 171.24,135.53 v3(171.24,135.62)
  vias: v2(164.09,107.97) v3(160.31,106.75) v3(160.31,106.16) v3(160.9,106.75) v3(160.9,106.16) v3(161.48,106.75) v3(161.48,106.16) v3(167.41,118.99) v3(168.02,137.21) v3(167.97,135.58) v3(168,118.99) v3(169.3,135.58)
