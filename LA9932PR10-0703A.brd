# Allegro board LA9932PR10-0703A.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
PS8401ATQFN40GTR-A3_TQFN40_5X5
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 21(3.6,4.975) 22(3.2,4.975) 23(2.8,4.975) 24(2.4,4.975) 25(2,4.975) 26(1.6,4.975) 27(1.2,4.975) 28(0.8,4.975) 29(0.4,4.975) 30(0,4.975)
  oval 1.016x0.203 smd: 11(4.288,0.688) 12(4.288,1.088) 13(4.288,1.488) 14(4.288,1.888) 15(4.288,2.288) 16(4.288,2.688) 17(4.288,3.088) 18(4.288,3.488) 19(4.288,3.888) 20(4.288,4.288) 31(-0.688,4.288) 32(-0.688,3.888) 33(-0.688,3.488) 34(-0.688,3.088) 35(-0.688,2.688) 36(-0.688,2.288) 37(-0.688,1.888) 38(-0.688,1.488) 39(-0.688,1.088) 40(-0.688,0.688)
  rect 3.607x3.607 smd: 41(1.8,2.488)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R0805_0OHM
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.445x0.445 smd: 1(0,0) 4(5.004,0)
  custom 0.114x0.114 smd: 2(1.194,0) 3(3.81,0)
RB717F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
RB751V40_SC76-2
  rect 0.61x0.61 smd: 1(0,0) 2(2.2,0)
RB751V-40_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
RHU002N06_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8207MZQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RT9818A-44GU3_SC70-3
  oval 0.61x0.787 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
RTD2136S-CG_QFN48_6X6
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,5.95) 26(4,5.95) 27(3.6,5.95) 28(3.2,5.95) 29(2.8,5.95) 30(2.4,5.95) 31(2,5.95) 32(1.6,5.95) 33(1.2,5.95) 34(0.8,5.95) 35(0.4,5.95) 36(0,5.95)
  oval 1.041x0.203 smd: 13(5.175,0.775) 14(5.175,1.175) 15(5.175,1.575) 16(5.175,1.975) 17(5.175,2.375) 18(5.175,2.775) 19(5.175,3.175) 20(5.175,3.575) 21(5.175,3.975) 22(5.175,4.375) 23(5.175,4.775) 24(5.175,5.175) 37(-0.775,5.175) 38(-0.775,4.775) 39(-0.775,4.375) 40(-0.775,3.975) 41(-0.775,3.575) 42(-0.775,3.175) 43(-0.775,2.775) 44(-0.775,2.375) 45(-0.775,1.975) 46(-0.775,1.575) 47(-0.775,1.175) 48(-0.775,0.775)
  rect 3.962x3.962 smd: 49(2.2,2.975)
SAMTE_BSH-030-01-L-D-A_60P
  round 1.016 hole 1.016 unplated: (-2.81,5.53) (17.316,5.53)
  oval 0.279x2.261 smd: 1(0,0) 2(0,5.728) 3(0.5,0) 4(0.5,5.728) 5(1,0) 6(1,5.728) 7(1.5,0) 8(1.5,5.728) 9(2,0) 10(2,5.728) 11(2.5,0) 12(2.5,5.728) 13(3,0) 14(3,5.728) 15(3.5,0) 16(3.5,5.728) 17(4,0) 18(4,5.728) 19(4.5,0) 20(4.5,5.728) 21(5,0) 22(5,5.728) 23(5.5,0) 24(5.5,5.728) 25(6,0) 26(6,5.728) 27(6.5,0) 28(6.5,5.728) 29(7,0) 30(7,5.728) 31(7.5,0) 32(7.5,5.728) 33(8,0) 34(8,5.728) 35(8.5,0) 36(8.5,5.728) 37(9,0) 38(9,5.728) 39(9.5,0) 40(9.5,5.728) 41(10,0) 42(10,5.728) 43(10.5,0) 44(10.5,5.728) 45(11,0) 46(11,5.728) 47(11.5,0) 48(11.5,5.728) 49(12,0) 50(12,5.728) 51(12.5,0) 52(12.5,5.728) 53(13,0) 54(13,5.728) 55(13.5,0) 56(13.5,5.728) 57(14,0) 58(14,5.728) 59(14.5,0) 60(14.5,5.728)
SANTA_196003-1_22P
  round 1.6 hole 1.6 unplated: (-32.47,-3) (0.72,-3)
  oval 0.889x2.388 smd: 1(0,0) 2(-1.27,0) 3(-2.54,0) 4(-3.81,0) 5(-5.08,0) 6(-6.35,0) 7(-7.62,0) 8(-13.97,0) 9(-15.24,0) 10(-16.51,0) 11(-17.78,-0.5) 12(-19.05,0) 13(-20.32,0) 14(-21.59,0) 15(-22.86,0) 16(-24.13,0) 17(-25.4,0) 18(-26.67,0) 19(-27.94,-0.5) 20(-29.21,0) 21(-30.48,0) 22(-31.75,0)
  oval 1.803x3.277 hole 0.991x2.489: 23(-34.585,-2.24) 24(2.835,-2.24)
SANTA_373130-1_9P
  round 0.991 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.397x3.2 hole 0.787x2.591: 10(4.35,-2.38) 13(-11.35,-2.38)
  oval 1.397x2.388 hole 0.787x1.803: 11(4.35,-9.48) 12(-11.35,-9.48)
SBR3A40SA-13_SMA2
  rect 2.489x1.702 smd: 1(0,0) 2(4,0)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI4835BDY-T1-E3_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.285) 6(2.54,5.285) 7(1.27,5.285) 8(0,5.285)
SI7170DP-T1-GE3_POWERPAK8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.36)
SI7716ADN-T1-GE3_POWERPAK8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SINGA_2SJ3082-000111F_6P-T
  round 1.194 hole 1.194 unplated: (3.8,9.1) (3.8,3.1)
  oval 1.092x1.905 hole 0.61x1.397: 1(0,0) 2(7.5,7.6) 3(0.1,9.9) 4(6.5,9.7) 5(6,0) 6(7.6,0) 7(8.4,4.6) 8(-0.8,5.6)
SIR472DP-T1-GE3_POWERPAK8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.36)
SIR818DP-T1_POWERPAK-SO8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
SIS412DN-T1-GE3_POWERPAK8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SLGC55584AVTR_TDFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.6x0.889 smd: 9(0.75,1.1)
SN74LVC1G07DCKR_SC70-5
  oval 0.381x0.864 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0,1.74)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
SW_SKRBAAE010_4P
  rect 0.889x1.219 smd: 1(0,0) 2(3.9,0) 3(0,4.075) 4(3.9,4.075)
SY8033BDBC_DFN10_3X3
  oval 0.305x0.559 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.7) 7(1.5,2.7) 8(1,2.7) 9(0.5,2.7) 10(0,2.7)
  rect 2.591x1.753 smd: 11(1,1.35)
SY8036DBC_DFN10_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,3.1) 7(1.5,3.1) 8(1,3.1) 9(0.5,3.1) 10(0,3.1)
  rect 2.388x1.575 smd: 11(1,1.55)
T-SOL_159-1000302602_10P-T
  round 0.889 hole 0.889 unplated: (2.885,-1.425) (3.075,-14.375)
  oval 0.508x1.245 smd: 1(0,0) 2(-1.4,0) 3(-2.8,0) 4(-4.2,0) 5(-0.7,0) 6(-2.1,0) 7(-3.5,0) 8(-4.9,0) 9(-5.6,0) 10(0.7,0)
  rect 0.889x1.397 smd: 11(3.355,0.075) 18(-6.755,0.075)
  rect 0.381x1.6 smd: 12(5.11,-2.475)
  rect 0.381x1.499 smd: 13(5.11,-9.325) 16(-9.22,-9.325)
  rect 1.092x1.092 smd: 14(4.745,-15.145) 15(-8.855,-15.145)
  rect 0.381x1.245 smd: 17(-9.22,-3.085)
TAIMA_IH-115-F_24P
  oval 0.762x2.057 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0) 8(8.89,0) 9(10.16,0) 10(11.43,0) 11(12.7,0) 12(13.97,0) 13(13.97,9.365) 14(12.7,9.365) 15(11.43,9.365) 16(10.16,9.365) 17(8.89,9.365) 18(7.62,9.365) 19(6.35,9.365) 20(5.08,9.365) 21(3.81,9.365) 22(2.54,9.365) 23(1.27,9.365) 24(0,9.365)
TAIYO_CBC2012T4R7M_2P
  rect 0.711x1.448 smd: 1(0,0) 2(1.5,0)
TAIYO_FBMJ4516HS720NT_2P
  rect 1.549x1.854 smd: 1(0,0) 2(3.95,0)
TC7SET04FU_SSOP5
  oval 0.381x1.321 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.8) 5(0,1.8)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TOKO_FDSD0420-H-1R0M-P3T_2P
  rect 1.702x2.388 smd: 1(0,0) 2(3.5,0)
TOKO_FDSD0630-H-1R0M-P3_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
TOKO_FDUE1040D-1R0M-P3_2P
  rect 2.896x4.597 smd: 1(0,0) 2(8.9,0)
TOKO_FDVE1040-H-5R6M-P3_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.8,0)
TPC12
  round 0.305 smd: 1(0,0)
TPS2231MRGPR-2_QFN20_4X4
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 11(2,3.95) 12(1.5,3.95) 13(1,3.95) 14(0.5,3.95) 15(0,3.95)
  oval 0.838x0.279 smd: 6(2.975,0.975) 7(2.975,1.475) 8(2.975,1.975) 9(2.975,2.475) 10(2.975,2.975) 16(-0.975,2.975) 17(-0.975,2.475) 18(-0.975,1.975) 19(-0.975,1.475) 20(-0.975,0.975)
  rect 2.21x2.21 smd: 21(1,1.975)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS51212DSCR_SON10_3X3
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.95) 7(1.5,2.95) 8(1,2.95) 9(0.5,2.95) 10(0,2.95)
  custom 0.412x0.412 smd: 11(1,1.475)
TPS51225CRUKR_QFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
TS5A63157DCKR_SC70-6
  oval 0.406x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,2.2) 5(0.65,2.2) 6(0,2.2)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
TVWDF1004AD0_DFN9
  oval 0.203x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.406x1.549 smd: 3(1,0.437)
TYCO_1-2041070-6_16P
  oval 0.305x1.295 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0)
  rect 2.489x1.905 smd: 17(2.15,3.3) 18(-9.65,3.3)
TYCO_2-2013290-1_204P
  round 1.092 hole 1.092 unplated: (-65.05,-4.1)
  round 1.6 hole 1.6 unplated: (1.75,-4.1)
  oval 0.356x2.007 smd: 1(0,0) 2(-0.3,-8.2) 3(-0.6,0) 4(-0.9,-8.2) 5(-1.2,0) 6(-1.5,-8.2) 7(-1.8,0) 8(-2.1,-8.2) 9(-2.4,0) 10(-2.7,-8.2) 11(-3,0) 12(-3.3,-8.2) 13(-3.6,0) 14(-3.9,-8.2) 15(-4.2,0) 16(-4.5,-8.2) 17(-4.8,0) 18(-5.1,-8.2) 19(-5.4,0) 20(-5.7,-8.2) 21(-6,0) 22(-6.3,-8.2) 23(-6.6,0) 24(-6.9,-8.2) 25(-7.2,0) 26(-7.5,-8.2) 27(-7.8,0) 28(-8.1,-8.2) 29(-8.4,0) 30(-8.7,-8.2) 31(-9,0) 32(-9.3,-8.2) 33(-9.6,0) 34(-9.9,-8.2) 35(-10.2,0) 36(-10.5,-8.2) 37(-10.8,0) 38(-11.1,-8.2) 39(-11.4,0) 40(-11.7,-8.2) 41(-12,0) 42(-12.3,-8.2) 43(-12.6,0) 44(-12.9,-8.2) 45(-13.2,0) 46(-13.5,-8.2) 47(-13.8,0) 48(-14.1,-8.2) 49(-14.4,0) 50(-14.7,-8.2) 51(-15,0) 52(-15.3,-8.2) 53(-15.6,0) 54(-15.9,-8.2) 55(-16.2,0) 56(-16.5,-8.2) 57(-16.8,0) 58(-17.1,-8.2) 59(-17.4,0) 60(-17.7,-8.2) 61(-18,0) 62(-18.3,-8.2) 63(-18.6,0) 64(-18.9,-8.2) 65(-19.2,0) 66(-19.5,-8.2) 67(-19.8,0) 68(-20.1,-8.2) 69(-20.4,0) 70(-20.7,-8.2) 71(-21,0) 72(-21.3,-8.2) 73(-24,0) 74(-24.3,-8.2) 75(-24.6,0) 76(-24.9,-8.2) 77(-25.2,0) 78(-25.5,-8.2) 79(-25.8,0) 80(-26.1,-8.2) 81(-26.4,0) 82(-26.7,-8.2) 83(-27,0) 84(-27.3,-8.2) 85(-27.6,0) 86(-27.9,-8.2) 87(-28.2,0) 88(-28.5,-8.2) 89(-28.8,0) 90(-29.1,-8.2) 91(-29.4,0) 92(-29.7,-8.2) 93(-30,0) 94(-30.3,-8.2) 95(-30.6,0) 96(-30.9,-8.2) 97(-31.2,0) 98(-31.5,-8.2) 99(-31.8,0) 100(-32.1,-8.2) 101(-32.4,0) 102(-32.7,-8.2) 103(-33,0) 104(-33.3,-8.2) 105(-33.6,0) 106(-33.9,-8.2) 107(-34.2,0) 108(-34.5,-8.2) 109(-34.8,0) 110(-35.1,-8.2) 111(-35.4,0) 112(-35.7,-8.2) 113(-36,0) 114(-36.3,-8.2) 115(-36.6,0) 116(-36.9,-8.2) 117(-37.2,0) 118(-37.5,-8.2) 119(-37.8,0) 120(-38.1,-8.2) 121(-38.4,0) 122(-38.7,-8.2) 123(-39,0) 124(-39.3,-8.2) 125(-39.6,0) 126(-39.9,-8.2) 127(-40.2,0) 128(-40.5,-8.2) 129(-40.8,0) 130(-41.1,-8.2) 131(-41.4,0) 132(-41.7,-8.2) 133(-42,0) 134(-42.3,-8.2) 135(-42.6,0) 136(-42.9,-8.2) 137(-43.2,0) 138(-43.5,-8.2) 139(-43.8,0) 140(-44.1,-8.2) 141(-44.4,0) 142(-44.7,-8.2) 143(-45,0) 144(-45.3,-8.2) 145(-45.6,0) 146(-45.9,-8.2) 147(-46.2,0) 148(-46.5,-8.2) 149(-46.8,0) 150(-47.1,-8.2) 151(-47.4,0) 152(-47.7,-8.2) 153(-48,0) 154(-48.3,-8.2) 155(-48.6,0) 156(-48.9,-8.2) 157(-49.2,0) 158(-49.5,-8.2) 159(-49.8,0) 160(-50.1,-8.2) 161(-50.4,0) 162(-50.7,-8.2) 163(-51,0) 164(-51.3,-8.2) 165(-51.6,0) 166(-51.9,-8.2) 167(-52.2,0) 168(-52.5,-8.2) 169(-52.8,0) 170(-53.1,-8.2) 171(-53.4,0) 172(-53.7,-8.2) 173(-54,0) 174(-54.3,-8.2) 175(-54.6,0) 176(-54.9,-8.2) 177(-55.2,0) 178(-55.5,-8.2) 179(-55.8,0) 180(-56.1,-8.2) 181(-56.4,0) 182(-56.7,-8.2) 183(-57,0) 184(-57.3,-8.2) 185(-57.6,0) 186(-57.9,-8.2) 187(-58.2,0) 188(-58.5,-8.2) 189(-58.8,0) 190(-59.1,-8.2) 191(-59.4,0) 192(-59.7,-8.2) 193(-60,0) 194(-60.3,-8.2) 195(-60.6,0) 196(-60.9,-8.2) 197(-61.2,0) 198(-61.5,-8.2) 199(-61.8,0) 200(-62.1,-8.2) 201(-62.4,0) 202(-62.7,-8.2) 203(-63,0) 204(-63.3,-8.2)
  rect 3.505x4.597 smd: 205(1.15,7.9) 206(-64.45,7.9)
TYCO_2-2013311-1_204P
  round 1.092 hole 1.092 unplated: (-65.05,-4.1)
  round 1.6 hole 1.6 unplated: (1.75,-4.1)
  oval 0.356x2.007 smd: 1(0,0) 2(-0.3,-8.2) 3(-0.6,0) 4(-0.9,-8.2) 5(-1.2,0) 6(-1.5,-8.2) 7(-1.8,0) 8(-2.1,-8.2) 9(-2.4,0) 10(-2.7,-8.2) 11(-3,0) 12(-3.3,-8.2) 13(-3.6,0) 14(-3.9,-8.2) 15(-4.2,0) 16(-4.5,-8.2) 17(-4.8,0) 18(-5.1,-8.2) 19(-5.4,0) 20(-5.7,-8.2) 21(-6,0) 22(-6.3,-8.2) 23(-6.6,0) 24(-6.9,-8.2) 25(-7.2,0) 26(-7.5,-8.2) 27(-7.8,0) 28(-8.1,-8.2) 29(-8.4,0) 30(-8.7,-8.2) 31(-9,0) 32(-9.3,-8.2) 33(-9.6,0) 34(-9.9,-8.2) 35(-10.2,0) 36(-10.5,-8.2) 37(-10.8,0) 38(-11.1,-8.2) 39(-11.4,0) 40(-11.7,-8.2) 41(-12,0) 42(-12.3,-8.2) 43(-12.6,0) 44(-12.9,-8.2) 45(-13.2,0) 46(-13.5,-8.2) 47(-13.8,0) 48(-14.1,-8.2) 49(-14.4,0) 50(-14.7,-8.2) 51(-15,0) 52(-15.3,-8.2) 53(-15.6,0) 54(-15.9,-8.2) 55(-16.2,0) 56(-16.5,-8.2) 57(-16.8,0) 58(-17.1,-8.2) 59(-17.4,0) 60(-17.7,-8.2) 61(-18,0) 62(-18.3,-8.2) 63(-18.6,0) 64(-18.9,-8.2) 65(-19.2,0) 66(-19.5,-8.2) 67(-19.8,0) 68(-20.1,-8.2) 69(-20.4,0) 70(-20.7,-8.2) 71(-21,0) 72(-21.3,-8.2) 73(-24,0) 74(-24.3,-8.2) 75(-24.6,0) 76(-24.9,-8.2) 77(-25.2,0) 78(-25.5,-8.2) 79(-25.8,0) 80(-26.1,-8.2) 81(-26.4,0) 82(-26.7,-8.2) 83(-27,0) 84(-27.3,-8.2) 85(-27.6,0) 86(-27.9,-8.2) 87(-28.2,0) 88(-28.5,-8.2) 89(-28.8,0) 90(-29.1,-8.2) 91(-29.4,0) 92(-29.7,-8.2) 93(-30,0) 94(-30.3,-8.2) 95(-30.6,0) 96(-30.9,-8.2) 97(-31.2,0) 98(-31.5,-8.2) 99(-31.8,0) 100(-32.1,-8.2) 101(-32.4,0) 102(-32.7,-8.2) 103(-33,0) 104(-33.3,-8.2) 105(-33.6,0) 106(-33.9,-8.2) 107(-34.2,0) 108(-34.5,-8.2) 109(-34.8,0) 110(-35.1,-8.2) 111(-35.4,0) 112(-35.7,-8.2) 113(-36,0) 114(-36.3,-8.2) 115(-36.6,0) 116(-36.9,-8.2) 117(-37.2,0) 118(-37.5,-8.2) 119(-37.8,0) 120(-38.1,-8.2) 121(-38.4,0) 122(-38.7,-8.2) 123(-39,0) 124(-39.3,-8.2) 125(-39.6,0) 126(-39.9,-8.2) 127(-40.2,0) 128(-40.5,-8.2) 129(-40.8,0) 130(-41.1,-8.2) 131(-41.4,0) 132(-41.7,-8.2) 133(-42,0) 134(-42.3,-8.2) 135(-42.6,0) 136(-42.9,-8.2) 137(-43.2,0) 138(-43.5,-8.2) 139(-43.8,0) 140(-44.1,-8.2) 141(-44.4,0) 142(-44.7,-8.2) 143(-45,0) 144(-45.3,-8.2) 145(-45.6,0) 146(-45.9,-8.2) 147(-46.2,0) 148(-46.5,-8.2) 149(-46.8,0) 150(-47.1,-8.2) 151(-47.4,0) 152(-47.7,-8.2) 153(-48,0) 154(-48.3,-8.2) 155(-48.6,0) 156(-48.9,-8.2) 157(-49.2,0) 158(-49.5,-8.2) 159(-49.8,0) 160(-50.1,-8.2) 161(-50.4,0) 162(-50.7,-8.2) 163(-51,0) 164(-51.3,-8.2) 165(-51.6,0) 166(-51.9,-8.2) 167(-52.2,0) 168(-52.5,-8.2) 169(-52.8,0) 170(-53.1,-8.2) 171(-53.4,0) 172(-53.7,-8.2) 173(-54,0) 174(-54.3,-8.2) 175(-54.6,0) 176(-54.9,-8.2) 177(-55.2,0) 178(-55.5,-8.2) 179(-55.8,0) 180(-56.1,-8.2) 181(-56.4,0) 182(-56.7,-8.2) 183(-57,0) 184(-57.3,-8.2) 185(-57.6,0) 186(-57.9,-8.2) 187(-58.2,0) 188(-58.5,-8.2) 189(-58.8,0) 190(-59.1,-8.2) 191(-59.4,0) 192(-59.7,-8.2) 193(-60,0) 194(-60.3,-8.2) 195(-60.6,0) 196(-60.9,-8.2) 197(-61.2,0) 198(-61.5,-8.2) 199(-61.8,0) 200(-62.1,-8.2) 201(-62.4,0) 202(-62.7,-8.2) 203(-63,0) 204(-63.3,-8.2)
  rect 4.699x6.807 smd: 205(5.7,7.2) 206(-69,7.2)
TYCO_2-2041070-0_20P-T
  oval 0.305x1.295 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0)
  rect 2.489x1.905 smd: 21(-11.65,3.3) 22(2.15,3.3)
TYCO_2-2129116-3_31P-T
  round 0.94 hole 0.94 unplated: (-20.88,-4.825) (2.12,-4.825)
  round 0.991 hole 0.61: 1(0,0) 2(-1.27,0) 3(-2.54,0) 4(-3.81,0) 5(-5.08,0) 6(-6.35,0) 7(-7.62,0) 8(-13.83,-0.2) 9(-14.83,-1.2) 10(-15.83,-0.2) 11(-16.83,-1.2) 12(-17.83,-0.2) 13(-18.83,-1.2) 14(-0.379,-3.9) 15(-1.179,-1.5) 16(-1.979,-2.7) 17(-2.779,-3.9) 18(-3.579,-1.5) 19(-4.379,-2.7) 20(-5.18,-3.9) 21(-5.98,-1.5) 22(-6.78,-2.7) 23(-7.58,-3.9) 24(-8.38,-1.5) 25(-13.38,-2.7) 26(-14.18,-3.9) 27(-14.98,-2.7) 28(-15.78,-3.9) 29(-16.58,-2.7) 30(-17.38,-3.9) 31(-18.181,-2.7)
  oval 1.194x2.438 hole 0.508x1.753: 32(2.12,-1.8) 33(-20.88,-1.8)
W25Q32FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q64FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
WGI217LM-QPN9-A2_QFN48_6X6
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,5.95) 26(4,5.95) 27(3.6,5.95) 28(3.2,5.95) 29(2.8,5.95) 30(2.4,5.95) 31(2,5.95) 32(1.6,5.95) 33(1.2,5.95) 34(0.8,5.95) 35(0.4,5.95) 36(0,5.95)
  oval 1.041x0.203 smd: 13(5.175,0.775) 14(5.175,1.175) 15(5.175,1.575) 16(5.175,1.975) 17(5.175,2.375) 18(5.175,2.775) 19(5.175,3.175) 20(5.175,3.575) 21(5.175,3.975) 22(5.175,4.375) 23(5.175,4.775) 24(5.175,5.175) 37(-0.775,5.175) 38(-0.775,4.775) 39(-0.775,4.375) 40(-0.775,3.975) 41(-0.775,3.575) 42(-0.775,3.175) 43(-0.775,2.775) 44(-0.775,2.375) 45(-0.775,1.975) 46(-0.775,1.575) 47(-0.775,1.175) 48(-0.775,0.775)
  rect 2.997x2.997 smd: 49(2.2,2.975)
Y_7V27000050_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_Q13FC1350000_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_Q22FA2380049900_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.6) 4(0,1.6)
Y_X3G025000DI1H-H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
0.75V_DDR_VTT_ON: PR208.1 RP6.3 U46.A60
1.05V_A_PWRGD: PR300.1 PU300.1 U51.B28
1.05V_RUN_ENABLE: C773.1 Q52.3 Q63.4 R930.2 R1611.1
1.5VSP_FB: PC402.2 PR402.2 PR405.1 PU400.6
1.5VSP_LX: PC407.1 PL401.1 PU400.2 PU400.3
1.5VSP_VIN: PC400.1 PC401.1 PJP400.1 PU400.8 PU400.9 PU400.10
1.35V_B+: PC202.1 PC203.1 PC205.1 PJP200.1 PQ201.5 PR205.1
1.35V_FB: PC211.1 PR204.1 PR207.2 PU200.6
1.35V_SUS_PWRGD: PR209.2 PU200.10 RC9.2 RC103.2 U51.B9
3.3V_RUN_GFX_ON: QH3.2 U46.A55
3V_5V_EN: PC120.1 PR110.2 PU100.6 PU100.20
+0.9V_LAN: C462.1 C463.1 C466.1 C467.1 C468.1 C469.1 C1177.1 L29.2 U31.8 U31.11 U31.16 U31.22 U31.37 U31.40 U31.43 U31.46 U31.47
+0.675V_DDR_VTT: CD17.1 CD18.1 CD19.1 CD20.1 CD39.1 CD40.1 CD41.1 CD42.1 JDIMM1.203 JDIMM1.204 JDIMM2.203 JDIMM2.204 PJP202.1 R927.1
+0.675V_P: PC207.1 PC208.1 PJP202.2 PU200.2 PU200.20
+1.2V_LDO: C1505.2 C1506.2 C1507.2 L47.2 U38.10 U38.41
+1.2V_LDO_OZ: C561.2 C1508.2 C1509.2 C1510.2 L47.1 U38.1 U38.28 U38.31 U38.36
+1.2V_OZ_AUX_LDO: C564.2 U38.12
+1.5V_CARD: C637.1 C638.1 C645.1 JEXP1.10 JEXP1.12 U41.11 U41.13
+1.05V_M: CH28.1 CH29.1 CH30.1 PJP301.1 Q63.5 Q63.6 Q63.7 Q63.8 UH1.AA18 UH1.L17 UH1.R18 UH1.U18 UH1.U20 UH1.U22 UH1.U24 UH1.V18 UH1.V20 UH1.V22 UH1.V24 UH1.Y18 UH1.Y20 UH1.Y22
+1.05V_MP: PC301.1 PC310.1 PJP301.2 PL301.2 PR306.1
+1.5V_RUN: C635.1 CH52.1 LH1.1 PJP2.1 PJP401.1 RH51.1 RH57.2 RH96.1 RH98.2 RH99.1 RH100.1 RH163.2 RH165.2 RH188.1 RH192.1 U41.12 U41.14 UH1.AF34 UH1.AK26 UH1.AK28 UH1.AN11 UH1.AW40 UH1.BB44 UH1.BE22
+1.05V_RUN: C772.1 CH21.1 CH22.1 CH23.1 CH24.1 CH25.1 CH34.1 CH35.1 CH36.1 CH37.1 CH38.1 CH47.1 CH50.1 JXDP2.40 Q63.1 Q63.2 Q63.3 R866.2 R925.1 R931.1 R1179.1 RC27.1 RC53.1 RC54.1 RC55.1 RC57.1 RC60.1 RC85.1 RC86.2 RC99.2 RC105.2 RH206.1 RH244.1 RH246.1 UH1.AA24 UH1.AA26 UH1.AD20 UH1.AD22 UH1.AD24 UH1.AD26 UH1.AD28 UH1.AE18 UH1.AE20 UH1.AE22 UH1.AE24 UH1.AE26 UH1.AG18 UH1.AG20 UH1.AG22 UH1.AG24 UH1.AK18 UH1.AK20 UH1.AK22 UH1.AM18 UH1.AM20 UH1.AM22 UH1.AN34 UH1.AN35 UH1.AP22 UH1.AR22 UH1.AT22 UH1.U30 UH1.U35 UH1.U36 UH1.V28 UH1.V30 UH1.Y26 UH1.Y30
+1.05V_RUN_CHG: Q70.1 R925.2
+1.5V_RUN_HDMI: C340.1 C342.1 C344.1 C354.1 C355.1 PJP2.2 U19.12 U19.19 U19.20 U19.31 U19.40
+1.5V_RUNP: PC402.1 PC403.1 PC404.1 PC405.1 PJP401.2 PL401.2 PR402.1
+1.05VSP_5V: PC308.1 PR309.1 PU300.7
+1.05VSP_B+: PC302.1 PC303.1 PC304.1 PC305.1 PJP300.2 PQ301.5
+1.8V_MPLL_PVDD: CV215.1 CV216.1 CV219.1 LV17.1 UV1.L8
+1.8V_RUN_CARD: C560.2 C580.1 JSD1.14 U38.24
+1.8V_RUN_FB: PR687.1 PR689.1 PU603.2
+1.8V_RUN_GFX: CV66.1 CV67.1 CV68.1 CV198.1 CV201.1 CV203.1 LV16.1 LV17.2 LV18.2 LV19.1 PJP612.1 RV237.1 RV239.1 RV241.1 RV244.1 UV1.AF14 UV1.AM30
+1.8V_RUN_VIN: PC669.1 PC670.1 PJP611.2 PU603.5 PU603.6
+1.8V_RUNP: PC672.1 PC674.1 PJP612.2 PR687.2 PU603.3 PU603.4
+1.8V_SPLL_PVDD: CV220.1 CV221.1 CV222.1 LV18.1 UV1.H7
+1.35V_MEM: CC24.1 CC25.1 CC26.1 CC27.1 CC28.1 CC29.1 CC30.1 CC31.1 CC32.1 CC33.1 CC34.1 CC35.1 CC36.1 CC37.1 CC38.1 CC39.1 CC40.1 CC41.1 CC42.1 CC43.1 CC44.1 CC45.1 CC46.1 CD3.1 CD4.1 CD5.1 CD6.1 CD7.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD25.1 CD26.1 CD27.1 CD28.1 CD29.1 CD30.1 CD31.1 CD32.1 CD33.1 CD34.1 CD35.1 CD36.1 JCPU1.AB2 JCPU1.AB5 JCPU1.AB8 JCPU1.AB11 JCPU1.AE2 JCPU1.AE5 JCPU1.AE8 JCPU1.AE11 JCPU1.AH11 JCPU1.K11 JCPU1.N8 JCPU1.N11 JCPU1.T2 JCPU1.T5 JCPU1.T8 JCPU1.T11 JCPU1.W2 JCPU1.W5 JCPU1.W8 JCPU1.W11 JDIMM1.75 JDIMM1.76 JDIMM1.81 JDIMM1.82 JDIMM1.87 JDIMM1.88 JDIMM1.93 JDIMM1.94 JDIMM1.99 JDIMM1.100 JDIMM1.105 JDIMM1.106 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM2.75 JDIMM2.76 JDIMM2.81 JDIMM2.82 JDIMM2.87 JDIMM2.88 JDIMM2.93 JDIMM2.94 JDIMM2.99 JDIMM2.100 JDIMM2.105 JDIMM2.106 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 PJP203.1 PJP204.1 QV1.5 QV1.6 QV1.7 QV1.8 R926.1 RC6.1 RD2.1 RD15.1 RD19.1 RD22.1
+1.35V_MEM_CHG: Q71.1 R926.2
+1.35V_MEM_GFX: C783.1 CV13.1 CV18.1 CV19.1 CV20.1 CV21.1 CV22.1 CV23.1 CV24.1 CV25.1 CV26.1 CV41.1 CV42.1 CV43.1 CV44.1 CV56.1 CV58.1 CV59.1 CV130.1 CV131.1 CV133.1 CV134.1 CV137.1 CV138.1 CV139.1 CV140.1 CV141.1 CV142.1 CV143.1 CV144.1 CV145.1 CV146.1 CV147.1 CV148.1 CV149.1 CV150.1 CV151.1 CV152.1 CV153.1 CV154.1 CV155.1 CV156.1 CV157.1 CV158.1 CV159.1 CV162.1 CV163.1 CV164.1 CV165.1 CV166.1 CV167.1 CV176.1 CV177.1 CV178.1 CV179.1 CV180.1 CV181.1 CV182.1 CV185.1 CV188.1 CV189.1 CV191.1 CV192.1 CV208.1 CV209.1 CV322.1 CV323.1 CV325.1 CV328.1 CV330.1 CV333.1 CV350.1 CV352.1 CV354.1 CV356.1 QV1.1 QV1.2 QV1.3 RV109.1 RV119.1 RV129.1 RV139.1 RV140.1 RV145.1 RV148.1 RV182.1 RV183.1 RV185.1 RV187.2 RV188.2 RV189.2 RV190.2 RV191.1 RV193.1 RV195.1 RV197.1 RV203.1 UV1.H13 UV1.H16 UV1.H19 UV1.J9 UV1.J10 UV1.J23 UV1.J24 UV1.K9 UV1.K10 UV1.K23 UV1.K24 UV1.L11 UV1.L12 UV1.L13 UV1.L20 UV1.L21 UV1.L22 UV3.B1 UV3.B3 UV3.B12 UV3.B14 UV3.C5 UV3.C10 UV3.D1 UV3.D3 UV3.D11 UV3.D12 UV3.D13 UV3.D14 UV3.E5 UV3.E10 UV3.F1 UV3.F3 UV3.F12 UV3.F14 UV3.G1 UV3.G2 UV3.G4 UV3.G11 UV3.G13 UV3.G14 UV3.H3 UV3.H12 UV3.J1 UV3.K3 UV3.K12 UV3.L1 UV3.L2 UV3.L4 UV3.L11 UV3.L13 UV3.L14 UV3.M1 UV3.M3 UV3.M12 UV3.M14 UV3.N5 UV3.N10 UV3.P1 UV3.P2 UV3.P3 UV3.P11 UV3.P12 UV3.P14 UV3.R5 UV3.R10 UV3.T1 UV3.T3 UV3.T12 UV3.T14 UV4.B1 UV4.B3 UV4.B12 UV4.B14 UV4.C5 UV4.C10 UV4.D1 UV4.D3 UV4.D11 UV4.D12 UV4.D13 UV4.D14 UV4.E5 UV4.E10 UV4.F1 UV4.F3 UV4.F12 UV4.F14 UV4.G1 UV4.G2 UV4.G4 UV4.G11 UV4.G13 UV4.G14 UV4.H3 UV4.H12 UV4.K3 UV4.K12 UV4.L1 UV4.L2 UV4.L4 UV4.L11 UV4.L13 UV4.L14 UV4.M1 UV4.M3 UV4.M12 UV4.M14 UV4.N5 UV4.N10 UV4.P1 UV4.P2 UV4.P3 UV4.P11 UV4.P12 UV4.P14 UV4.R5 UV4.R10 UV4.T1 UV4.T3 UV4.T12 UV4.T14 UV5.B1 UV5.B3 UV5.B12 UV5.B14 UV5.C5 UV5.C10 UV5.D1 UV5.D3 UV5.D11 UV5.D12 UV5.D13 UV5.D14 UV5.E5 UV5.E10 UV5.F1 UV5.F3 UV5.F12 UV5.F14 UV5.G1 UV5.G2 UV5.G4 UV5.G11 UV5.G13 UV5.G14 UV5.H3 UV5.H12 UV5.J1 UV5.K3 UV5.K12 UV5.L1 UV5.L2 UV5.L4 UV5.L11 UV5.L13 UV5.L14 UV5.M1 UV5.M3 UV5.M12 UV5.M14 UV5.N5 UV5.N10 UV5.P1 UV5.P2 UV5.P3 UV5.P11 UV5.P12 UV5.P14 UV5.R5 UV5.R10 UV5.T1 UV5.T3 UV5.T12 UV5.T14 UV6.B1 UV6.B3 UV6.B12 UV6.B14 UV6.C5 UV6.C10 UV6.D1 UV6.D3 UV6.D11 UV6.D12 UV6.D13 UV6.D14 UV6.E5 UV6.E10 UV6.F1 UV6.F3 UV6.F12 UV6.F14 UV6.G1 UV6.G2 UV6.G4 UV6.G11 UV6.G13 UV6.G14 UV6.H3 UV6.H12 UV6.K3 UV6.K12 UV6.L1 UV6.L2 UV6.L4 UV6.L11 UV6.L13 UV6.L14 UV6.M1 UV6.M3 UV6.M12 UV6.M14 UV6.N5 UV6.N10 UV6.P1 UV6.P2 UV6.P3 UV6.P11 UV6.P12 UV6.P14 UV6.R5 UV6.R10 UV6.T1 UV6.T3 UV6.T12 UV6.T14
+1.35V_MEM_GFX_CHG: QV11.1 RV182.2
+1.35V_MEN_P: PC201.1 PC211.2 PC214.1 PC216.1 PJP201.1 PJP203.2 PJP204.2 PL201.1 PR204.2 PU200.5
+3.3V_ALW: C288.1 C720.1 C756.1 C778.1 C1184.1 CV87.1 JAPS1.7 JKB1.4 JSF1.3 PC733.2 PC801.2 PC805.2 PJP63.2 PJP65.1 PJP100.1 PJP102.2 PJP400.2 PJP609.2 PJP611.1 PR6.1 PR11.2 PR119.2 PR209.1 PR300.2 PR720.1 PR748.1 PR801.1 PR807.1 PR810.1 PR868.2 PR895.1 PU704.5 PU801.5 PU804.5 QV12.3 R51.1 R52.2 R418.1 R420.1 R515.1 R755.2 R796.1 R800.1 R817.1 R834.1 R839.1 R850.1 R864.1 R871.1 R872.1 R875.1 R932.1 R937.1 R1162.1 R1171.1 R1630.2 RH238.1 RH241.1 RP2.1 RP2.2 RP2.3 RP2.4 RP3.1 RP3.2 RP3.3 RP3.4 RP4.1 RP4.2 RP4.3 RP4.4 RP7.1 RP7.2 RP7.3 RP7.4 RP10.5 RP10.6 RP10.7 RP10.8 RP11.5 RP11.6 RP11.7 RP11.8 RP12.6 RP12.7 RP12.8 RP14.1 RP14.2 RP16.6 RP16.7 RP16.8 RP18.3 RP19.8 U9.5 U36.1 U36.2 U36.6 U36.7 U50.5 U57.1 U57.2 U57.6 U57.7 U58.5 U145.1 U145.2 U145.6 U145.7 U146.1 U146.2 U146.6 U146.7 U148.4 U148.5 UV14.5
+3.3V_ALW2: CH11.1 PC114.2 PC808.2 PC810.2 PC812.2 PC814.2 PR103.1 PR726.1 PR733.1 PR747.1 PR808.1 PR816.2 PR819.2 PR823.2 PR824.2 PR829.1 PR846.1 PR849.1 PR862.1 PR864.1 PR875.1 PR894.1 PU100.3 PU805.5 PU806.5 PU807.5 PU808.5 R517.1 R874.2 R909.1 RV81.2 UH2.5
+3.3V_ALW_5048: C705.1 C706.1 C707.1 C708.1 C709.1 C710.1 PJP63.1 U46.A17 U46.A43 U46.A54 U46.B5 U46.B30
+3.3V_ALW_PCH: C452.1 CH2.1 CH43.1 CH45.1 CH51.1 JAPS1.1 JXDP2.43 JXDP2.44 R1622.2 R1624.2 RC11.1 RH35.1 RH46.1 RH73.1 RH75.1 RH78.1 RH170.1 RH222.2 RH237.1 RH240.1 RP18.1 RP18.2 RP19.7 RPH1.5 RPH1.6 RPH1.7 RPH1.8 RPH3.5 RPH3.6 RPH3.7 RPH3.8 RPH8.5 RPH8.6 RPH8.7 RPH8.8 RPH9.5 RPH9.6 RPH9.7 RPH9.8 RPH12.5 RPH12.6 RPH12.7 RPH12.8 RPH15.6 RPH15.7 RPH15.8 RPH18.5 RPH21.2 RPH21.3 RPH21.4 U146.13 U146.14 UH1.A26 UH1.AJ30 UH1.AJ32 UH1.R20 UH1.R22 UH1.R24 UH1.R26 UH1.R28 UH1.U26
+3.3V_ALW_PCH_JTAG: RH46.2 RH48.1 RH50.1 RH52.1
+3.3V_ALW_VTR: C759.1 C774.1 C776.1 C777.1 C780.1 C781.1 C782.1 PJP65.2 U51.A11 U51.A26 U51.A41 U51.A52 U51.B3 U51.B35
+3.3V_CARD: C640.1 C641.1 C649.1 JEXP1.24 JEXP1.26 U41.3 U41.5
+3.3V_CARDAUX: C642.1 C643.1 C646.1 JEXP1.16 U41.15
+3.3V_LAN: C447.1 C472.1 C473.1 C474.1 C478.1 C481.1 C482.1 C1167.1 JLOM1.9 JLOM1.12 R154.1 R545.1 R546.1 R549.1 R553.1 R558.1 RH174.1 RH175.1 U15.5 U32.1 U32.4 U32.8 U32.14 U32.21 U32.30 U32.39 U57.8 U57.9
+3.3V_LAN_OUT: C464.1 C1178.1 R154.2 U31.4 U31.5 U31.15 U31.19 U31.29
+3.3V_M: C439.1 CH59.1 JSPI1.16 RH185.1 U36.13 U36.14 UH1.AD12
+3.3V_OZ_IO_LDO: C566.2 C800.2 U38.25
+3.3V_PCIE_FLASH: C449.1 C621.1 C622.1 C623.1 C624.2 C625.2 C626.1 JMINI3.2 JMINI3.24 JMINI3.39 JMINI3.41 JMINI3.52 U145.8 U145.9
+3.3V_PCIE_WWAN: C446.1 C610.1 C611.1 C612.1 C613.1 C614.1 C615.1 JMINI1.2 JMINI1.24 JMINI1.39 JMINI1.41 JMINI1.52 Q77.2 R719.2 U145.13 U145.14
+3.3V_RTC_LDO: PD3.3 PR103.2
+3.3V_RUN: C25.1 C26.1 C27.1 C28.1 C29.1 C31.1 C32.1 C51.1 C301.1 C356.1 C366.1 C453.1 C574.1 C578.1 C581.1 C634.1 C725.1 C1501.2 C1502.2 C1503.2 C1504.2 CC21.1 CD21.1 CD22.1 CD43.1 CD44.1 CH10.1 CH12.1 CH27.1 CH48.1 CH49.1 CH65.1 JDIMM1.199 JDIMM2.199 JIO1.15 JIO1.17 JLVDS1.37 JUSH1.8 L45.2 PJP53.1 PJP60.1 PJP61.1 PJP64.1 PJP67.1 PR519.2 PR627.1 PR691.2 PR692.1 Q23.3 QH4.2 QH4.5 QV5.2 R30.1 R38.1 R61.1 R65.1 R72.1 R73.1 R79.1 R80.1 R85.1 R86.1 R159.1 R160.1 R415.1 R416.1 R501.1 R502.1 R503.1 R508.1 R772.1 R894.1 R1081.1 R1082.1 R1099.1 R1100.1 R1161.1 R1658.2 R1700.1 RC52.1 RD12.2 RH34.1 RH37.1 RH40.1 RH88.1 RH89.1 RH90.1 RH93.1 RH202.2 RH224.1 RH225.2 RH228.2 RH229.1 RH242.1 RH245.1 RH255.1 RH256.1 RH328.1 RH331.1 RP1.1 RP1.2 RP1.3 RP1.4 RP5.5 RP5.6 RP5.7 RP14.3 RP14.4 RP17.1 RP20.1 RP20.2 RPH4.5 RPH4.6 RPH4.7 RPH4.8 RPH6.5 RPH6.6 RPH6.7 RPH6.8 RPH13.5 RPH13.6 RPH13.7 RPH13.8 RPH14.5 RPH14.6 RPH14.7 RPH14.8 RPH16.6 RPH16.7 RPH16.8 RPH18.6 RPH18.7 RPH19.7 RPH19.8 RPH20.3 RPH20.4 RV33.1 U6.4 U6.23 U6.29 U6.32 U19.11 U19.37 U20.14 U23.14 U38.11 U38.13 U38.23 U38.42 U41.2 U41.4 U54.5 U146.8 U146.9 UC2.5 UC3.5 UH1.AE14 UH1.AF12 UH1.AG14 UH1.AK30 UH1.AK32 UH1.L24 UH1.M31 UH1.R30 UH1.R32 UH3.5
+3.3V_RUN_CARD: C559.2 C572.1 JSD1.4 U38.22
+3.3V_RUN_DVDD: C952.1 C994.1 PJP60.2 U74.3 U74.9
+3.3V_RUN_EDP: PJP67.2 R105.2 R107.2 R3881.2 R3882.2
+3.3V_RUN_FFS: C387.1 C388.1 PJP53.2 U88.1 U88.7 U88.8 U88.14
+3.3V_RUN_GFX: CV423.1 LV30.1 PR602.2 PR604.2 PR608.2 QV4.3 QV12.1 RPV1.5 RPV1.6 RPV1.7 RPV1.8 RV29.1 RV41.2 RV57.1 RV103.1
+3.3V_RUN_GFX_VDDR3: CV49.1 CV61.1 CV62.1 LV30.2 UV1.AA17 UV1.AA18 UV1.AB17 UV1.AB18
+3.3V_RUN_HDD: C399.1 C402.1 JSATA1.8 JSATA1.9 PJP64.2 R1635.1
+3.3V_RUN_HDD_R: JSATA1.10 R1635.2
+3.3V_RUN_OZVCC: C575.1 C576.1 C577.1 L45.1 U38.9 U38.27
+3.3V_RUN_TPM: C44.1 C45.1 C550.1 C551.1 C552.1 C553.1 PJP61.2 U39.5 U39.10 U39.19 U39.24
+3.3V_SPI: C746.1 C1216.1 JSPI1.15 R3664.1 R3665.1 R3666.1 R3668.1 RH185.2 U52.8 U53.8
+3.3V_SUS: C53.1 C443.1 C633.1 JUSH1.11 JUSH1.12 JUSH1.13 R585.1 R589.1 R731.1 R732.1 U36.8 U36.9 U41.17
+3.3V_TP: C755.1 JTP1.5 R902.1 R903.1 R1161.2 R1162.2
+3.3V_VCCPRTCSUS: CH53.1 RH240.2 RH241.2 UH1.K8
+3.3V_VTR: C739.1 C775.1 R834.2 U51.A22
+3.3V_VTR_ADC: C736.1 C757.1 R839.2 U51.A58
+3.3V_WLAN: C423.1 C603.1 C604.1 C605.1 C606.2 C607.2 C608.1 JMINI2.2 JMINI2.24 JMINI2.39 JMINI2.41 JMINI2.52 Q89.2 Q124.2 Q124.5 R725.2 R3885.2 R3886.2 RP13.6 RP13.7 RP13.8 U57.13 U57.14
+3V5V_PWR_SRC: PC103.1 PC105.1 PC106.1 PC109.1 PC110.1 PC117.1 PL103.1 PQ101.5 PQ102.5 PU100.12
+3VALWP: PC101.1 PJP100.2 PJP102.1 PL101.1 PR100.1
+5V_ALW: C50.1 C675.1 C676.1 C715.1 C998.1 C1002.1 C1004.1 C1525.1 C1526.1 C1540.1 C1541.1 JIO1.19 JIO1.20 JIO1.21 JIO1.22 JIO1.23 JIO1.24 JLED1.1 JLVDS1.1 JMDIA1.1 PJP101.2 PJP103.2 PR14.1 PR203.1 PR211.1 PR309.2 PR520.2 PR530.2 PR635.2 PR645.2 PR723.2 PR745.1 PR843.2 PU1.5 Q75.3 Q79.3 R816.2 R957.2 R1614.2 R1629.1 U2.5 U36.4 U37.1 U37.2 U37.4 U37.6 U37.7 U48.2 U48.3 U57.4 U91.2 U91.3 U93.2 U93.3 U145.4 U146.4
+5V_ALW2: PC118.1 PU100.13
+5V_HDD: C395.1 C396.1 JSATA1.14 JSATA1.15 JSATA1.16 PJP3.1 R506.1
+5V_MOD: C397.1 C398.1 C765.1 JSATA2.9 JSATA2.10 JSATA2.25 PJP4.1 U37.13 U37.14
+5V_RUN: C7.1 C30.1 C52.1 C306.1 C365.1 C369.1 C758.1 C764.1 C1001.1 D1.1 JFAN1.1 JIO1.16 JIO1.18 JKB1.5 JUSH1.7 L77.2 PJP3.2 PJP4.2 PU600.18 Q32.3 R431.1 R1095.1 RP8.1 RP8.2 RP8.3 RP8.4 U6.16 U21.5 U24.5 U37.8 U37.9 U89.1
+5V_TSP: C302.1 JTCH1.1 JTCH1.2 Q32.1
+5V_USB_CHG_PWR: C651.1 C654.1 C1552.1 JUSB1.1 U48.6 U48.7 U48.8
+5V_USB_PWR2: C1523.1 C1524.1 JUSB2.1 PJP702.2 U91.6 U91.7 U91.8
+5V_USB_PWR3: C1538.1 C1539.1 JUSB3.1 PJP702.1 U93.6 U93.7 U93.8
+5VALWP: PC102.1 PJP101.1 PJP103.1 PL102.2 PR101.1 PU100.14
+AVCC33: C106.1 C107.1 C108.1 R3882.1 U27.5
+DVCC33: C113.1 C114.1 C115.1 C116.1 C117.1 R3881.1 U27.18 U27.22
+DVDD_CORE: C954.1 U74.1
+VCC_CORE: JCPU1.AA26 JCPU1.AA28 JCPU1.AA30 JCPU1.AA32 JCPU1.AA34 JCPU1.AB25 JCPU1.AB26 JCPU1.AB27 JCPU1.AB28 JCPU1.AB29 JCPU1.AB30 JCPU1.AB31 JCPU1.AB32 JCPU1.AB33 JCPU1.AB34 JCPU1.AB35 JCPU1.AC26 JCPU1.AC28 JCPU1.AC30 JCPU1.AC32 JCPU1.AC34 JCPU1.AD25 JCPU1.AD26 JCPU1.AD27 JCPU1.AD28 JCPU1.AD29 JCPU1.AD30 JCPU1.AD31 JCPU1.AD32 JCPU1.AD33 JCPU1.AD34 JCPU1.AD35 JCPU1.AE26 JCPU1.AE28 JCPU1.AE30 JCPU1.AE32 JCPU1.AE34 JCPU1.AF25 JCPU1.AF26 JCPU1.AF27 JCPU1.AF28 JCPU1.AF29 JCPU1.AF30 JCPU1.AF31 JCPU1.AF32 JCPU1.AF33 JCPU1.AF34 JCPU1.AF35 JCPU1.AG26 JCPU1.AG28 JCPU1.AG30 JCPU1.AG32 JCPU1.AG34 JCPU1.AH25 JCPU1.AH26 JCPU1.AH27 JCPU1.AH28 JCPU1.AH29 JCPU1.AH30 JCPU1.AH31 JCPU1.AH32 JCPU1.AH33 JCPU1.AH34 JCPU1.AH35 JCPU1.AJ25 JCPU1.AJ26 JCPU1.AJ27 JCPU1.AJ28 JCPU1.AJ29 JCPU1.AJ30 JCPU1.AJ31 JCPU1.AJ32 JCPU1.AJ33 JCPU1.AJ34 JCPU1.AJ35 JCPU1.F25 JCPU1.G25 JCPU1.H25 JCPU1.J25 JCPU1.K25 JCPU1.K26 JCPU1.L25 JCPU1.M25 JCPU1.N25 JCPU1.P25 JCPU1.R25 JCPU1.T25 JCPU1.U25 JCPU1.U26 JCPU1.V25 JCPU1.V26 JCPU1.W26 JCPU1.W27 JCPU1.Y25 JCPU1.Y26 JCPU1.Y27 JCPU1.Y28 JCPU1.Y29 JCPU1.Y30 JCPU1.Y31 JCPU1.Y32 JCPU1.Y33 JCPU1.Y34 JCPU1.Y35 PC900.1 PC901.1 PC902.1 PC903.1 PC904.1 PC905.1 PC906.1 PC907.1 PC908.1 PC909.1 PC910.1 PC911.1 PC912.1 PC913.1 PC914.1 PC916.1 PC917.1 PC918.1 PC919.1 PC920.1 PC921.1 PC922.1 PC923.1 PC924.1 PC925.1 PC926.1 PC935.1 PC936.1 PC937.1 PC938.1 PC939.1 PC940.1 PC941.1 PC942.1 PC943.1 PL502.1 PL503.1 PR544.1 PR546.2 PR555.2 PR556.1 RC91.1
+VCCADAC: CH18.1 CH19.1 CH20.1 LH1.2 UH1.P45
+VCCIO2PCH: CC137.1 CH60.1 CH61.1 CH62.1 RC105.1 RC106.2 UH1.AJ12 UH1.AJ14
+VCCIO2PCH_R: JCPU1.A23 RC106.1
+VCCIO_OUT: CC17.1 CC18.1 JCPU1.AN35 JXDP1.16 PC548.2 PR500.2 PR503.2 PR504.2 R55.1 RC28.1 RC29.1 RC74.2 RC86.1 RC87.1 RC90.1 RV78.1
+VCCST: CC47.1 CC48.1 JCPU1.AK31 RC99.1
+VDD_MEM15_REFDA: CV275.1 RV145.2 RV146.1 UV1.K26
+VDD_MEM15_REFSA: CV274.1 RV147.1 RV148.2 UV1.J26
+VDDA_AVDD: C955.1 C957.1 L77.1 U74.27
+VDDA_AVDD2: C956.1 C968.1 R1658.1 U74.38
+VDDA_PVDD: C958.1 C959.1 C960.1 C961.1 R1095.2 U74.39 U74.45
+VDDC_CT: CV54.1 CV55.1 CV60.1 LV19.2 UV1.AA20 UV1.AA21 UV1.AB20 UV1.AB21
