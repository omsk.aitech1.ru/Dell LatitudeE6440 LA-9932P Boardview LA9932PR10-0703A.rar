# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DQA1_13: length 17.4
  TOP w0.089: UV3.U11 v3(61.86,109.66)
  IN1 w0.127: v3(64.73,121.76) 65.05,121.76 65.4,121.41 65.4,115.86 64.03,114.49 64.03,112.95 61.86,110.78 v3(61.86,109.66)
  BOTTOM w0.089: UV1.C9 65.38,124.05 65.08,123.75 65.08,123.27 65.18,123.17 65.18,122.21 v3(64.73,121.76)
DQA1_14: length 20.3
  TOP w0.089: UV3.T11 v3(61.86,108.86)
  IN1 w0.127: v3(61.86,108.86) 62.42,109.42 62.42,110.69 64.47,112.73 64.47,114.1 65.84,115.47 65.84,121.74 65.24,122.34 v3(64.71,122.34)
  BOTTOM w0.089: v3(64.71,122.34) 64.99,122.62 64.99,123.09 64.89,123.19 64.89,125.31 UV1.F9
DQA1_15: length 18.1
  TOP w0.089: UV3.U13 v3(59.46,109.66)
  IN1 w0.127: v3(64.78,120.05) 64.51,119.78 64.51,116.19 60.14,111.81 60.14,110.61 59.46,109.93 v3(59.46,109.66)
  BOTTOM w0.089: 64.18,122.67 64.18,123.05 64.28,123.15 64.28,124.3 UV1.D8
  BOTTOM w0.1: 64.18,122.67 64.33,122.53 64.33,120.5 v3(64.78,120.05)
DQA1_16: length 51.4
  TOP w0.089: UV3.F4 v3(67.46,100.06)
  IN1 w0.127: v3(63.16,120.21) 58.73,120.21 56.49,117.97 56.49,114.62 56.62,114.49 57.69,114.49 57.81,114.37 57.81,114.06 57.69,113.93 55.98,113.93 55.85,113.8 55.85,113.53 55.98,113.4 57.69,113.4 57.81,113.27 57.81,112.99 57.69,112.86 55.98,112.86 55.85,112.74 55.85,101.7 57.47,100.09 59.16,100.09 59.76,99.49 61.34,99.49 61.6,99.75 63.88,99.75 65.57,98.07 66.83,98.07 67.06,98.29 67.06,99.65 v3(67.46,100.06)
  BOTTOM w0.089: 63.98,121.03 64.13,121.18 64.13,122.04 63.98,122.19 63.98,123.17 64.08,123.27 64.08,124.7 UV1.E7
  BOTTOM w0.1: 63.98,121.03 v3(63.16,120.21)
DQA1_17: length 52.4
  TOP w0.089: UV3.E4 v3(67.46,99.26)
  IN1 w0.127: v3(67.46,99.26) 67.87,98.85 67.87,98.28 67.66,98.07 67.22,98.07 66.42,97.27 65.11,97.27 64.98,97.39 64.98,97.84 64.85,97.97 64.57,97.97 64.45,97.84 64.45,97.39 64.32,97.27 64.04,97.27 63.91,97.39 63.91,98.8 63.79,98.92 63.51,98.92 63.38,98.8 63.38,97.39 63.25,97.27 62.96,97.27 62.83,97.39 62.83,98.73 62.7,98.86 59.37,98.86 58.97,99.27 57.36,99.27 57.06,99.56 55.62,99.56 55.42,99.77 55.42,114.36 55.55,114.49 55.93,114.49 56.06,114.62 56.06,115 55.93,115.13 55.55,115.13 55.42,115.25 55.42,115.63 55.55,115.76 55.93,115.76 56.06,115.89 56.06,116.27 55.93,116.4 55.55,116.4 55.42,116.52 55.42,116.96 55.55,117.08 55.93,117.08 56.06,117.21 56.06,118.15 58.6,120.69 63.09,120.69 v3(63.16,120.77)
  BOTTOM w0.089: UV1.A7 v1(63.78,121.72) 63.78,121.39 v3(63.16,120.77)
DQA1_18: length 51.3
  TOP w0.089: UV3.B4 v3(66.66,96.86)
  IN1 w0.127: v3(66.66,96.86) 66.19,96.38 65.78,96.38 65.46,96.71 60.78,96.71 60.66,96.84 60.66,97.14 60.78,97.27 62.26,97.27 62.38,97.39 62.38,97.93 62.26,98.05 60.47,98.05 60.07,98.45 59.75,98.45 59.63,98.33 59.63,96.94 59.5,96.81 59.22,96.81 59.09,96.94 59.09,98.33 58.97,98.45 57.56,98.45 56.88,99.13 55.45,99.13 54.99,99.59 54.99,117.69 58.42,121.12 62.31,121.12 v3(63.15,121.97)
  BOTTOM w0.089: UV1.C7 63.78,123.82 63.48,123.52 63.48,123.28 63.58,123.18 63.58,122.32
  BOTTOM w0.1: v3(63.15,121.97) 63.23,121.97 63.58,122.32
DQA1_19: length 52.5
  TOP w0.089: UV3.A4 v3(66.66,96.06)
  IN1 w0.127: v3(66.66,96.06) 65.46,96.06 65.22,96.29 60.39,96.29 60.16,96.07 58.2,96.07 58.07,96.19 58.07,97.84 57.95,97.97 56.87,97.97 56.75,97.84 56.75,97.56 56.87,97.44 57.41,97.44 57.54,97.31 57.54,96.19 57.41,96.07 56.97,96.07 56.11,96.93 56.11,97.86 54.56,99.41 54.56,117.87 58.24,121.56 62.22,121.56 62.79,122.13 v3(62.79,122.45)
  BOTTOM w0.089: 63.41,125.42 63.41,123.8 63.28,123.67 63.28,123.21 63.38,123.11 63.38,122.73
  BOTTOM w0.1: 63.38,122.73 63.1,122.45 v3(62.79,122.45) ; UV1.F7 63.41,125.42
DQA1_20: length 57.5
  TOP w0.089: UV3.B2 v3(68.26,96.86)
  IN1 w0.127: v3(68.26,96.86) 68.84,96.29 68.84,95.03 67.07,93.27 55.82,93.27 51.38,97.71 51.38,118.62 57.07,124.3 58.82,124.3 59.49,123.62 59.83,123.62 v3(60.26,123.19)
  BOTTOM w0.089: v3(60.26,123.19) 60.59,122.86 61.09,122.86 61.22,122.99 61.47,122.99 61.88,123.4 UV1.A5
DQA1_21: length 63.7
  TOP w0.089: UV3.F2 v3(69.06,100.06)
  IN1 w0.127: v3(61.79,123.82) 60.58,123.82 60.54,123.86 59.59,123.86 58.71,124.73 56.85,124.73 50.92,118.81 50.92,97.56 55.67,92.81 67.22,92.81 69.3,94.88 69.3,96.38 69.03,96.65 69.03,98.1 68.66,98.47 68.66,99.65 v3(69.06,100.06)
  BOTTOM w0.089: v3(61.79,123.82) 61.79,124.6 UV1.E5
DQA1_22: length 53.4
  TOP w0.089: UV3.A2 v3(68.26,96.06)
  IN1 w0.127: v3(68.26,96.06) 68.39,95.93 68.39,95.2 66.92,93.73 55.98,93.73 51.84,97.86 51.84,118.42 57.28,123.87 58.92,123.87 59.61,123.18 v3(59.7,123.18)
  BOTTOM w0.1: v3(59.7,123.18) 60.34,123.82 61,123.82 UV1.C3
DQA1_23: length 62.4
  TOP w0.089: UV3.E2 v3(69.06,99.26)
  IN1 w0.127: v3(69.06,99.26) 69.34,98.98 69.34,96.77 69.79,96.32 69.79,94.76 67.38,92.35 55.52,92.35 50.49,97.38 50.49,119.02 56.63,125.16 59.7,125.16 v3(60.2,124.66)
  BOTTOM w0.089: UV1.E1 60.54,125 v3(60.2,124.66)
DQA1_24: length 35.6
  BOTTOM w0.089: UV1.G7 63.28,126.1 61.53,126.1 61.28,125.85 61.28,125.67 60.92,125.32 60.43,125.32 60.19,125.07 60.02,125.07 ; 58.22,101.85 58.73,101.85 58.93,101.65 59.25,101.65 59.44,101.46 59.44,100.96 59.57,100.83 61.09,100.83 UV6.M11
  BOTTOM w0.13: 58.22,101.85 57.14,101.85 56.64,102.35 56.64,102.68 55.3,104.03 55.3,118.33 v1(57.38,120.41) 59.31,122.34 59.31,124.36 60.02,125.07
DQA1_25: length 34.2
  BOTTOM w0.089: 58.22,100.89 59.08,100.89 59.51,100.46 UV6.M13 ; UV1.G6 62.67,126.29 60.97,126.29 60.6,125.91 59.88,125.91 59.57,125.59
  BOTTOM w0.13: 58.22,100.89 57.45,100.89 56.18,102.16 56.18,102.49 v1(55.5,103.18) 54.84,103.84 54.84,118.52 59.08,122.76 59.08,124.46 59.57,124.95 59.57,125.59
DQA1_26: length 36
  BOTTOM w0.089: UV6.N11 61.09,99.29 58.22,99.29
  BOTTOM w0.13: 58.22,99.29 57.76,99.29 55.26,101.78 55.26,102.11 v1(53.92,103.45) 53.92,118.91 58.61,123.6 58.61,124.77 58.99,125.15 58.99,125.85 59.5,126.36 60.34,126.36 UV1.G1
DQA1_27: length 33.9
  BOTTOM w0.089: 59.31,125.73 59.69,126.1 60.52,126.1 61.01,126.6 UV1.G3 ; UV6.N13 59.46,100.07 58.22,100.07
  BOTTOM w0.13: 59.31,125.73 59.31,125.02 58.84,124.56 58.84,123.18 54.38,118.71 54.38,103.65 55.72,102.3 55.72,101.97 v1(56.09,101.61) 57.63,100.07 58.22,100.07
DQA1_28: length 44.9
  BOTTOM w0.089: UV1.J6 62.61,128.2 62.31,127.9 61.81,127.9 61.61,127.7 59.76,127.7 58.61,126.55
  BOTTOM w0.13: UV6.T13 59.44,96.83 59.44,96.36 59,95.92 57.09,95.92 51.28,101.73 51.28,119.54 v1(57.27,125.54) 58.28,126.55 58.61,126.55
DQA1_29: length 47.5
  BOTTOM w0.089: UV1.J1 59.55,128.2
  BOTTOM w0.13: UV6.T11 61.46,97.06 61.1,96.69 61.1,95.78 60.32,95 56.71,95 v1(54.33,97.37) 50.36,101.35 50.36,119.92 57.87,127.44 58.78,127.44 59.55,128.2
DQA1_30: length 49.8
  BOTTOM w0.089: UV1.J3 60.75,128.49 60.74,128.5 59.36,128.5 58.81,127.95
  BOTTOM w0.13: 58.81,127.95 57.73,127.95 v1(57.18,127.4) 49.9,120.11 49.9,101.16 56.52,94.54 60.51,94.54 61.6,95.63 61.6,96.32 UV6.U11
DQA1_31: length 45.2
  BOTTOM w0.089: UV1.J5 61.81,128.2 61.51,127.9 59.61,127.9 58.64,126.93
  BOTTOM w0.13: UV6.U13 59.86,96.13 59.19,95.46 56.9,95.46 v1(52.63,99.73) 50.82,101.54 50.82,119.73 58.01,126.93 58.64,126.93
DRAM_RST#: length 43.3
  TOP w0.089: 69.6,102.46 70.61,103.48 ; 69.6,102.46 v3(69.06,102.46) UV3.J2 ; 69.6,102.46 70.02,102.03 70.27,102.03 ; 78.04,103.26 v3(79.4,103.26) UV4.J2
  TOP w0.102: 78.04,103.26 77.98,103.26 76.75,102.03 70.27,102.03 ; 70.61,103.48 v1(70.61,115.31) 67.57,118.35 64.38,118.35 61.08,121.66 59.94,121.66 RV179.2
  BOTTOM w0.089: UV3.J2 v3(69.06,102.46) ; UV4.J2 v3(79.4,103.26)
DRAM_RST#_R: length 10.1
  TOP w0.089: RV178.1 59.82,124.96 59.92,125.06 60.76,125.06 RV180.2 CV344.1 62.98,126.42 63.53,126.42 65.34,128.23 65.34,128.95 v1(65.44,129.05) 66.03,129.05 v3(66.45,129.47)
  BOTTOM w0.089: v3(66.45,129.47) 66.18,129.74 UV1.L10
DSWODVREN: length 9.8
  BOTTOM w0.089: 178.75,130.79 178.73,130.78 175.99,130.78 175.86,130.91 175.66,130.91 175.39,131.18 174.97,131.18 UH1.C8
  BOTTOM w0.102: v1(183.06,129.58) 183.01,129.63 RH67.1 182.83,130.53 182.42,130.94 181.18,130.94 RH81.2 179.07,130.47 178.75,130.79
DYN_TUR_CURRNT_SET#: length 80.8
  TOP w0.102: v3(214.34,86.4) 213.83,86.91 R1171.2 212.98,86.08 212.43,85.53 U51.A35
  TOP w0.254: v3(207.77,133.23) 207.77,135.28 212.68,140.19 v2(215.3,140.19) 217.14,140.19 219.23,138.1 221.95,138.1 223.04,139.19 223.19,139.19 PQ709.2
  IN2 w0.127: v3(214.34,86.4) 214.34,86.54 215.09,87.29 215.09,88.71 215.5,89.12 215.5,101.92 217.52,103.95 217.52,109.75 218.58,110.81 218.58,114.64 216.01,117.21 214.18,117.21 209.46,121.93 209.46,123.34 208.83,123.98 208.83,127.08 207.35,128.55 207.35,132.82 v3(207.77,133.23)
DYN_TURB_PWR_ALRT#: length 2.8
  TOP w0.102: R796.2 178.73,64.29 v1(179.01,64.57) 179.5,65.06 U46.A46
EC5048_TX: length 176.7
  TOP w0.102: v3(232.03,76.5) 232.55,77.02 234.82,77.02 235.02,76.83 235.02,76.38 235.27,76.12 RP12.3 236.15,76.12 236.35,76.32 236.35,76.51 237.24,77.4 237.56,77.4 238.28,76.67 JDEG2.9 ; v3(189.17,64.91) 189.6,64.47 190.03,64.47 190.19,64.31 U46.B2 ; v3(192.27,64.8) 193.19,63.87 R806.1
  IN2 w0.127: v3(192.27,64.8) 192.69,65.22 199.57,65.22 201.93,67.58 201.93,69.99 203.04,71.09 203.04,74.68 200.98,76.74 200.98,83.48 203.99,86.49 203.99,89.29 203.99,89.29 203.99,89.5 203.58,89.91 203.58,92.54 209.01,97.97 209.01,98.18 209.01,106.77 207.53,108.25 207.53,111.23 207.84,111.54 207.84,114.65 206.54,115.95 206.54,126.13 203.65,129.02 203.65,142.39 201.03,145.01 199.49,145.01 v3(198.93,145.57)
  IN3 w0.127: v3(232.03,76.5) 232.03,75.24 224.38,67.59 218.63,67.59 215.56,64.53 207.88,64.53 207.16,63.81 205.27,63.81 203.8,65.29 193.63,65.29 193.56,65.22 192.47,65.22 192.27,65.01 v3(192.27,64.8)
  BOTTOM w0.102: JMINI2.17 203.1,157.51 202.81,157.22 202.44,157.22 200.98,155.76 200.98,150.51 198.93,148.46 v3(198.93,145.57) ; v3(192.27,64.8) 191.97,64.5 v1(191.07,64.5) 189.36,64.5 189.17,64.7 v3(189.17,64.91)
EC_32KHZ_ECE5048: length 36.1
  TOP w0.102: v3(181.15,73.46) 180.91,73.22 180.91,71.94 181.04,71.81 U46.B35 ; v3(205.74,77.78) 205.72,77.79 U51.B62
  IN1 w0.102: v3(205.74,77.78) 205.41,77.78 204.42,76.79 204.42,75.8 203.76,75.14 198.4,75.14 197.32,76.22 191.09,76.22 189.26,74.38 189.26,73.12 188.79,72.65 188.79,70.92 188.36,70.5 181.78,70.5 181.5,70.77 181.5,73.11 v3(181.15,73.46)
EC_WAKE#: length 115.6
  TOP w0.102: v3(213.01,77.6) 213.42,77.19 213.9,77.19 214,77.29 U51.B23
  IN2 w0.127: v3(212.62,122.91) 214.5,121.03 214.5,119.16 215.69,117.97 216.32,117.97 219.34,114.95 219.34,110.5 218.28,109.44 218.28,103.63 216.47,101.82 216.47,84.62 215.19,83.34 215.19,79.1 214.13,78.03 213.43,78.03 213.01,77.62 v3(213.01,77.6)
  IN3 w0.089: v3(170.22,132.1) 170.69,131.63 170.69,131.63 170.82,131.49 170.82,130 171.04,129.78 171.44,129.78 172.26,128.96 172.91,128.96 173.56,128.31 174.39,128.31 174.46,128.38 175.08,128.38 175.59,128.9 176.64,128.9 176.69,128.95 177.22,128.95
  IN3 w0.127: v3(212.62,122.91) 212.44,123.09 209.12,123.09 206.98,125.22 204.47,125.22 203.95,124.7 192.8,124.7 190.45,127.05 v3(188.85,127.05) 188.63,126.84 183.24,126.84 182.54,127.54 179.26,127.54 177.84,128.95 177.22,128.95
  BOTTOM w0.089: UH1.R11 169.98,132.1 v3(170.22,132.1)
  BOTTOM w0.102: RH216.1 RH196.1 185.7,134.25 188.98,134.25 189.45,133.78 189.45,132.4 187.34,130.29 187.34,128.56 v1(188.34,127.56) v3(188.85,127.05)
ECE5048_PWRGD: length 17.4
  TOP w0.102: v3(213.21,85.55) 212.84,85.18 212.84,84.72 212.93,84.64 U51.A34 ; v3(201.33,88.61) 200.69,89.26 U50.1
  BOTTOM w0.102: v3(213.21,85.55) 212.76,85.55 211.33,84.13 205.8,84.13 v1(202.43,87.51) 202.43,87.52 v3(201.33,88.61)
EDCA0_0: length 26
  BOTTOM w0.089: UV5.R13 89.03,108.09 89.03,109.4 ; 83.38,127.47 82.53,127.47 82.31,127.7 81.09,127.7 80.79,127.4 UV1.H28
  BOTTOM w0.13: 89.03,109.4 89.41,109.78 89.41,110.48 88.46,111.43 v1(88.46,119.37) 88.46,121.89 87.29,123.06 87.29,124.19 84.48,127 83.85,127 83.38,127.47
EDCA0_1: length 22.3
  TOP w0.089: UV4.C2 v3(79.4,108.06)
  IN1 w0.089: v3(79.4,108.06) 79.4,108.06 79.78,107.69 82.23,107.69 83.02,108.47 83.02,109.89
  IN1 w0.127: 83.02,109.89 83.02,112.75 82.03,113.73 82.03,119.7 79.61,122.13 79.61,122.71 79.95,123.06 v3(80.16,123.06)
  BOTTOM w0.1: v3(80.16,123.06) 80.16,123.82 UV1.C27
EDCA0_2: length 32.1
  BOTTOM w0.089: 77.03,122.09 76.61,122.52 76.61,123.37 UV1.A23 ; 78.04,96.57 78.61,96.57 78.93,96.89 79.12,96.89 79.44,97.21 79.44,97.46 79.8,97.82 UV5.C2
  BOTTOM w0.13: 78.04,96.57 77.86,96.57 75.35,99.08 v1(75.35,107.94) 75.35,113.84 77.7,116.19 77.7,120.3 77.03,120.97 77.03,122.09
EDCA0_3: length 46.2
  TOP w0.089: UV4.R13 v3(88.2,97.66)
  IN1 w0.127: v3(73.43,121.11) 73.63,121.11 73.92,120.83 73.92,119.69 72.66,118.43 72.66,99.88 78.04,94.5 83.07,94.5 84.71,96.14 84.71,96.51 85.47,97.27 87.81,97.27 v3(88.2,97.66)
  BOTTOM w0.089: 72.98,122.6 72.98,123.08 72.88,123.18 72.88,123.98 UV1.E19
  BOTTOM w0.1: v3(73.43,121.11) 72.96,121.58 72.96,122.58 72.98,122.6
EDCA1_0: length 19.2
  BOTTOM w0.089: 70.08,121.7 69.78,122 69.78,123.08 69.68,123.18 69.68,124.5 UV1.E15 ; 68.98,110.29 68.98,107.98 UV6.C2
  BOTTOM w0.13: 68.98,110.29 68.03,111.25 v1(68.03,113.91) 68.03,115.92 70.16,118.05 70.16,119.57 70.08,119.65 70.08,121.7
EDCA1_1: length 23.9
  TOP w0.089: UV3.R13 v3(59.46,108.06)
  IN1 w0.127: v3(59.46,108.06) 59.87,107.65 63.15,107.65 63.82,108.32 63.82,110 67.31,113.49 67.31,119.82 v3(66.84,120.29)
  BOTTOM w0.089: UV1.D10 65.88,124.3 65.88,123.15 65.78,123.05 65.78,122.65 66.11,122.32
  BOTTOM w0.1: v3(66.84,120.29) 66.11,121.02 66.11,122.32
EDCA1_2: length 56.4
  TOP w0.089: UV3.C2 v3(68.26,97.66)
  IN1 w0.127: v3(68.26,97.66) 68.26,97.46 67.86,97.06 67.86,95.85 67.5,95.49 67.38,95.49 66.96,95.08 66.96,94.95 66.57,94.57 56.39,94.57 54.24,96.71 54.24,96.89 54.53,97.18 54.53,97.36 54.33,97.55 54.15,97.55 53.86,97.27 53.68,97.27 53.49,97.47 53.49,97.65 53.77,97.93 53.77,98.11 53.58,98.31 53.4,98.31 53.15,98.07 52.97,98.07 52.68,98.36 52.68,98.54 52.9,98.76 52.9,98.99 52.68,99.2 52.68,103.52 52.81,103.65 52.96,103.65 53.08,103.77 53.08,104.15 52.96,104.28 52.81,104.28 52.68,104.41 52.68,118.08 57.63,123.03 59.29,123.03 59.54,122.78 61.35,122.78 v3(61.71,122.42)
  BOTTOM w0.089: UV1.D6 62.67,124.29 62.67,123.19 62.33,122.85 62.13,122.85 v3(61.71,122.42)
EDCA1_3: length 41.6
  BOTTOM w0.089: 59.05,126.23 59.06,126.23 59.43,126.61 60.1,126.61 60.4,126.91 61.87,126.91 UV1.G5 ; UV6.R13 59.48,98.44 58.22,98.44
  BOTTOM w0.13: 59.05,126.23 58.76,125.94 58.76,125.25 58.34,124.82 58.34,124.51 v1(57.43,123.6) 52.75,118.93 52.75,115.63 52.88,115.5 52.95,115.5 53.08,115.37 53.08,115.1 52.95,114.97 52.88,114.97 52.75,114.84 52.75,114.56 52.88,114.43 52.95,114.43 53.08,114.3 53.08,114.02 52.95,113.89 52.88,113.89 52.75,113.76 52.75,113.49 52.88,113.36 52.95,113.36 53.08,113.23 53.08,112.95 52.95,112.82 52.88,112.82 52.75,112.69 52.75,112.42 52.88,112.29 52.95,112.29 53.08,112.16 53.08,111.88 52.95,111.75 52.88,111.75 52.75,111.62 52.75,111.34 52.88,111.21 52.95,111.21 53.08,111.08 53.08,110.81 52.95,110.68 52.88,110.68 52.75,110.55 52.75,110.27 52.88,110.14 52.95,110.14 53.08,110.01 53.08,109.74 52.95,109.61 52.88,109.61 52.75,109.48 52.75,109.2 52.88,109.07 52.95,109.07 53.08,108.94 53.08,108.66 52.95,108.53 52.88,108.53 52.75,108.4 52.75,108.13 52.88,108 52.95,108 53.08,107.87 53.08,107.59 52.95,107.46 52.88,107.46 52.75,107.33 52.75,107.06 52.88,106.93 52.95,106.93 53.08,106.8 53.08,106.52 52.95,106.39 52.88,106.39 52.75,106.26 52.75,103.43 54.42,101.76 54.42,101.31 56.22,99.51 56.34,99.51 57.41,98.44 58.22,98.44
EDP_COMP: length 2.4
  TOP w0.508: RC73.2 140.23,98 v3(140.45,98.22)
  BOTTOM w0.305: JCPU1.E24 140.94,98.71 v3(140.45,98.22)
EDP_CPU_AUX: length 118.5
  TOP w0.089: v3(132.47,102.2) 132.77,102.5 132.77,102.7 132.89,102.82 132.89,105.42 134.27,106.8 134.67,106.8 134.87,107.01 134.87,108.41 135.25,108.79 135.6,108.79 136.87,110.07 136.87,110.46 136.87,110.47 136.87,110.7
  TOP w0.102: v3(145.08,156.86) 145.27,156.67 145.27,155.92 145.67,155.52 145.67,151.41 142.56,148.3 142.56,137.51 141.47,136.42 141.47,115.76 136.87,111.16 136.87,110.7 ; v3(195.07,163.68) 194.84,163.91 194.84,164.03 195.03,164.22 195.55,164.22 C104.2
  IN1 w0.114: v3(195.07,163.68) 195.01,163.74 195.01,164.26 194.76,164.52 190.18,164.52 189.48,163.82 177.61,163.82 177.17,164.26 172.72,164.26 172.28,163.82 165.41,163.82 161.93,160.34 156.77,160.34 152.82,156.39 147.2,156.39 145.99,157.6 145.54,157.6 145.26,157.31 145.26,157.04 v3(145.08,156.86)
  BOTTOM w0.089: v3(132.47,102.2) JCPU1.N27
EDP_CPU_AUX#: length 118.5
  TOP w0.089: v3(133.47,102.2) 133.06,102.2 132.97,102.29 132.97,102.62 133.08,102.73 133.08,105.34 134.35,106.61 134.75,106.61 135.07,106.92 135.07,108.32 135.34,108.59 135.68,108.59 137.07,109.99 137.07,110.61 137.08,110.61 137.08,110.67 137.08,110.68 137.08,110.7
  TOP w0.102: v3(145.67,156.86) 145.48,156.67 145.48,156.01 145.88,155.61 145.88,151.32 142.77,148.22 142.77,137.42 141.68,136.33 141.68,115.67 137.08,111.07 137.08,110.7 ; v3(194.49,163.68) 194.63,163.82 194.63,164.12 194.94,164.43 195.55,164.43 C105.2
  IN1 w0.114: v3(194.49,163.68) 194.78,163.97 194.78,164.17 194.66,164.29 190.27,164.29 189.57,163.59 177.52,163.59 177.07,164.04 172.82,164.04 172.37,163.59 165.51,163.59 162.03,160.11 156.86,160.11 152.91,156.16 147.1,156.16 145.89,157.37 145.64,157.37 145.49,157.22 145.49,157.04 v3(145.67,156.86)
  BOTTOM w0.089: v3(133.47,102.2) JCPU1.M27
EDP_CPU_AUX#_C: length 1.8
  TOP w0.102: C105.1 197.15,164.43 197.68,164.43 197.77,164.52 U27.3
EDP_CPU_AUX_C: length 1.8
  TOP w0.102: C104.1 197.13,164.22 197.68,164.22 197.77,164.12 U27.4
EDP_CPU_LANE_N0: length 112.6
  TOP w0.102: v3(194.15,162.99) 194.18,162.96 194.18,162.49 194.44,162.23 195.25,162.23 C101.2 ; v3(131.43,110.25) 131.22,110.04 131,110.04 130.88,110.16 130.88,110.48 131.58,111.18 133.63,111.18 134.46,112.01 135.94,112.01 140.09,116.16 140.09,136.8 141.39,138.1 141.39,148.79 144.07,151.48 144.07,156.64 v3(144.27,156.84)
  IN1 w0.114: v3(194.15,162.99) 194.38,162.77 194.38,162.62 194.31,162.55 192.16,162.55 191.61,163.1 176.81,163.1 176.53,163.38 172.87,163.38 172.59,163.1 166.97,163.1 163.49,159.62 157.07,159.62 153.12,155.67 144.93,155.67 144.15,156.45 144.15,156.71 v3(144.27,156.84)
  BOTTOM w0.089: v3(131.43,110.25) 131.94,109.74 JCPU1.P35
EDP_CPU_LANE_N0_C: length 2.6
  TOP w0.102: C101.1 196.29,162.25 196.58,162.54 196.69,162.54 196.96,162.27 197.38,162.27 197.63,162.52 U27.8
EDP_CPU_LANE_N1: length 112.6
  TOP w0.102: v3(144.57,153.72) 144.76,153.54 144.76,151.48 141.87,148.59 141.87,137.8 140.64,136.57 140.64,115.91 136.02,111.29 136.02,110.65 135.42,110.06 134.39,110.06 134.16,109.82 134.16,108.92 134.02,108.78 133.02,108.78 132.92,108.88 132.92,109.28 133.03,109.4 133.27,109.4 v3(133.47,109.2) ; C118.2 195.25,160.45 194.58,160.45 194.18,160.85 v3(194.18,161.48)
  IN1 w0.114: v3(144.57,153.72) 144.78,153.93 144.78,154.68 145.04,154.94 145.77,154.94 146.04,154.68 146.04,154.3 146.16,154.17 146.48,154.17 146.61,154.3 146.61,154.69 146.85,154.94 147.39,154.94 147.64,154.69 147.64,154.3 147.76,154.17 148.08,154.17 148.21,154.3 148.21,154.69 148.46,154.94 153.44,154.94 155.3,156.8 156.12,156.8 158.21,158.89 163.79,158.89 166.16,161.25 172.32,161.25 173.65,162.59 176.25,162.59 177.11,161.72 179.2,161.72 180.15,160.77 194.12,160.77 194.37,161.03 194.37,161.29 v3(194.18,161.48)
  BOTTOM w0.089: JCPU1.N34 133,108.73 v3(133.47,109.2)
EDP_CPU_LANE_N1_C: length 2.7
  TOP w0.102: C118.1 197.19,161.23 197.22,161.23 197.64,161.65 197.64,161.67 197.69,161.72 U27.10
EDP_CPU_LANE_P0: length 112.6
  TOP w0.102: v3(143.69,156.84) 143.86,156.66 143.86,151.56 141.18,148.88 141.18,138.18 139.88,136.89 139.88,116.25 135.85,112.22 134.37,112.22 133.54,111.39 131.49,111.39 130.66,110.57 130.66,110.4 v3(130.46,110.2) ; v3(194.73,162.99) 194.4,162.66 194.4,162.57 194.53,162.44 194.83,162.44 C100.2
  IN1 w0.114: v3(143.69,156.84) 143.92,156.6 143.92,156.36 144.84,155.44 153.21,155.44 157.17,159.39 163.59,159.39 167.07,162.87 172.69,162.87 172.97,163.15 176.44,163.15 176.72,162.87 191.52,162.87 192.06,162.32 194.4,162.32 194.6,162.52 194.6,162.86 194.6,162.86 v3(194.73,162.99)
  BOTTOM w0.089: JCPU1.R35 130.93,109.73 v3(130.46,110.2)
EDP_CPU_LANE_P0_C: length 2.6
  TOP w0.102: U27.7 197.86,162.92 197.67,162.73 197.54,162.73 197.29,162.48 197.05,162.48 196.78,162.75 196.54,162.75 C100.1
EDP_CPU_LANE_P1: length 112.6
  TOP w0.102: v3(145.16,153.72) 144.97,153.54 144.97,151.4 142.08,148.5 142.08,137.71 140.85,136.48 140.85,115.82 136.23,111.2 136.23,110.56 135.51,109.85 134.48,109.85 134.37,109.74 134.37,108.83 134.11,108.57 132.93,108.57 132.71,108.79 132.71,108.98 v3(132.48,109.2) ; C103.2 194.83,160.67 194.67,160.67 194.4,160.94 194.4,161.1 v3(194.77,161.48)
  IN1 w0.114: v3(194.77,161.48) 194.6,161.31 194.6,160.93 194.21,160.54 180.06,160.54 179.1,161.5 177.01,161.5 176.15,162.36 173.74,162.36 172.41,161.03 166.25,161.03 163.89,158.66 158.3,158.66 156.21,156.57 155.4,156.57 153.54,154.71 148.55,154.71 148.44,154.6 148.44,154.2 148.17,153.94 147.67,153.94 147.41,154.2 147.41,154.6 147.29,154.71 146.95,154.71 146.84,154.6 146.84,154.2 146.57,153.94 146.07,153.94 145.81,154.2 145.81,154.59 145.68,154.71 145.14,154.71 145.01,154.59 145.01,153.87 v3(145.16,153.72)
  BOTTOM w0.089: v3(132.48,109.2) 132.42,109.2 131.95,108.73 JCPU1.P34
EDP_CPU_LANE_P1_C: length 2.7
  TOP w0.102: C103.1 196.48,161.03 196.69,161.03 v4(197.27,161.61) 197.6,161.93 197.7,161.93 197.89,162.12 U27.9
EDP_HPD#: length 18.6
  TOP w0.089: 130.95,111.73 130.06,110.84 130.06,109.5 130.94,108.61 130.94,101.74 v3(131.47,101.2)
  TOP w0.102: QC3.1 135.72,114.36 RC74.1 133.43,112.07 v1(133.16,112.07) 131.28,112.07 130.95,111.73
  BOTTOM w0.089: JCPU1.P27 131.94,101.67 v3(131.47,101.2)
EMBCLK_REQ#: length 103
  TOP w0.089: v3(168.31,125.83) 168.77,126.29 RPH9.4
  IN1 w0.102: v3(173.98,78.67) 173.98,77 172.19,75.21 172.19,61.34 170.46,59.62 170.46,55.3 169.95,54.79 169.95,46.04 JSATA2.26
  IN2 w0.127: v3(173.98,78.67) 174.49,79.17 175.67,79.17 179.12,82.62 179.12,87.02 178.69,87.45 178.69,89.62 178.56,89.75 178.56,90.62 179.76,91.81 179.76,103.77 180.3,104.31 180.3,105.27 179.21,106.35 v3(178.39,106.35)
  IN4 w0.089: v3(168.31,125.83) 168.78,125.36 168.78,125
  IN4 w0.102: v3(178.39,106.35) 177.93,106.81 177.93,107.24 175.61,109.56 174.09,109.56 170.12,113.53 168.98,113.53 167.71,114.81 167.71,117.67 169.25,119.22 169.25,119.37 170.08,120.2 170.08,121.05 168.79,122.34 168.79,122.61 168.4,122.99 168.4,124.01 168.78,124.39 168.78,125
  BOTTOM w0.089: UH1.Y3 167.75,128.9 167.75,128.74 167.79,128.7 167.79,128.6 167.79,128.56 167.79,128.38 168.03,128.14 168.03,127.83 167.89,127.69 167.89,126.98
  BOTTOM w0.102: v3(168.31,125.83) 168.31,125.87 168.14,126.04 168.14,126.04 167.91,126.27 167.91,126.27 167.89,126.29 167.89,126.98 ; v3(173.98,78.67) v1(173.98,79.23)
EN_1.5VSP: length 4.6
  TOP w0.102: PR403.2 203.09,52.9 v1(203.14,52.85)
  TOP w0.254: PR403.2 PR406.2 PC406.1 199.84,53.28 199.84,53.84 200.11,54.11 PU400.5
EN_+1.05VSP: length 6.3
  TOP w0.102: PR303.2 179.31,93.73 179.64,93.4 181.04,93.4 v1(181.55,92.89)
  TOP w0.254: PU300.3 178.5,95.68 178.56,95.75 PC307.1 PR308.2 PR303.2
EN_+1.8V_RUN: length 4.3
  BOTTOM w0.102: v1(106.36,120.32) 106.16,120.53 PC675.1
  BOTTOM w0.254: PU603.8 105.04,122.93 105.17,122.8 PR688.2 PC675.1
EN_DK_PWRBAR: length 8.7
  TOP w0.102: PR874.1 42.53,149.79 v2(41.4,149.79)
  TOP w0.254: PR874.1 43.32,149 43.32,147.55 43.58,147.3 PR866.1 44.07,147.1 44.07,144.07 43.73,143.73 PU800.17
EN_DOCK_PWR_BAR: length 242.4
  TOP w0.102: U46.B37 181.82,70.81 v3(181.93,70.92)
  TOP w0.254: PR866.2 43.88,148.75 v3(43.95,148.82)
  IN3 w0.127: v3(47.52,132.51) 47.52,130.37 51.35,126.55 51.35,120.26 49.29,118.2 49.29,98.63 54.48,93.44 72.34,93.44 73.03,92.75 77.34,92.75 78.03,93.44 79.76,93.44 80.15,93.04 85.22,93.04 89.89,88.38 89.89,81.53 88.06,79.7 88.06,63.12 90.78,60.4 106,60.4 115.68,50.73 150.15,50.73 155.89,56.47 164.85,56.47 166.58,58.19 175.28,58.19 177.06,59.98 177.06,63.83 178.54,65.31 178.54,69.09 178.94,69.48 180.93,69.48 181.42,69.97 181.42,70.41 v3(181.93,70.92)
  BOTTOM w0.102: v3(47.52,132.51) 46.25,133.78 v1(43.88,133.78) 42.86,133.78 42.2,134.44 42.2,135.64 43.4,136.83 43.4,148.02 43.95,148.57 v3(43.95,148.82)
EN_I2S_NB_CODEC#: length 173.7
  TOP w0.102: v3(181.91,71.65) 181.56,71.31 U46.B36 ; v3(248.83,158.01) 249.3,157.53 249.84,157.53 250.09,157.28 250.09,156.01 251.75,154.35 251.75,153.59 253.98,151.36 260.21,151.36 261.3,152.45 261.3,160.24 263.29,162.23 v1(263.86,162.23) 264.35,162.23 264.67,162.55 266.26,162.55 267.34,161.47 268.48,161.47 268.79,161.16 U74.48
  IN2 w0.127: v3(201.61,139.66) 200.06,138.11 200.06,127.48 197.68,125.09 197.68,118.13 197.27,117.72 197.27,101.75 195.68,100.16 195.68,93.34 194.83,92.49 194.83,85.42 192.25,82.84 192.25,80.49 190.92,79.16 190.92,74.05 188.79,71.91 188.79,70.92 188.53,70.67 188.16,70.67 187.62,70.13 183.31,70.13 181.91,71.53 v3(181.91,71.65)
  IN3 w0.127: v3(248.83,158.01) 248.53,158.01 247.86,157.33 245.26,157.33 243.87,155.94 240.32,155.94 238.82,154.44 233.24,154.44 230.63,151.82 230.63,148.31 224.12,141.8 219.6,141.8 219.39,141.6 207.39,141.6 206.12,140.33 202.28,140.33 v3(201.61,139.66)
EN_INVPWR: length 122.5
  TOP w0.102: RP9.7 222.37,75.42 222.51,75.56 222.51,76.76 v3(222.06,77.21) ; Q22.2 211.44,165.49 211.77,165.15 211.77,163.07 209.83,161.13 209.83,158.22 208.52,156.91 208.52,154.05 208.93,153.65 208.93,152.44 209.55,151.82 211.46,151.82 212.24,151.04 216.33,151.04 216.73,150.65 216.73,148.22 216.24,147.74 216.24,142.76 214.66,141.18 212.26,141.18 209.62,138.53 208.17,137.09 207.32,137.09 v3(206.59,136.36) ; U51.A25 v3(215.9,79.04)
  IN2 w0.127: v3(206.59,136.36) 207,136.77 207.52,136.77 208.51,135.78 208.51,128.47 209.59,127.39 209.59,125.85 211.49,123.94 212.18,123.94 214.76,121.36 214.76,119.26 215.79,118.23 216.43,118.23 219.6,115.06 219.6,110.39 218.54,109.33 218.54,103.53 216.73,101.72 216.73,84.51 215.45,83.23 215.45,79.69 215.9,79.24 v3(215.9,79.04)
  BOTTOM w0.102: v3(222.06,77.21) 222.51,77.65 222.51,78.48 221.62,79.37 v1(218,79.37) 216.79,79.37 216.47,79.04 v3(215.9,79.04)
EN_PCIE: length 3.9
  TOP w0.102: v3(108.44,135.17) 108.44,136.02 v1(108.21,136.26)
  TOP w0.254: v3(108.44,135.17) 108.44,134.45 PR681.2 108.52,134.31 PC665.1
  BOTTOM w0.254: v3(108.44,135.17) PU602.5
ENVDD_PCH: length 114.5
  TOP w0.089: v3(172.93,143.05) 172.93,142.88 173.18,142.62 174.45,142.62 174.69,142.87 RH118.2
  TOP w0.102: v3(182.51,69.9) 182.51,70.11 182.22,70.4 181.71,70.4 181.61,70.31 U46.B38
  IN2 w0.127: v3(187.39,149.66) 187.56,149.49 188.01,149.49 192.09,145.42 192.09,142.19 194.19,140.09 194.19,133.25 191.94,131 191.94,118.9 191.26,118.22 191.26,104.62 191.37,104.51 191.37,95.99 188.54,93.17 188.54,86.76 187.99,86.21 187.99,80.53 186.44,78.98 185.15,78.98 181.05,74.89 181.05,74.15 181.57,73.63 181.57,72.78 181.49,72.7 181.49,70.73 181.74,70.48 182.13,70.48 182.51,70.09 v3(182.51,69.9)
  IN3 w0.089: 177.22,144.61 175.88,143.27 174.08,143.27 173.86,143.5 173.38,143.5 172.93,143.05 v3(172.93,143.05)
  IN3 w0.127: v3(187.39,149.66) 187.12,149.66 184.49,147.03 182.8,145.34 177.95,145.34 177.22,144.61
  BOTTOM w0.089: v3(172.93,143.05) 172.93,142.89 UH1.G36
  BOTTOM w0.102: v1(181.55,69.4) 181.61,69.46 182.31,69.46 182.51,69.66 v3(182.51,69.9)
ERC1: length 5.1
  TOP w0.102: v1(35.94,136.39) 36.7,137.15 PC815.1
  TOP w0.254: PC815.1 37.45,137.15 38.05,137.75 38.65,137.75 39.32,138.42 PU800.3
ERC2: length 7.3
  TOP w0.102: v1(46.1,137.54) PC817.1
  TOP w0.254: PU800.13 43.87,141.73 44.07,141.53 44.83,141.53 45.32,141.05 45.32,138.52 44.9,138.1 PC817.1
ERC3: length 5.5
  TOP w0.254: PU800.12 43.83,141.23 43.97,141.09 44.39,141.09 v1(44.64,140.83) 44.93,140.54 44.93,138.71 43.82,137.59 PC816.1
ESATA_USB_PWR_EN#: length 213.9
  TOP w0.102: v1(280.86,166.04) 280.56,166.35 v3(280.56,167.31) 280.39,167.48 U93.4 ; v3(190.4,60.22) 190.4,59.75 190.12,59.48 RP4.7 ; v3(182.58,66.72) 181.99,67.31 U46.B44 ; v3(283.39,179.93) U91.4
  IN1 w0.102: v3(182.58,66.72) 183.07,66.72 184.42,65.37 184.88,65.37 185.43,64.82 185.43,63.74 186.44,62.73 187.64,62.73 187.92,62.45 189.68,62.45 190.22,61.9 190.22,60.4 v3(190.4,60.22)
  IN3 w0.127: v3(190.4,60.22) 190.75,60.22 192.43,61.9 217.1,61.9 218.19,62.99 226.13,62.99 231.08,67.94 231.08,69.33 235.61,73.87 235.61,81.18 v3(235.4,81.4) ; v3(280.56,167.31) 279.88,167.99 279.88,170.98 283.39,174.49 v3(283.39,179.93)
  IN4 w0.102: v3(235.4,81.4) 236.69,81.4 240.3,85 240.3,138.42 248.86,146.98 248.86,149.52 249.12,149.79 249.12,150.59 249.91,151.37 249.91,153.69 251.94,155.72 254.35,155.72 255.41,156.78 255.41,158.17 254.52,159.06 254.52,162.93 257.24,165.65 260.48,165.65 262.84,168.01 272.61,168.01 273.84,166.78 280.02,166.78 v3(280.56,167.31)
EXPCLK_REQ#: length 178.4
  TOP w0.089: v3(168.29,126.43) 168.27,126.45 RPH9.3
  TOP w0.102: JEXP1.27 228.68,36.65 226.57,34.54 226.57,30.5 225.58,29.51 222.45,29.51 v1(221.24,30.72) 220.22,30.72 219.14,31.8 v3(219.14,32.08)
  IN4 w0.089: v3(168.29,126.43) 168.33,126.43 169.14,125.62 169.14,125
  IN4 w0.102: 169.14,125 169.14,124.07 169.64,123.57 169.64,121.84 170.31,121.17 170.31,120.06 169.48,119.23 169.48,117.68 167.93,116.13 167.93,114.9 169.08,113.76 170.22,113.76 174.19,109.79 175.71,109.79 178.79,106.7 178.79,104.09 182.04,100.84 182.04,96.6 182.4,96.24 182.4,90.72 182.69,90.42 182.69,86.42 182.57,86.3 182.57,85.67 182.84,85.41 182.84,83.71 182.28,83.15 182.28,81.69 181.08,80.49 180.37,80.49 175.63,75.75 174.85,75.75 174.51,75.41 172.98,75.41 171.79,74.22 171.79,55.59 170.63,54.43 170.63,44.05 173.52,41.15 174.08,41.15 174.18,41.05 174.18,38.73 173.97,38.51 173.97,37.86 174.69,37.13 174.69,35.61 178.04,32.27 192.91,32.27 195.32,29.85 218.02,29.85 219.14,30.98 v3(219.14,32.08)
  BOTTOM w0.089: v3(168.29,126.43) 168.29,127.07 168.21,127.16 168.21,128.17 168.42,128.38 168.42,128.84 UH1.V3
EXPRCRD_CPPE#: length 38.2
  TOP w0.102: v3(221.01,37.65) 222,37.65 222.25,37.9 v1(223.27,37.9) 225.43,37.9 225.74,37.58 225.74,36.84 225.55,36.65 JEXP1.28 ; U41.10 232.4,61.98 232.24,62.14 v3(231.81,62.14) 230.77,61.1 CE11.1
  IN1 w0.102: v3(221.01,37.65) 222.16,38.8 222.16,52.46 231.84,62.14 v3(231.81,62.14)
EXPRCRD_STBY_R#: length 4.8
  TOP w0.102: v1(238,66.86) 237.89,66.97 R734.2 R717.2 236.09,66.53 236.09,65.9 235.63,65.44 U41.1
EXT_MIC: length 12.8
  IN1 w1.524: JHP1.4 299.9,159.69 295.78,159.69 291.86,155.77 291.85,155.77 290.41,154.33
  vias: v2(290.03,152.92) v3(289.05,153.28) v3(289.43,152.77) v3(289.65,153.34)
FAN1_PWM: length 207.2
  TOP w0.102: U51.A24 215.4,78.54 215.99,77.96 v3(216.1,77.96) 216.12,77.96 216.52,78.36 v2(216.52,78.73)
  BOTTOM w0.102: JFAN1.3 50.16,90.18 50.48,90.5 52.17,90.5 52.68,89.99 55.34,89.99 R38.2 56.31,89.02 81.86,89.02 86.62,84.26 86.62,71.55 86.64,71.53 86.64,71.49 98.54,59.59 147.52,59.59 151.06,56.06 164.67,56.06 166.51,57.9 171.66,57.9 172.55,58.79 176.58,58.79 177.58,57.79 180.5,57.79 181.4,58.69 184.43,58.69 185.22,59.48 186.46,59.48 187.39,60.41 187.39,62.16 188.05,62.82 192.2,62.82 192.84,63.46 195.94,63.46 196.44,63.95 207.1,63.95 209.74,66.6 209.74,68.88 209.96,69.1 209.96,70.69 210.4,71.14 210.4,73.94 210.1,74.25 210.1,75.97 210.47,76.35 213.2,76.35 213.23,76.38 214.52,76.38 v3(216.1,77.96)
FAN1_TACH_FB: length 207.5
  TOP w0.102: U51.B22 214.27,76.79 v3(213.62,76.79) ; v3(93.13,65.61) v2(92.57,65.61)
  BOTTOM w0.102: v3(213.62,76.79) 213.24,77.16 212.68,77.16 212.09,76.58 209.81,76.58 209.17,75.94 209.17,74.6 209.33,74.44 209.33,71.2 209.04,70.91 209.04,66.22 207,64.18 196.34,64.18 195.85,63.69 190.4,63.69 189.77,63.06 187.93,63.06 187.29,62.42 186.76,62.42 186.21,61.86 186.21,60.83 185.95,60.57 185.68,60.57 185.31,60.2 185.31,59.89 184.46,59.05 181.42,59.05 180.4,58.02 177.67,58.02 176.67,59.02 172.45,59.02 171.57,58.13 166.41,58.13 164.57,56.29 161.44,56.29 151.15,56.29 147.62,59.82 98.92,59.82 v3(93.13,65.61) 92.9,65.61 86.87,71.64 86.87,84.37 81.97,89.27 59.76,89.27 58.07,90.96 56.22,90.96 R30.2 C1555.1 55.45,91.46 55.23,91.24 55.23,90.54 54.92,90.22 52.77,90.22 52.15,90.85 49.3,90.85 48.91,90.45 JFAN1.2
FB: length 5.2
  TOP w0.102: v1(128.08,148.83) 128,148.76 PR533.2
  TOP w0.254: PR543.2 PR537.2 ; PR543.2 127.65,146.81 v3(127.38,146.55) ; PR543.2 128,146.83 PR533.2
  BOTTOM w0.203: v3(127.38,146.55) 127.38,146.1 127.01,145.73 PU500.8
FB2/VSEN: length 3.3
  BOTTOM w0.102: PR529.2 129.47,145.9 v1(129.92,146.36)
  BOTTOM w0.203: PR529.2 128.1,145.09 PU500.9
FB_+1.05VSP: length 4.2
  TOP w0.102: PR306.2 179.31,98.91 v1(179.39,98.99)
  TOP w0.254: PU300.4 178.86,96.18 178.95,96.28 178.96,96.28 PR307.2 PR306.2
FB_PCIE: length 4.9
  BOTTOM w0.102: PR684.1 109.59,128.37 v1(109.98,128.77)
  BOTTOM w0.254: PU602.6 108.44,129.91 108.15,129.62 PR683.2 PC668.2 108.21,128.37 PR684.1
FB_VGA: length 15.5
  TOP w0.203: PU600.8 24.18,145.77 24.47,145.48 v3(24.47,145.21)
  TOP w0.254: v3(27.55,141.07) 27.31,141.07 PR640.1 26.8,139.52 26.53,139.25 25.85,139.25 25.8,139.29 24.79,139.29 24.12,139.96 PR639.1 PR642.2 24.11,141.48 PR644.1 23.23,141.49 PC613.2
  BOTTOM w0.254: v3(27.55,141.07) 26.9,141.72 25.99,141.72 24.45,143.26 v1(24.45,144.07) 24.47,144.1 v3(24.47,145.21)
FC_G6: length 20.7
  TOP w0.102: v3(148.97,89.65) v1(149.86,89.65)
  IN4 w0.089: 146.33,89.65 140.34,89.65 139.96,89.27 139.96,81.68 v3(139.47,81.2)
  IN4 w0.102: v3(148.97,89.65) 146.33,89.65
  BOTTOM w0.089: v3(139.47,81.2) 139,80.73 JCPU1.G6
  BOTTOM w0.102: RC68.1 RC69.2 v3(148.97,89.65)
FDI_CSYNC: length 64.9
  IN4 w0.089: v3(138.47,104.2) 138.85,104.58 143.89,104.58 145.09,105.77 145.09,106.35 ; v3(162.76,143.89) 162.38,143.51 162.38,141.46 162.5,141.34 162.5,138.87 162.12,138.49 158.3,138.49 158.05,138.74 155.02,138.74 153.86,139.89 153.69,139.89
  IN4 w0.102: 153.69,139.89 153.2,139.89 152.51,140.59 149.95,140.59 144.26,134.9 144.26,113.9 145.09,113.07 145.09,106.35
  BOTTOM w0.089: v3(162.76,143.89) 163,144.13 UH1.AL39 ; v3(138.47,104.2) 138,103.73 JCPU1.H29
FDI_CTX_PRX_N0: length 80
  IN4 w0.089: 155.67,137.81 157.04,137.81 157.76,137.1 158.73,137.1 158.98,137.35 160.08,137.35 160.27,137.15 163.03,137.15 163.82,137.95 163.82,138.92 163.36,139.37 163.36,140.85 163.59,141.07 163.98,141.07 164.18,141.28 164.18,142.21 164.14,142.25 164.14,142.83 164.05,142.92 163.93,142.92 163.74,142.72 v3(163.74,142.59) ; 146.17,104.01 146.15,104 146.15,103.98 143.96,101.78 133.35,101.78 133.07,102.06 133.07,105.33 132.6,105.81 132.18,105.81 132.05,105.94 132.05,107.34 131.51,107.88 v3(131.51,108.18)
  IN4 w0.114: 155.67,137.81 154.14,137.81 153.66,138.29 150.62,138.29 145.87,133.55 145.87,126.48 145.4,126 145.4,114.37 146.59,113.18 146.59,104.43 146.17,104.01
  BOTTOM w0.089: v3(163.74,142.59) 164.08,142.59 164.23,142.44 UH1.AJ35 ; v3(131.51,108.18) 131.94,107.75 JCPU1.P33
FDI_CTX_PRX_N1: length 74.1
  IN4 w0.089: 155.73,138.44 157.37,138.44 157.69,138.12 158.74,138.12 159.11,137.74 160.29,137.74 160.42,137.61 162.22,137.61 162.76,138.15 162.76,139.08 162.95,139.26 162.95,141.43 163.17,141.65 163.17,142.09 163.08,142.18 162.89,142.18 162.76,142.05 v3(162.76,141.94) ; 144.99,105.26 144.98,105.26 144.96,105.25 144.9,105.25 143.46,103.81 140.91,103.81 139.89,102.8 134.34,102.8 134.07,103.07 134.07,104.42 133.68,104.81 133.68,106.06 133.13,106.61 132.53,106.61 132.34,106.8 132.34,107.08 v3(132.48,107.23)
  IN4 w0.114: 144.99,105.26 145.34,105.26 145.94,105.86 145.94,112.91 144.75,114.1 144.75,126.84 145.23,127.31 145.23,133.82 150.81,139.4 153.32,139.4 154.29,138.44 155.73,138.44
  BOTTOM w0.089: UH1.AL35 162.85,141.94 v3(162.76,141.94) ; v3(132.48,107.23) 132.94,106.77 JCPU1.N32
FDI_CTX_PRX_P0: length 80.1
  IN4 w0.089: v3(163.74,143.24) 163.86,143.12 164.13,143.12 164.34,142.91 164.34,142.33 164.38,142.3 164.38,141.19 164.06,140.87 163.67,140.87 163.57,140.76 163.57,139.46 164.02,139 164.02,137.86 163.11,136.95 160.19,136.95 160,137.14 159.06,137.14 158.82,136.9 157.67,136.9 156.96,137.61 155.77,137.61 155.76,137.6 155.69,137.6 155.68,137.58 155.67,137.58 ; 146.33,103.85 146.33,103.85 146.33,103.85 146.31,103.83 146.3,103.83 144.04,101.58 133.27,101.58 132.87,101.98 132.87,105.25 132.51,105.6 132.1,105.6 131.85,105.86 131.85,107.16 131.72,107.29 v3(131.5,107.29)
  IN4 w0.114: 146.33,103.85 146.82,104.34 146.82,113.28 145.63,114.47 145.63,125.91 146.1,126.38 146.1,133.45 150.71,138.06 153.56,138.06 154.04,137.58 155.67,137.58
  BOTTOM w0.089: UH1.AJ36 163.93,143.24 v3(163.74,143.24) ; JCPU1.R33 130.95,107.73 131.39,107.29 v3(131.5,107.29)
FDI_CTX_PRX_P1: length 74.1
  IN4 w0.089: 144.99,105.04 144.97,105.04 143.55,103.61 140.99,103.61 139.98,102.59 134.26,102.59 133.87,102.98 133.87,104.33 133.48,104.73 133.48,105.97 133.05,106.4 132.66,106.4 v3(132.49,106.23) ; 155.73,138.21 155.74,138.21 155.76,138.22 155.82,138.22 155.83,138.24 157.28,138.24 157.61,137.91 158.65,137.91 159.03,137.54 160.21,137.54 160.34,137.4 162.31,137.4 162.97,138.06 162.97,138.99 163.15,139.17 163.15,141.34 163.37,141.57 163.37,142.17 163.17,142.38 162.91,142.38 v3(162.76,142.53)
  IN4 w0.114: 155.73,138.21 154.19,138.21 153.23,139.18 150.91,139.18 145.45,133.72 145.45,127.22 144.98,126.74 144.98,114.2 146.17,113.01 146.17,105.77 145.44,105.04 144.99,105.04
  BOTTOM w0.089: UH1.AL36 163.22,142.94 162.81,142.53 v3(162.76,142.53) ; v3(132.49,106.23) 131.99,106.73 JCPU1.P32
FDI_INT: length 66.3
  IN4 w0.089: v3(162.76,144.49) 162.31,144.04 162.31,143.71 162.19,143.59 162.19,141.38 162.31,141.26 162.31,138.94 162.04,138.68 158.38,138.68 158.13,138.93 155.1,138.93 153.9,140.12 153.69,140.12 ; v3(137.47,104.2) 138.04,104.77 143.7,104.77 143.96,105.02
  IN4 w0.102: 153.69,140.12 153.29,140.12 152.6,140.81 149.86,140.81 144.03,134.99 144.03,113.81 144.86,112.98 144.86,105.93 143.96,105.02
  BOTTOM w0.089: UH1.AL40 163.01,144.49 v3(162.76,144.49) ; v3(137.47,104.2) 137,103.73 JCPU1.J29
FDI_IREF: length 9.5
  BOTTOM w0.254: UH1.AT45 161.21,147.02 159.78,148.44 158.72,148.44 158.19,148.97 154.8,148.97 v1(154.26,149.5) 153.74,150.02 RH96.2
FDI_RCOMP: length 9.4
  BOTTOM w0.254: UH1.AR44 161.61,147.09 159.92,148.78 158.86,148.78 157.99,149.66 v1(157.48,149.66) 156.91,149.66 156.82,149.75 155.09,149.75 154.63,150.21 RH99.2
FFS_INT2: length 179.3
  TOP w0.102: Q29.2 81.6,35.61 81.73,35.74 81.73,37.33 82.11,37.71 v3(83.69,37.71) 83.69,38.28 v2(83.63,38.34)
  TOP w0.254: U88.9 v3(85.65,56.68)
  IN1 w0.102: v3(85.65,56.68) 86.62,55.72 86.62,39.55 84.77,37.71 v3(83.69,37.71)
  IN2 w0.127: v3(85.65,56.68) 86.49,56.68 v3(93.38,63.57) ; v3(161.84,126.76) 161.86,126.74 161.86,124.31 161.46,123.9 161.46,121.17 161.87,120.76 161.87,118.87 162.56,118.18 162.56,115.71 163.13,115.14 163.13,113.05 157.29,107.2 157.29,103.71 155.51,101.93 155.51,95.62 v3(153.51,93.62)
  IN3 w0.127: v3(93.38,63.57) 94.02,64.21 107.05,64.21 113.87,57.39 146.45,57.39 157.02,67.96 157.02,77.88 154.5,80.4 154.5,92.64 v3(153.51,93.62)
  BOTTOM w0.089: UH1.AN4 162.43,128.93 162.76,128.6 162.76,128.37 162.48,128.1 162.48,127.35 161.9,126.76 v3(161.84,126.76)
FFS_INT2_Q: length 5.8
  TOP w0.102: R506.2 79.38,35.31 v3(79.38,35.61) ; R506.2 v1(79.77,33.51) ; R506.2 79.82,34.96 Q29.3
  BOTTOM w0.102: JSATA1.18 79.86,35.13 v3(79.38,35.61)
FFS_PCH_INT: length 20.2
  TOP w0.102: v3(170.58,119) 170.08,118.51 RH106.2
  IN2 w0.089: 169.42,126.62 169.42,127.12 169.25,127.28 169.25,128.55 168.85,128.96 168.85,132.9 169.17,133.21 170.65,133.21 v3(171.06,133.62)
  IN2 w0.127: 169.42,126.62 169.42,125.85 171.57,123.7 171.57,122.24 171.71,122.11 171.71,120.13 v3(170.58,119)
  BOTTOM w0.089: UH1.M15 171.06,133.94 v3(171.06,133.62)
  BOTTOM w0.102: v3(170.58,119) v1(170.58,118.29)
FWP#: length 14
  TOP w0.102: v3(206.44,76.83) 205.98,76.37 205.56,76.37 205.49,76.29 U51.B65 ; R872.2 R879.2 199.07,75.3 199.4,74.97 v3(199.4,74.64)
  IN1 w0.102: v3(206.44,76.83) 206,77.27 205.61,77.27 204.97,76.62 204.97,75.59 204.01,74.64 v3(199.4,74.64)
  BOTTOM w0.102: v1(207.16,77.9) 207.16,77.55 v3(206.44,76.83)
GFX_CLK_REQ#: length 225
  TOP w0.102: RPH18.4 203.29,118.16 202.95,117.82 202.95,111.83 v3(203.39,111.38) ; v3(164.78,116.32) 165.23,116.32 165.61,116.7 QH3.1
  IN2 w0.089: 163.74,125 163.76,125.01 163.76,125.03 163.39,125.4 163.39,128.87 164.72,130.2 v3(164.74,130.2)
  IN2 w0.127: v3(60.64,148.57) 60.52,148.44 60.52,141.56 56.59,137.64 56.59,137.61 56.58,137.59 56.58,137.27 54.61,135.3 54.61,134.61 v3(55.5,133.72) ; 163.74,125 163.74,123.36 164.19,122.91 164.19,121.83 163.39,121.03 163.39,117.72 v3(164.78,116.32)
  IN3 w0.127: v3(60.64,148.57) 60.78,148.71 64.58,148.71 68.65,144.64 79.5,144.64 81.43,146.58 81.43,147.41 81.91,147.88 86.16,147.88 86.66,148.38 93.2,148.38 93.3,148.29 103.03,148.29 108.29,153.55 114.94,153.55 115.25,153.86 126.51,153.86 127,153.37 132.75,153.37 134.34,151.78 136.48,151.78 136.91,152.21 138.42,152.21 143.77,146.87 143.77,125.28 147.58,121.47 153.04,121.47 153.84,120.67 159.24,120.67 160.02,119.88 160.02,119.49 160.02,119.28 160.89,118.42 160.97,118.33 162.52,118.33 164.53,116.32 v3(164.78,116.32) 165.33,116.32 166.19,115.46 166.9,115.46 168.43,113.93 173.3,113.93 173.49,113.74 177.43,113.74 178.21,112.97 184.42,112.97 185.38,112 202.77,112 v3(203.39,111.38)
  BOTTOM w0.089: v3(164.74,130.2) 164.97,130.2 UH1.AF6
  BOTTOM w0.102: v1(54.48,134.23) 54.99,133.72 v3(55.5,133.72) 55.69,133.53 55.69,133.47 56.19,132.97 RV52.1
GFX_CLK_REQ#_R: length 7.9
  BOTTOM w0.089: UV1.N7 63.68,131.1 61.93,131.1 61.79,131.24 61.79,131.55 61.47,131.87 61.47,132.2 61.16,132.51 60.27,132.51 59.77,133.01 58.11,133.01
  BOTTOM w0.102: RV52.2 57.21,133.01 v1(58.1,133.01) 58.11,133.01
GFX_MEM_VTT_EN: length 16.5
  TOP w0.102: RV67.2 93.1,94.75 QV2.1 92.71,92.7 v1(91.63,92.7) 89.73,92.7 87.37,90.34 87.37,86.97 86.69,86.3 RV80.1 CV129.1 85.03,86.81 85.03,87.37 85.22,87.56 QV1.4
GPIO_PSID_SELECT: length 84.5
  TOP w0.102: v3(192.67,67.37) 192.67,67.12 v1(192.41,66.86) 192.11,66.56 U46.A6
  TOP w0.254: v3(223.29,119.52) 223.29,120.04 222.58,120.75 PU1.6
  IN2 w0.127: v3(192.67,67.37) 192.75,67.37 193.85,68.47 194.44,68.47 195.89,69.92 195.89,76.03 196.43,76.57 196.43,79.02 196.71,79.3 196.71,83.24 197.66,84.19 197.66,86.91 198.64,87.89 198.64,92.24 202.95,96.54 202.95,100.34 202.63,100.66 202.63,111.03 202.86,111.26 202.86,120.68 v3(203.46,121.28)
  IN3 w0.127: v3(203.46,121.28) 207.52,121.28 208.12,120.68 211.09,120.68 212.58,119.19 214.26,119.19 215.61,120.55 222.26,120.55 v3(223.29,119.52)
GPU_HOT#: length 73
  TOP w0.102: v3(55.44,133.09) 55.7,133.35 57.72,133.35 RV103.2 RV76.2 58.57,132.58 60.4,132.58 CV358.1 63.41,133.15 63.65,133.39 v1(63.9,133.39) 64.99,133.39 v3(65.38,133) ; QV8.1 58.99,147.91 58.99,146.31 v3(58.98,146.29)
  TOP w0.254: v3(19.05,141.53) 19.05,141.02 19.5,140.58 PR633.2
  IN1 w0.254: v3(55.44,133.09) 54.66,133.86 39.17,133.86 33.97,139.06 30.72,139.06 29.71,140.07 24.89,140.07 23.94,141.02 19.56,141.02 v3(19.05,141.53)
  IN2 w0.127: v3(58.98,146.29) 58.98,140.5 56.33,137.85 56.33,137.37 54.29,135.34 54.29,134.29 55.44,133.15 v3(55.44,133.09)
  BOTTOM w0.1: v3(65.38,133) UV1.T9
GPU_JTAG_TCK: length 4.3
  BOTTOM w0.089: v3(59.68,129.27) 60.85,129.27 UV1.L3
  BOTTOM w0.102: RV88.2 58.65,129.02 58.9,129.27 v3(59.68,129.27)
GPU_JTAG_TDI: length 6.9
  BOTTOM w0.089: v3(62.66,128.63) 62.66,129.56 62.42,129.8 UV1.L5 61.88,130.1 61.15,130.1 60.9,129.85 60.9,129.62 60.77,129.49 60.17,129.49
  BOTTOM w0.102: RPV1.3 58.1,130.62 59.03,129.68 59.97,129.68 60.17,129.49
GPU_JTAG_TDO: length 11.2
  TOP w0.102: v3(55.83,127.8) v2(55.23,127.8)
  BOTTOM w0.089: 59.27,128.69 61.47,128.69 UV1.K4
  BOTTOM w0.102: 59.27,128.69 59,128.69 58.73,128.42 57.57,128.42 56.95,127.8 v3(55.83,127.8) 55.5,128.13 55.5,129.1 55.93,129.53 56.77,129.53 57.36,130.12 RPV1.4
GPU_JTAG_TMS: length 3.3
  BOTTOM w0.102: UV1.L1 60.54,129.8 59.67,130.67 v3(59.6,130.67) 58.61,130.67 58.17,131.12 RPV1.2
GPU_JTAG_TRSTB: length 5.9
  BOTTOM w0.089: UV1.L6 62.94,129.8 v3(62.62,130.12) 62.44,130.3 60.66,130.3
  BOTTOM w0.102: RPV1.1 58.37,131.61 58.55,131.44 59.53,131.44 60.66,130.3
GPU_PSI#: length 46.7
  TOP w0.254: v3(21.69,142.7) 21.59,142.8 PR631.1
  IN1 w0.254: v3(21.69,142.7) 23.35,142.7 25.59,140.45 30.01,140.45 31,139.46 34.11,139.46 39.33,134.24 54.74,134.24 v3(55.22,134.72)
  BOTTOM w0.089: 58.11,135.56 58.69,135.56 59.97,134.29 62.67,134.29 UV1.U6
  BOTTOM w0.102: 58.11,135.56 56.07,135.56 v1(55.88,135.37) 55.65,135.14 55.64,135.14 v3(55.22,134.72)
GPU_PWR_LEVEL: length 217.4
  TOP w0.102: v3(184.02,61.06) 183.62,61.46 U46.A52 ; RV76.1 55.83,132.9 54.77,131.84 54.77,126.39 54.87,126.28 54.87,125.31 v1(52.14,122.58) 50.33,120.77 v3(49.95,120.77)
  IN3 w0.127: v3(49.95,120.77) 48.66,119.47 48.66,97.46 53.57,92.55 67.5,92.55 68.19,91.86 77.71,91.86 78.4,92.55 79.39,92.55 83.75,88.19 86.47,88.19 87.87,86.79 87.87,80.76 87.17,80.07 87.17,62.75 90.41,59.51 105.64,59.51 115.31,49.84 150.52,49.84 155.06,54.37 161.8,54.37 162.6,55.17 165.17,55.17 167.05,57.05 175.75,57.05 178.34,59.64 182.65,59.64 183.2,60.19 183.2,60.7 183.56,61.06 v3(184.02,61.06)
GPU_SMBCLK: length 22.9
  TOP w0.102: U51.B49 206.68,82.57 v3(207.15,82.1) ; v3(192.7,78.22) 192.27,78.65 v1(191.54,78.65) 190.5,79.69 190.32,79.69 190.18,79.56 RP14.5
  IN1 w0.102: v3(207.15,82.1) 206.79,82.46 206.79,82.61 205.82,83.58 202.5,83.58 200.41,81.5 197.04,81.5 194.82,79.28 194.82,78.99 193.67,77.84 193.08,77.84 v3(192.7,78.22)
GPU_SMBDAT: length 21.7
  TOP w0.102: v3(207.19,82.68) 207.19,83.38 U51.B48 ; RP14.6 190.16,80.05 190.3,79.92 190.59,79.92 191.5,79.01 192.52,79.01 v3(193.29,78.25)
  IN1 w0.102: v3(193.29,78.25) 193.75,78.25 194.59,79.09 194.59,79.37 196.95,81.73 200.32,81.73 202.4,83.81 205.91,83.81 207.02,82.7 207.05,82.7 207.07,82.68 v3(207.19,82.68)
GPU_THERMAL_INT: length 58.5
  TOP w0.102: RV53.1 92.71,124.83 v3(93.47,124.07)
  IN1 w0.089: 58.11,135.25 58.99,135.25 59.37,134.86 59.37,133.39 58.17,132.18 58.17,128.83 59.12,127.88 60.56,127.88 63.73,124.7 79.06,124.7 79.57,125.21 79.57,126.16 80.01,126.61 82.11,126.61 82.77,125.95 84.2,125.95
  IN1 w0.102: v3(93.47,124.07) 92.01,125.53 87.7,125.53 86.78,126.44 85.68,126.44 85.18,125.95 84.2,125.95 ; v3(56.52,134.74) 57.02,135.25 58.11,135.25
  BOTTOM w0.089: UV1.R6 62.7,133 62.42,133.28 62.3,133.28 62.1,133.47 62.1,133.91 61.91,134.1 59.89,134.1 58.78,135.21 58.11,135.21
  BOTTOM w0.102: 58.11,135.21 v1(57.91,135.21) 57.3,135.21 56.83,134.74 v3(56.52,134.74)
GPU_VID0: length 8.9
  TOP w0.102: PR628.1 15.95,153.6 v1(15.11,154.43)
  TOP w0.203: PU600.32 19.75,150.11 19.12,150.74
  TOP w0.254: PR628.1 16.17,152.45 16.59,152.03 16.59,151.34 16.9,151.03 17.64,151.03 PR610.2 18.29,151.56 19.12,150.74
GPU_VID1: length 5.6
  TOP w0.203: PR608.1 v3(18.81,150.1) 19.15,149.76 20.22,149.76 20.27,149.71 PU600.33
  TOP w0.254: PR625.1 15.95,151.36 16.66,150.65 17.63,150.65 PR608.1
GPU_VID2: length 5.6
  TOP w0.203: PR605.2 18.57,148.96 19.01,149.41 20.12,149.41 20.22,149.31 PU600.34
  TOP w0.254: PR621.1 15.95,149.89 16.32,149.52 v3(16.64,149.52) 17.62,149.52 PR605.2
GPU_VID3: length 5.7
  TOP w0.203: PU600.35 v3(19.83,148.91) 19.16,148.91 18.18,147.92 PR604.1 17.65,148.41 16.41,148.41 15.95,148.87 PR618.1
GPU_VID4: length 6.2
  TOP w0.203: 18.81,147.82 19.43,148.44 20.17,148.44 20.23,148.51 PU600.36
  TOP w0.254: 18.81,147.82 v3(18.81,147.81) 18.81,147.46 PR602.1 17.64,147.36 16.31,147.36 15.95,147.72 PR620.1
GPU_VID_0: length 58.3
  TOP w0.254: v3(14.3,151.02) 14.3,152.07 14.68,152.45 PR628.2
  BOTTOM w0.089: 58.11,132.67 59.73,132.67 60.08,132.32 60.86,132.32 UV1.P2
  BOTTOM w0.102: 58.11,132.67 57.98,132.67 57.75,132.44 54.04,132.44 53.71,132.11 41.99,132.11 34.56,139.54 31.35,139.54 30.22,140.67 27.38,140.67 26.63,141.42 25.86,141.42 22.1,145.18 19.85,145.18 17.45,147.58 17.45,150.03 16.74,150.74 v1(14.8,150.74) 14.52,151.02 v3(14.3,151.02)
GPU_VID_1: length 60.1
  TOP w0.254: v3(13.83,148.96) 13.83,149.82 15.04,151.03 PR625.2
  BOTTOM w0.089: UV1.M4 61.54,130.6 61.03,131.12 61.03,131.44 60.39,132.07 60.06,132.07 59.65,132.48 58.3,132.48 58.11,132.29
  BOTTOM w0.102: v3(13.83,148.96) 14.28,149.41 v1(14.8,149.41) 15.42,149.41 16.36,148.47 16.88,148.47 17.21,148.14 17.21,147.49 19.76,144.95 22.01,144.95 25.77,141.19 26.54,141.19 27.28,140.44 30.13,140.44 31.26,139.31 34.46,139.31 41.89,131.88 53.82,131.88 54.16,132.21 58.03,132.21 58.11,132.29
GPU_VID_2: length 55.4
  TOP w0.254: v3(14.42,148.96) 14.42,149.48 PR621.2
  BOTTOM w0.089: 58.11,131.98 58.26,131.98 58.56,132.29 59.57,132.29 60.46,131.4 UV1.N1
  BOTTOM w0.102: v3(14.42,148.96) v1(15.31,148.07) 15.53,147.84 16,147.84 16.35,147.5 16.88,147.5 19.66,144.72 21.91,144.72 25.67,140.96 26.44,140.96 27.19,140.21 30.03,140.21 31.17,139.08 34.37,139.08 41.8,131.65 53.94,131.65 54.27,131.98 58.11,131.98
GPU_VID_3: length 59.3
  TOP w0.1: v3(64.07,131.82) 63.67,132.22 60.55,132.22 60.41,132.36 56.24,132.36 v3(55.45,131.57)
  TOP w0.254: PR618.2 15.04,148.88 14.35,148.2 v3(14.35,147.95)
  BOTTOM w0.089: UV1.P8 64.58,132.34 v3(64.07,131.82)
  BOTTOM w0.102: v3(14.35,147.95) 14.68,147.61 15.9,147.61 16.24,147.27 16.79,147.27 19.67,144.39 v1(21.07,144.39) 21.92,144.39 25.58,140.73 26.35,140.73 27.09,139.98 29.78,139.98 30.91,138.85 34.27,138.85 41.7,131.42 55.3,131.42 v3(55.45,131.57)
GPU_VID_4: length 70.9
  TOP w0.254: PR620.2 v3(15.04,147.16)
  IN2 w0.127: v3(63.41,131.83) 60.86,131.83 60.44,131.41 59.45,131.41 57.05,129.01 55.97,129.01 54.95,127.99 54.95,125.39 54.6,125.03 v3(53.81,125.03)
  IN4 w0.102: v3(15.04,147.16) 15.37,146.83 15.37,143.79 18.57,140.59 21.11,140.59 21.78,141.26 26.2,141.26 26.93,140.54 28.94,140.54 32.46,144.06 36.44,144.06 37.35,143.14 37.35,140.05 40.31,137.09 41.91,137.09 44.76,134.24 45.52,134.24 46.32,133.44 46.32,132.53 v3(53.81,125.03)
  BOTTOM w0.089: UV1.P7 63.78,132.2 v3(63.41,131.83)
GREEN_CRT: length 151.5
  IN4 w0.102: v3(3.56,178.04) 6.76,178.04 8.07,176.74 18.03,176.74 29.62,165.15 33.3,165.15 34.85,163.6 35.36,163.6 38.46,163.6 48.34,153.72 48.68,153.72 51.95,150.45 57.86,150.45 58.64,149.67 61.52,149.67 64.64,146.55 71.5,146.55 72.07,145.98 79.88,145.98 81.66,147.76 83.05,147.76 83.49,147.33 102.84,147.33 108.96,153.45 114.12,153.45 114.75,154.08 121.78,154.08 122.73,155.03 128.17,155.03 128.6,154.59 v3(128.6,154.39)
  BOTTOM w0.102: U6.25 132.97,155.49 131.92,156.55 131.42,156.55 131.32,156.64 v1(130.11,156.64) 129.89,156.64 128.6,155.36 v3(128.6,154.39) ; v3(3.56,178.04) 3.26,177.75 JIO1.5
