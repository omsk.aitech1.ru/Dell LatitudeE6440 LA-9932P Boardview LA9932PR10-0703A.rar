# Allegro board LA9932PR10-0703A.brd (continued)
## Nets (continued)
GND: C7.2 C18.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C31.2 C32.2 C44.2 C45.2 C46.2 C47.2 C50.2 C51.2 C52.2 C53.2 C106.2 C107.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C246.2 C247.2 C284.2 C288.2 C289.2 C290.2 C296.2 C298.2 C299.2 C300.2 C301.2 C302.2 C306.2 C340.2 C342.2 C344.2 C354.2 C355.2 C356.2 C365.2 C366.2 C369.2 C387.2 C388.2 C395.2 C396.2 C397.2 C398.2 C399.2 C402.2 C423.2 C435.2 C436.2 C437.2 C438.2 C439.2 C443.2 C444.2 C445.2 C446.2 C447.2 C448.2 C449.2 C450.2 C451.2 C452.2 C453.2 C454.2 C455.1 C462.2 C463.2 C464.2 C466.2 C467.2 C468.2 C469.2 C470.1 C471.1 C472.2 C473.2 C474.2 C478.2 C479.2 C480.2 C481.2 C482.2 C483.2 C484.2 C485.1 C550.2 C551.2 C552.2 C553.2 C559.1 C560.1 C561.1 C564.1 C566.1 C572.2 C574.2 C575.2 C576.2 C577.2 C578.2 C580.2 C581.2 C595.2 C603.2 C604.2 C605.2 C606.1 C607.1 C608.2 C610.2 C611.2 C612.2 C613.2 C614.2 C615.2 C616.2 C621.2 C622.2 C623.2 C624.1 C625.1 C626.2 C628.2 C629.2 C630.2 C631.2 C633.2 C634.2 C635.2 C636.2 C637.2 C638.2 C639.2 C640.2 C641.2 C642.2 C643.2 C645.2 C646.2 C649.2 C651.2 C654.2 C675.2 C676.2 C695.2 C696.2 C701.2 C702.2 C703.2 C705.2 C706.2 C707.2 C708.2 C709.2 C710.2 C714.2 C715.2 C716.2 C720.2 C721.2 C722.2 C724.2 C725.2 C727.2 C733.2 C734.2 C735.2 C736.2 C737.2 C739.2 C740.2 C741.2 C742.2 C743.2 C744.2 C746.2 C755.2 C756.2 C757.2 C758.2 C759.2 C764.2 C765.2 C772.2 C773.2 C774.2 C775.2 C776.2 C777.2 C778.2 C779.2 C780.2 C781.2 C782.2 C783.2 C800.1 C802.1 C952.2 C954.2 C958.2 C959.2 C960.2 C961.2 C967.2 C973.2 C974.2 C975.2 C976.2 C977.2 C994.2 C998.2 C1001.2 C1002.2 C1004.2 C1167.2 C1177.2 C1178.2 C1184.2 C1216.2 C1501.1 C1502.1 C1503.1 C1504.1 C1505.1 C1506.1 C1507.1 C1508.1 C1509.1 C1510.1 C1523.2 C1524.2 C1525.2 C1526.2 C1538.2 C1539.2 C1540.2 C1541.2 C1551.2 C1552.2 C1553.2 C1554.2 C1555.2 C1558.2 C1559.2 CC17.2 CC18.2 CC19.2 CC21.2 CC24.2 CC25.2 CC26.2 CC27.2 CC28.2 CC29.2 CC30.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.2 CC42.2 CC43.2 CC44.2 CC45.2 CC46.2 CC47.2 CC48.2 CC137.2 CC138.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CE5.2 CE6.2 CE7.2 CE10.2 CE11.2 CE12.2 CE13.2 CE14.2 CE15.2 CE16.2 CE17.2 CE18.2 CH2.2 CH4.1 CH5.1 CH6.1 CH7.1 CH10.2 CH11.2 CH12.2 CH13.1 CH14.1 CH17.2 CH18.2 CH19.2 CH20.2 CH21.2 CH22.2 CH23.2 CH24.2 CH25.2 CH27.2 CH28.2 CH29.2 CH30.2 CH34.2 CH35.2 CH36.2 CH37.2 CH38.2 CH40.2 CH43.2 CH44.2 CH45.2 CH46.2 CH47.2 CH48.2 CH49.2 CH50.2 CH51.2 CH52.2 CH53.2 CH54.2 CH55.2 CH56.2 CH57.2 CH59.2 CH60.2 CH61.2 CH62.2 CH63.2 CH64.2 CH65.2 CH66.2 CH67.2 CH68.2 CH69.2 CH70.2 CH71.2 CH72.2 CH73.2 CH74.2 CH75.2 CH76.2 CMOS1.1 CV13.2 CV18.2 CV19.2 CV20.2 CV21.2 CV22.2 CV23.2 CV24.2 CV25.2 CV26.2 CV41.2 CV42.2 CV43.2 CV44.2 CV49.2 CV52.2 CV53.2 CV54.2 CV55.2 CV56.2 CV57.2 CV58.2 CV59.2 CV60.2 CV61.2 CV62.2 CV66.2 CV67.2 CV68.2 CV69.2 CV70.2 CV71.2 CV72.2 CV73.2 CV74.2 CV75.2 CV76.2 CV77.2 CV78.2 CV79.2 CV80.2 CV81.2 CV82.2 CV83.2 CV84.2 CV87.2 CV92.2 CV93.2 CV94.2 CV95.2 CV98.2 CV129.2 CV130.2 CV131.2 CV133.2 CV134.2 CV137.2 CV138.2 CV139.2 CV140.2 CV141.2 CV142.2 CV143.2 CV144.2 CV145.2 CV146.2 CV147.2 CV148.2 CV149.2 CV150.2 CV151.2 CV152.2 CV153.2 CV154.2 CV155.2 CV156.2 CV157.2 CV158.2 CV159.2 CV162.2 CV163.2 CV164.2 CV165.2 CV166.2 CV167.2 CV176.2 CV177.2 CV178.2 CV179.2 CV180.2 CV181.2 CV182.2 CV185.2 CV188.2 CV189.2 CV191.2 CV192.2 CV198.2 CV199.2 CV201.2 CV202.2 CV203.2 CV204.2 CV207.2 CV210.2 CV215.2 CV216.2 CV219.2 CV220.2 CV221.2 CV222.2 CV223.2 CV224.2 CV225.2 CV274.2 CV275.2 CV324.2 CV326.2 CV327.2 CV329.2 CV331.2 CV332.2 CV340.2 CV341.2 CV342.2 CV343.2 CV344.2 CV349.2 CV351.2 CV353.2 CV355.2 CV357.2 CV358.2 CV411.2 CV423.2 D1.2 D33.1 D72.1 D78.3 D86.1 D88.3 D89.1 D90.1 D91.3 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H14.1(TP-1) H15.1(TP-1) H16.1(TP-1) H18.1(TP-1) H19.1(TP-1) H22.1(TP-1) H23.1(TP-1) JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.17 JAPS1.18 JCAM1.6 JCAM1.8 JCAM1.9 JCAM1.10 JCPU1.A3 JCPU1.A4 JCPU1.A7 JCPU1.A10 JCPU1.A13 JCPU1.A16 JCPU1.A19 JCPU1.A22 JCPU1.A25 JCPU1.A27 JCPU1.A29 JCPU1.A31 JCPU1.A33 JCPU1.AA11 JCPU1.AA25 JCPU1.AA27 JCPU1.AA29 JCPU1.AA31 JCPU1.AA33 JCPU1.AA35 JCPU1.AB1 JCPU1.AB3 JCPU1.AB4 JCPU1.AB6 JCPU1.AB7 JCPU1.AB9 JCPU1.AB10 JCPU1.AC11 JCPU1.AC25 JCPU1.AC27 JCPU1.AC29 JCPU1.AC31 JCPU1.AC33 JCPU1.AC35 JCPU1.AD7 JCPU1.AD11 JCPU1.AE1 JCPU1.AE3 JCPU1.AE4 JCPU1.AE6 JCPU1.AE7 JCPU1.AE9 JCPU1.AE10 JCPU1.AE25 JCPU1.AE27 JCPU1.AE29 JCPU1.AE31 JCPU1.AE33 JCPU1.AE35 JCPU1.AF6 JCPU1.AF8 JCPU1.AF11 JCPU1.AG6 JCPU1.AG11 JCPU1.AG25 JCPU1.AG27 JCPU1.AG29 JCPU1.AG31 JCPU1.AG33 JCPU1.AG35 JCPU1.AH1 JCPU1.AH2 JCPU1.AH3 JCPU1.AH4 JCPU1.AH5 JCPU1.AH6 JCPU1.AH7 JCPU1.AH8 JCPU1.AH9 JCPU1.AH10 JCPU1.AJ5 JCPU1.AJ11 JCPU1.AK5 JCPU1.AK11 JCPU1.AK25 JCPU1.AK26 JCPU1.AK28 JCPU1.AK29 JCPU1.AK30 JCPU1.AK32 JCPU1.AK34 JCPU1.AL1 JCPU1.AL2 JCPU1.AL3 JCPU1.AL4 JCPU1.AL5 JCPU1.AL6 JCPU1.AL7 JCPU1.AL8 JCPU1.AL9 JCPU1.AL10 JCPU1.AL11 JCPU1.AL12 JCPU1.AL14 JCPU1.AL15 JCPU1.AL17 JCPU1.AL18 JCPU1.AL19 JCPU1.AL20 JCPU1.AL21 JCPU1.AL22 JCPU1.AL23 JCPU1.AL24 JCPU1.AL31 JCPU1.AL32 JCPU1.AM4 JCPU1.AM7 JCPU1.AM10 JCPU1.AM13 JCPU1.AM16 JCPU1.AM19 JCPU1.AM20 JCPU1.AM21 JCPU1.AM22 JCPU1.AM23 JCPU1.AM24 JCPU1.AM25 JCPU1.AM32 JCPU1.AN2 JCPU1.AN4 JCPU1.AN7 JCPU1.AN10 JCPU1.AN13 JCPU1.AN16 JCPU1.AN19 JCPU1.AN21 JCPU1.AN24 JCPU1.AN27 JCPU1.AN30 JCPU1.AN34 JCPU1.AP1 JCPU1.AP4 JCPU1.AP7 JCPU1.AP10 JCPU1.AP13 JCPU1.AP16 JCPU1.AP19 JCPU1.AP27 JCPU1.AP34 JCPU1.AP35 JCPU1.AR2 JCPU1.AR4 JCPU1.AR7 JCPU1.AR10 JCPU1.AR13 JCPU1.AR16 JCPU1.AR19 JCPU1.AR22 JCPU1.AR25 JCPU1.AR26 JCPU1.AR28 JCPU1.AR31 JCPU1.AR34 JCPU1.AT3 JCPU1.AT4 JCPU1.AT7 JCPU1.AT10 JCPU1.AT13 JCPU1.AT16 JCPU1.AT19 JCPU1.AT21 JCPU1.AT24 JCPU1.AT27 JCPU1.AT30 JCPU1.AT32 JCPU1.AT33 JCPU1.AT34 JCPU1.B2 JCPU1.B4 JCPU1.B7 JCPU1.B10 JCPU1.B13 JCPU1.B16 JCPU1.B19 JCPU1.B22 JCPU1.B34 JCPU1.C1 JCPU1.C2 JCPU1.C4 JCPU1.C7 JCPU1.C10 JCPU1.C13 JCPU1.C16 JCPU1.C19 JCPU1.C22 JCPU1.C24 JCPU1.C26 JCPU1.C28 JCPU1.C30 JCPU1.C32 JCPU1.C34 JCPU1.D4 JCPU1.D7 JCPU1.D10 JCPU1.D13 JCPU1.D16 JCPU1.D19 JCPU1.D22 JCPU1.D25 JCPU1.D27 JCPU1.D29 JCPU1.D31 JCPU1.D33 JCPU1.D35 JCPU1.E1 JCPU1.E4 JCPU1.E7 JCPU1.E10 JCPU1.E13 JCPU1.E16 JCPU1.E19 JCPU1.E22 JCPU1.E25 JCPU1.F4 JCPU1.F6 JCPU1.F7 JCPU1.F8 JCPU1.F9 JCPU1.F10 JCPU1.F11 JCPU1.F12 JCPU1.F14 JCPU1.F15 JCPU1.F17 JCPU1.F18 JCPU1.F19 JCPU1.F20 JCPU1.F21 JCPU1.F23 JCPU1.F24 JCPU1.F26 JCPU1.F28 JCPU1.F30 JCPU1.F32 JCPU1.F34 JCPU1.G1 JCPU1.G2 JCPU1.G3 JCPU1.G4 JCPU1.G5 JCPU1.G11 JCPU1.G27 JCPU1.G29 JCPU1.G31 JCPU1.G33 JCPU1.G35 JCPU1.H6 JCPU1.H7 JCPU1.H10 JCPU1.H11 JCPU1.H26 JCPU1.J6 JCPU1.J11 JCPU1.J26 JCPU1.J28 JCPU1.J30 JCPU1.J32 JCPU1.J34 JCPU1.K1 JCPU1.K2 JCPU1.K3 JCPU1.K4 JCPU1.K5 JCPU1.K7 JCPU1.K8 JCPU1.K9 JCPU1.K10 JCPU1.K29 JCPU1.K31 JCPU1.K33 JCPU1.K35 JCPU1.L6 JCPU1.L11 JCPU1.L26 JCPU1.M6 JCPU1.M11 JCPU1.M26 JCPU1.M28 JCPU1.M30 JCPU1.M32 JCPU1.M34 JCPU1.N1 JCPU1.N2 JCPU1.N3 JCPU1.N4 JCPU1.N5 JCPU1.N6 JCPU1.N7 JCPU1.N9 JCPU1.N10 JCPU1.N29 JCPU1.N31 JCPU1.N33 JCPU1.N35 JCPU1.P5 JCPU1.P11 JCPU1.P26 JCPU1.R5 JCPU1.R10 JCPU1.R11 JCPU1.R26 JCPU1.R28 JCPU1.R30 JCPU1.R32 JCPU1.R34 JCPU1.T1 JCPU1.T3 JCPU1.T4 JCPU1.T6 JCPU1.T7 JCPU1.T9 JCPU1.T10 JCPU1.T26 JCPU1.T29 JCPU1.T31 JCPU1.T33 JCPU1.T35 JCPU1.U11 JCPU1.U27 JCPU1.V10 JCPU1.V11 JCPU1.V28 JCPU1.V30 JCPU1.V32 JCPU1.V34 JCPU1.W1 JCPU1.W3 JCPU1.W4 JCPU1.W6 JCPU1.W7 JCPU1.W9 JCPU1.W10 JCPU1.W25 JCPU1.W33 JCPU1.W35 JCPU1.Y11 JDEG2.10 JDEG2.11 JDEG2.12 JDIMM1.2 JDIMM1.3 JDIMM1.8 JDIMM1.9 JDIMM1.11 JDIMM1.13 JDIMM1.14 JDIMM1.19 JDIMM1.20 JDIMM1.25 JDIMM1.26 JDIMM1.28 JDIMM1.31 JDIMM1.32 JDIMM1.37 JDIMM1.38 JDIMM1.43 JDIMM1.44 JDIMM1.46 JDIMM1.48 JDIMM1.49 JDIMM1.54 JDIMM1.55 JDIMM1.60 JDIMM1.61 JDIMM1.63 JDIMM1.65 JDIMM1.66 JDIMM1.71 JDIMM1.72 JDIMM1.127 JDIMM1.128 JDIMM1.133 JDIMM1.134 JDIMM1.136 JDIMM1.138 JDIMM1.139 JDIMM1.144 JDIMM1.145 JDIMM1.150 JDIMM1.151 JDIMM1.153 JDIMM1.155 JDIMM1.156 JDIMM1.161 JDIMM1.162 JDIMM1.167 JDIMM1.168 JDIMM1.170 JDIMM1.172 JDIMM1.173 JDIMM1.178 JDIMM1.179 JDIMM1.184 JDIMM1.185 JDIMM1.187 JDIMM1.189 JDIMM1.190 JDIMM1.195 JDIMM1.196 JDIMM1.205 JDIMM1.206 JDIMM2.2 JDIMM2.3 JDIMM2.8 JDIMM2.9 JDIMM2.11 JDIMM2.13 JDIMM2.14 JDIMM2.19 JDIMM2.20 JDIMM2.25 JDIMM2.26 JDIMM2.28 JDIMM2.31 JDIMM2.32 JDIMM2.37 JDIMM2.38 JDIMM2.43 JDIMM2.44 JDIMM2.46 JDIMM2.48 JDIMM2.49 JDIMM2.54 JDIMM2.55 JDIMM2.60 JDIMM2.61 JDIMM2.63 JDIMM2.65 JDIMM2.66 JDIMM2.71 JDIMM2.72 JDIMM2.127 JDIMM2.128 JDIMM2.133 JDIMM2.134 JDIMM2.136 JDIMM2.138 JDIMM2.139 JDIMM2.144 JDIMM2.145 JDIMM2.150 JDIMM2.151 JDIMM2.153 JDIMM2.155 JDIMM2.156 JDIMM2.161 JDIMM2.162 JDIMM2.167 JDIMM2.168 JDIMM2.170 JDIMM2.172 JDIMM2.173 JDIMM2.178 JDIMM2.179 JDIMM2.184 JDIMM2.185 JDIMM2.187 JDIMM2.189 JDIMM2.190 JDIMM2.195 JDIMM2.196 JDIMM2.205 JDIMM2.206 JDOCK1.1 JDOCK1.7 JDOCK1.8 JDOCK1.13 JDOCK1.14 JDOCK1.19 JDOCK1.20 JDOCK1.25 JDOCK1.26 JDOCK1.31 JDOCK1.32 JDOCK1.37 JDOCK1.38 JDOCK1.43 JDOCK1.44 JDOCK1.47 JDOCK1.49 JDOCK1.50 JDOCK1.51 JDOCK1.52 JDOCK1.55 JDOCK1.57 JDOCK1.58 JDOCK1.61 JDOCK1.63 JDOCK1.64 JDOCK1.69 JDOCK1.70 JDOCK1.75 JDOCK1.76 JDOCK1.81 JDOCK1.82 JDOCK1.87 JDOCK1.88 JDOCK1.91 JDOCK1.93 JDOCK1.94 JDOCK1.95 JDOCK1.96 JDOCK1.101 JDOCK1.102 JDOCK1.107 JDOCK1.108 JDOCK1.113 JDOCK1.114 JDOCK1.119 JDOCK1.120 JDOCK1.123 JDOCK1.125 JDOCK1.126 JDOCK1.131 JDOCK1.132 JDOCK1.137 JDOCK1.138 JDOCK1.145 JDOCK1.152 JDOCK1.153 JDOCK1.154 JDOCK1.155 JDOCK1.156 JDOCK1.157 JDOCK1.158 JDOCK1.159 JDOCK1.160 JDOCK1.161 JDOCK1.162 JDOCK1.163 JDOCK1.164 JEXP1.1 JEXP1.4 JEXP1.7 JEXP1.13 JEXP1.19 JEXP1.20 JEXP1.25 JEXP1.29 JEXP1.30 JEXP1.31 JEXP1.32 JFAN1.4 JFAN1.5 JFAN1.6 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JIO1.1 JIO1.8 JIO1.11 JIO1.27 JIO1.30 JIO1.33 JIO1.36 JIO1.39 JIO1.40 JIO1.41 JIO1.42 JKB1.8 JKB1.10 JKB1.11 JKB1.12 JLED1.6 JLED1.7 JLED1.8 JLOM1.14 JLOM1.15 JLVDS1.11 JLVDS1.12 JLVDS1.13 JLVDS1.14 JLVDS1.17 JLVDS1.24 JLVDS1.27 JLVDS1.41 JLVDS1.42 JLVDS1.43 JLVDS1.44 JMDIA1.6 JMDIA1.7 JMDIA1.8 JMINI1.4 JMINI1.9 JMINI1.15 JMINI1.18 JMINI1.21 JMINI1.26 JMINI1.27 JMINI1.29 JMINI1.34 JMINI1.35 JMINI1.43 JMINI1.50 JMINI1.54 JMINI2.4 JMINI2.9 JMINI2.15 JMINI2.18 JMINI2.21 JMINI2.26 JMINI2.27 JMINI2.29 JMINI2.34 JMINI2.35 JMINI2.43 JMINI2.50 JMINI2.53 JMINI2.54 JMINI3.4 JMINI3.9 JMINI3.15 JMINI3.18 JMINI3.21 JMINI3.26 JMINI3.27 JMINI3.29 JMINI3.34 JMINI3.35 JMINI3.43 JMINI3.50 JMINI3.53 JRTC1.2 JRTC1.3 JRTC1.4 JSATA1.1 JSATA1.4 JSATA1.7 JSATA1.11 JSATA1.13 JSATA1.17 JSATA1.19 JSATA1.23 JSATA1.24 JSATA2.1 JSATA2.4 JSATA2.7 JSATA2.12 JSATA2.13 JSATA2.14 JSATA2.17 JSATA2.20 JSATA2.21 JSATA2.24 JSATA2.32 JSATA2.33 JSD1.3 JSD1.6 JSD1.10 JSD1.13 JSD1.19 JSD1.20 JSD1.21 JSD1.22 JSD1.23 JSD1.24 JSD1.25 JSF1.5 JSF1.6 JSF1.7 JSF1.8 JSIM1.5 JSIM1.10 JSIM1.11 JSIM1.12 JSIM1.13 JSIM1.14 JSIM1.15 JSIM1.16 JSIM1.17 JSIM1.18 JSPI1.17 JSPI1.18 JSPI1.19 JSPI1.20 JSPI1.21 JSPI1.22 JSPK1.5 JSPK1.6 JTAG1.2 JTCH1.6 JTCH1.7 JTCH1.8 JTP1.1 JTP1.9 JTP1.10 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSB3.4 JUSB3.7 JUSB3.10 JUSB3.11 JUSB3.12 JUSB3.13 JUSH1.2 JUSH1.3 JUSH1.17 JUSH1.20 JUSH1.21 JUSH1.22 JXDP1.3 JXDP1.6 JXDP1.9 JXDP1.19 JXDP1.25 JXDP1.27 JXDP1.28 JXDP2.1 JXDP2.2 JXDP2.7 JXDP2.8 JXDP2.13 JXDP2.14 JXDP2.19 JXDP2.20 JXDP2.25 JXDP2.26 JXDP2.31 JXDP2.32 JXDP2.37 JXDP2.38 JXDP2.49 JXDP2.50 JXDP2.59 JXDP2.60 ME1.1 PBATT1.1 PBATT1.2 PBATT1.4 PBATT1.10 PBATT1.11 PC3.2 PC5.2 PC12.2 PC13.2 PC14.2 PC17.2 PC101.2 PC102.2 PC103.2 PC105.2 PC106.2 PC109.2 PC110.2 PC114.1 PC117.2 PC118.2 PC120.2 PC201.2 PC202.2 PC203.2 PC205.2 PC207.2 PC208.2 PC209.2 PC210.2 PC213.2 PC214.2 PC215.2 PC216.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.2 PC307.2 PC308.2 PC310.2 PC400.2 PC401.2 PC403.2 PC404.2 PC405.2 PC406.2 PC500.1 PC509.1 PC510.2 PC511.2 PC512.2 PC513.2 PC514.2 PC515.2 PC516.2 PC518.2 PC525.1 PC526.1 PC527.1 PC530.2 PC531.2 PC532.2 PC533.2 PC534.2 PC535.2 PC536.2 PC541.1 PC546.1 PC547.2 PC548.1 PC600.1 PC601.2 PC602.2 PC603.2 PC604.2 PC606.2 PC608.2 PC610.2 PC619.2 PC621.2 PC622.2 PC628.2 PC629.2 PC660.2 PC661.2 PC662.2 PC663.2 PC664.2 PC665.2 PC666.2 PC669.2 PC670.2 PC672.2 PC674.2 PC675.2 PC677.2 PC680.2 PC706.2 PC707.2 PC710.2 PC712.2 PC713.2 PC714.2 PC717.2 PC718.2 PC719.2 PC720.2 PC724.2 PC725.2 PC726.2 PC727.2 PC728.2 PC729.2 PC730.2 PC731.2 PC732.2 PC733.1 PC734.2 PC735.2 PC736.2 PC737.2 PC738.2 PC739.2 PC801.1 PC805.1 PC808.1 PC810.1 PC811.2 PC812.1 PC813.2 PC814.1 PC815.2 PC816.2 PC817.2 PC818.2 PC819.2 PC820.2 PC900.2 PC901.2 PC902.2 PC903.2 PC904.2 PC905.2 PC906.2 PC907.2 PC908.2 PC909.2 PC910.2 PC911.2 PC912.2 PC913.2 PC914.2 PC916.2 PC917.2 PC918.2 PC919.2 PC920.2 PC921.2 PC922.2 PC923.2 PC924.2 PC925.2 PC926.2 PC927.2 PC928.2 PC929.2 PC930.2 PC931.2 PC932.2 PC933.2 PC934.2 PC935.2 PC936.2 PC937.2 PC938.2 PC939.2 PC940.2 PC941.2 PC942.2 PC943.2 PC944.2 PC945.2 PC946.2 PC947.2 PC948.2 PC949.2 PC950.2 PC951.2 PC963.2 PC964.2 PC965.2 PC966.2 PC970.2 PC971.2 PC972.2 PD2.1 PD4.1 PH500.2 PJP1.2 PJP62.2 PJP602.2 PJP701.2 PQ2.3 PQ6.6 PQ103.1 PQ103.2 PQ103.3 PQ104.1 PQ104.2 PQ104.3 PQ203.1 PQ203.2 PQ203.3 PQ303.1 PQ303.2 PQ303.3 PQ508.1 PQ508.2 PQ508.3 PQ512.1 PQ512.2 PQ512.3 PQ600.8 PQ601.8 PQ610.3 PQ706.1 PQ706.2 PQ706.3 PQ707.1 PQ707.4 PQ709.3 PQ710.3 PQ711.1 PQ711.2 PQ711.3 PQ802.3 PQ805.1 PQ805.4 PQ806.1 PQ806.4 PQ807.1 PQ807.4 PQ812.4 PQ813.1 PQ813.4 PQ816.3 PQ817.3 PQ818.3 PQ819.1 PQ819.4 PQ821.1 PQ821.4 PQ824.1 PQ824.4 PQ825.3 PQ827.3 PQ829.3 PQ831.3 PR15.1 PR20.2 PR22.2 PR25.2 PR102.1 PR104.1 PR105.2 PR106.2 PR109.2 PR111.1 PR112.2 PR202.2 PR207.1 PR302.1 PR304.2 PR305.2 PR307.1 PR401.2 PR405.2 PR507.1 PR509.1 PR512.1 PR521.2 PR528.2 PR529.1 PR541.2 PR554.2 PR558.2 PR605.1 PR610.1 PR612.1 PR615.2 PR616.1 PR622.2 PR653.2 PR657.1 PR680.2 PR684.2 PR689.2 PR721.1 PR731.2 PR738.2 PR739.2 PR740.2 PR814.1 PR817.2 PR844.2 PR858.2 PR874.2 PU1.2 PU100.21 PU200.1 PU200.3 PU200.14 PU200.21 PU300.11 PU400.11 PU500.33 PU600.22 PU600.27 PU602.11 PU603.1 PU603.9 PU700.14 PU701.4 PU703.1 PU703.2 PU704.3 PU800.5 PU800.14 PU800.23 PU800.32 PU800.37 PU801.3 PU804.3 PU805.3 PU806.3 PU807.3 PU808.3 Q22.3 Q24.3 Q29.1 Q29.4 Q45.3 Q47.3 Q48.3 Q52.1 Q52.4 Q59.3 Q70.3 Q71.3 Q72.3 Q76.1 Q123.1 Q331.1 Q331.4 QC1.3 QC3.3 QH3.3 QV2.3 QV3.3 QV6.3 QV7.3 QV11.3 R5.2 R6.2 R15.2 R75.2 R76.2 R81.2 R82.2 R87.2 R88.2 R100.1 R101.1 R104.2 R106.1 R108.1 R114.1 R152.1 R407.2 R424.1 R491.1 R492.1 R512.2 R557.2 R561.2 R562.2 R657.2 R677.1 R726.2 R733.2 R757.2 R758.2 R793.2 R803.2 R804.2 R812.1 R836.2 R843.1 R879.1 R931.2 R938.2 R1069.2 R1137.2 R1138.2 R1139.2 R1141.2 R1142.2 R1154.1 R1611.2 R1636.1 R1640.2 R1702.2 R3737.2 R3884.2 RC16.2 RC56.2 RC58.2 RC59.1 RC61.2 RC62.1 RC63.2 RC67.2 RC68.2 RC75.2 RC76.2 RC77.2 RC78.2 RC79.2 RC80.2 RC81.2 RC82.2 RC83.2 RC89.2 RC94.2 RC100.2 RC108.2 RC109.2 RC110.2 RD6.1 RD7.1 RD11.2 RD16.2 RD18.2 RD21.2 RD24.2 RD27.2 RD28.2 RD30.2 RH47.2 RH53.1 RH54.2 RH55.2 RH56.2 RH70.2 RH76.2 RH81.1 RH97.1 RH118.1 RH119.2 RH120.1 RH146.2 RH176.2 RH187.2 RH223.2 RH226.2 RH227.2 RH230.2 RH231.2 RH332.1 RP5.8 RP6.5 RP6.6 RP6.7 RP6.8 RP9.2 RP9.3 RP9.4 RP16.5 RP17.3 RP17.4 RP18.4 RP19.5 RP19.6 RP20.4 RPH5.5 RPH5.6 RPH5.7 RPH5.8 RPH15.5 RPH17.1 RPH17.2 RPH17.3 RPH19.5 RPH19.6 RPH20.1 RPH20.2 RV25.1 RV36.1 RV45.2 RV46.2 RV48.1 RV49.2 RV60.1 RV61.1 RV80.2 RV82.1 RV88.1 RV104.1 RV107.1 RV108.1 RV110.2 RV111.1 RV117.1 RV118.1 RV120.2 RV128.2 RV131.2 RV146.2 RV147.2 RV180.1 RV181.2 RV184.2 RV186.2 RV192.2 RV194.2 RV196.2 RV198.2 RV205.2 RV238.2 RV240.2 RV242.2 RV243.2 SW1.1 SW1.3 T72.1(TP-1) U2.9 U6.3 U6.11 U6.28 U6.31 U6.33 U8.2 U9.3 U15.3 U19.8 U19.15 U19.35 U19.41 U20.7 U21.3 U23.7 U24.3 U27.6 U27.49 U31.49 U32.43 U36.11 U36.15 U37.11 U37.15 U38.49 U39.1 U39.2 U39.3 U39.4 U39.8 U39.11 U39.18 U39.25 U41.7 U41.21 U46.B27 U46.C1 U48.1 U50.3 U51.B11 U51.B18 U51.B54 U51.B60 U51.B66 U51.C1 U52.4 U53.4 U54.3 U56.3 U57.11 U57.15 U58.3 U74.7 U74.42 U74.49 U88.5 U88.10 U88.12 U88.13 U88.15 U88.16 U89.2 U91.1 U93.1 U145.11 U145.15 U146.11 U146.15 U148.2 UC1.3 UC2.3 UC3.3 UH1.A2 UH1.A4 UH1.A5 UH1.A41 UH1.A43 UH1.A44 UH1.AA4 UH1.AA16 UH1.AA20 UH1.AA22 UH1.AA28 UH1.AB8 UH1.AB12 UH1.AB34 UH1.AB38 UH1.AC2 UH1.AC44 UH1.AD6 UH1.AD8 UH1.AD14 UH1.AD16 UH1.AD18 UH1.AD30 UH1.AD32 UH1.AD40 UH1.AE16 UH1.AE28 UH1.AF8 UH1.AF38 UH1.AG2 UH1.AG16 UH1.AG26 UH1.AG28 UH1.AG44 UH1.AJ6 UH1.AJ8 UH1.AJ16 UH1.AJ18 UH1.AJ20 UH1.AJ22 UH1.AJ24 UH1.AJ34 UH1.AJ38 UH1.AK14 UH1.AK16 UH1.AK24 UH1.AK43 UH1.AK45 UH1.AL2 UH1.AL8 UH1.AL12 UH1.AL34 UH1.AL38 UH1.AM14 UH1.AM16 UH1.AM24 UH1.AM26 UH1.AM28 UH1.AM30 UH1.AM32 UH1.AN8 UH1.AN36 UH1.AN40 UH1.AN42 UH1.AP13 UH1.AP24 UH1.AP31 UH1.AP43 UH1.AR2 UH1.AT10 UH1.AT15 UH1.AT17 UH1.AT20 UH1.AT26 UH1.AT29 UH1.AT36 UH1.AT38 UH1.AT43 UH1.AV6 UH1.AV7 UH1.AV13 UH1.AV22 UH1.AV24 UH1.AV31 UH1.AV33 UH1.AV40 UH1.AW2 UH1.AY7 UH1.AY10 UH1.AY15 UH1.AY20 UH1.AY26 UH1.AY29 UH1.AY36 UH1.B1 UH1.B2 UH1.B7 UH1.B11 UH1.B15 UH1.B19 UH1.B23 UH1.B27 UH1.B31 UH1.B35 UH1.B39 UH1.B44 UH1.B45 UH1.BA1 UH1.BA40 UH1.BB25 UH1.BB42 UH1.BC1 UH1.BC16 UH1.BC22 UH1.BC28 UH1.BD1 UH1.BD2 UH1.BD7 UH1.BD11 UH1.BD15 UH1.BD19 UH1.BD31 UH1.BD35 UH1.BD39 UH1.BD44 UH1.BD45 UH1.BE2 UH1.BE3 UH1.BE5 UH1.BE41 UH1.C45 UH1.D1 UH1.D4 UH1.D25 UH1.D42 UH1.E1 UH1.E45 UH1.F15 UH1.F20 UH1.F29 UH1.F33 UH1.F43 UH1.G2 UH1.G8 UH1.G38 UH1.G44 UH1.H7 UH1.H10 UH1.H13 UH1.H17 UH1.H22 UH1.H24 UH1.H26 UH1.H31 UH1.H36 UH1.H40 UH1.K10 UH1.K15 UH1.K20 UH1.K29 UH1.K33 UH1.K39 UH1.L2 UH1.L44 UH1.M17 UH1.M22 UH1.M24 UH1.N6 UH1.N10 UH1.N12 UH1.N35 UH1.N39 UH1.P22 UH1.P24 UH1.P26 UH1.P28 UH1.P30 UH1.P32 UH1.P43 UH1.R2 UH1.R8 UH1.R12 UH1.R14 UH1.R16 UH1.R34 UH1.R38 UH1.R44 UH1.T43 UH1.U6 UH1.U10 UH1.U16 UH1.U28 UH1.U34 UH1.U38 UH1.U39 UH1.U42 UH1.V14 UH1.V16 UH1.V26 UH1.V43 UH1.W2 UH1.W44 UH1.Y8 UH1.Y14 UH1.Y16 UH1.Y24 UH1.Y28 UH1.Y34 UH1.Y36 UH1.Y40 UH2.3 UH3.3 UV1.A3 UV1.A30 UV1.AA1 UV1.AA11 UV1.AA13 UV1.AA16 UV1.AA27 UV1.AB6 UV1.AB10 UV1.AB15 UV1.AB24 UV1.AB32 UV1.AC9 UV1.AC17 UV1.AC24 UV1.AC26 UV1.AC27 UV1.AD6 UV1.AD8 UV1.AD25 UV1.AD32 UV1.AE7 UV1.AE14 UV1.AE27 UV1.AF32 UV1.AG12 UV1.AG25 UV1.AG27 UV1.AH10 UV1.AH28 UV1.AH32 UV1.AJ25 UV1.AK26 UV1.B6 UV1.B8 UV1.B10 UV1.B12 UV1.B14 UV1.B16 UV1.B18 UV1.B20 UV1.B22 UV1.B24 UV1.B26 UV1.C1 UV1.C32 UV1.E28 UV1.F2 UV1.F6 UV1.F8 UV1.F10 UV1.F12 UV1.F14 UV1.F16 UV1.F18 UV1.F20 UV1.F22 UV1.F24 UV1.F26 UV1.G8 UV1.G10 UV1.G27 UV1.G31 UV1.H2 UV1.H6 UV1.H14 UV1.H17 UV1.H20 UV1.J7 UV1.J27 UV1.J31 UV1.K2 UV1.K6 UV1.K11 UV1.K22 UV1.K28 UV1.K32 UV1.L27 UV1.M6 UV1.M12 UV1.M32 UV1.N11 UV1.N13 UV1.N16 UV1.N18 UV1.N21 UV1.N25 UV1.N27 UV1.P6 UV1.P9 UV1.P25 UV1.P32 UV1.R11 UV1.R12 UV1.R15 UV1.R17 UV1.R20 UV1.R27 UV1.T6 UV1.T11 UV1.T13 UV1.T16 UV1.T18 UV1.T21 UV1.T25 UV1.T32 UV1.U1 UV1.U3 UV1.U9 UV1.U15 UV1.U17 UV1.U20 UV1.U25 UV1.U27 UV1.V6 UV1.V11 UV1.V13 UV1.V16 UV1.V18 UV1.V32 UV1.W1 UV1.W25 UV1.W26 UV1.W27 UV1.Y6 UV1.Y10 UV1.Y15 UV1.Y17 UV1.Y20 UV1.Y25 UV1.Y32 UV3.A1 UV3.A3 UV3.A12 UV3.A14 UV3.B5 UV3.B10 UV3.C1 UV3.C3 UV3.C4 UV3.C11 UV3.C12 UV3.C13 UV3.C14 UV3.D10 UV3.E1 UV3.E3 UV3.E12 UV3.E14 UV3.F5 UV3.F10 UV3.G5 UV3.G10 UV3.H1 UV3.H2 UV3.H13 UV3.H14 UV3.J10 UV3.K1 UV3.K2 UV3.K13 UV3.K14 UV3.L5 UV3.L10 UV3.M5 UV3.M10 UV3.N1 UV3.N3 UV3.N12 UV3.N14 UV3.P10 UV3.R1 UV3.R3 UV3.R4 UV3.R11 UV3.R12 UV3.R14 UV3.T5 UV3.T10 UV3.U1 UV3.U3 UV3.U12 UV3.U14 UV4.A1 UV4.A3 UV4.A12 UV4.A14 UV4.B5 UV4.B10 UV4.C1 UV4.C3 UV4.C4 UV4.C11 UV4.C12 UV4.C13 UV4.C14 UV4.D10 UV4.E1 UV4.E3 UV4.E12 UV4.E14 UV4.F5 UV4.F10 UV4.G5 UV4.G10 UV4.H1 UV4.H2 UV4.H13 UV4.H14 UV4.J1 UV4.J10 UV4.K1 UV4.K2 UV4.K13 UV4.K14 UV4.L5 UV4.L10 UV4.M5 UV4.M10 UV4.N1 UV4.N3 UV4.N12 UV4.N14 UV4.P10 UV4.R1 UV4.R3 UV4.R4 UV4.R11 UV4.R12 UV4.R14 UV4.T5 UV4.T10 UV4.U1 UV4.U3 UV4.U12 UV4.U14 UV5.A1 UV5.A3 UV5.A12 UV5.A14 UV5.B5 UV5.B10 UV5.C1 UV5.C3 UV5.C4 UV5.C11 UV5.C12 UV5.C13 UV5.C14 UV5.D10 UV5.E1 UV5.E3 UV5.E12 UV5.E14 UV5.F5 UV5.F10 UV5.G5 UV5.G10 UV5.H1 UV5.H2 UV5.H13 UV5.H14 UV5.J10 UV5.K1 UV5.K2 UV5.K13 UV5.K14 UV5.L5 UV5.L10 UV5.M5 UV5.M10 UV5.N1 UV5.N3 UV5.N12 UV5.N14 UV5.P10 UV5.R1 UV5.R3 UV5.R4 UV5.R11 UV5.R12 UV5.R14 UV5.T5 UV5.T10 UV5.U1 UV5.U3 UV5.U12 UV5.U14 UV6.A1 UV6.A3 UV6.A12 UV6.A14 UV6.B5 UV6.B10 UV6.C1 UV6.C3 UV6.C4 UV6.C11 UV6.C12 UV6.C13 UV6.C14 UV6.D10 UV6.E1 UV6.E3 UV6.E12 UV6.E14 UV6.F5 UV6.F10 UV6.G5 UV6.G10 UV6.H1 UV6.H2 UV6.H13 UV6.H14 UV6.J1 UV6.J10 UV6.K1 UV6.K2 UV6.K13 UV6.K14 UV6.L5 UV6.L10 UV6.M5 UV6.M10 UV6.N1 UV6.N3 UV6.N12 UV6.N14 UV6.P10 UV6.R1 UV6.R3 UV6.R4 UV6.R11 UV6.R12 UV6.R14 UV6.T5 UV6.T10 UV6.U1 UV6.U3 UV6.U12 UV6.U14 UV14.3 Y3.2 Y3.4 YH2.2 YH2.4 YV1.2 YV1.4
GND_CHASSIS: C485.2 R571.2 R572.2 R573.2 R574.2
GNDA: C955.2 C956.2 C957.2 C963.2 C965.1 C968.2 C969.2 C972.2 C1107.2 C1214.2 C1247.2 C1556.2 C1557.2 D81.1 D82.1 JHP1.7 JHP1.8 PJP62.1 Q106.1 Q106.4 Q324.3 Q330.1 Q330.4 R5.1 R6.1 R15.1 R1088.2 R1642.2 R1676.2 U74.26 U74.36
GNDA_CHG: PC703.1 PC705.2 PC708.1 PC716.1 PC721.1 PC723.2 PJP701.1 PR714.2 PR743.2 PU700.21
GNDA_GPU_CORE: PC617.2 PC618.2 PC624.2 PC630.1 PC632.2 PJP602.1 PR632.2 PR634.2 PR644.2 PU600.41
VCCPWRGOOD_0_R: JCPU1.AL34 RC33.2 RC56.1
VCCSENSE: PC520.1 PC541.2 PC545.1 PR537.1 RC91.2 RC92.2
VCCSENSE_R: JCPU1.AL35 RC92.1
VDD_1.35V: PC210.1 PR201.1 PR203.2 PU200.11
VDDP_1.35V: PC213.1 PR211.2 PU200.12
VSSSENSE: PC545.2 PC546.2 PU500.13 RC93.2 RC94.1
VSSSENSE_R: JCPU1.AK35 RC93.1
3301_DSCHRG_FET_GC: PR821.2 PU800.29
3301_PWRSRC: PC819.1 PR877.1 PU800.15
+ALC3226_CPVEE: C965.2 U74.34
+ALC3226_LDO_CAP: C963.1 U74.21
+ALC3226_VREF: C1107.1 C1214.1 U74.25
+BATT_SUM: PD800.2 PD800.3 PD806.1 PQ800.5 PQ800.6 PQ800.7 PQ800.8 PQ809.1 PQ809.2 PQ809.3 PQ815.5 PQ815.6 PQ815.7 PQ815.8 PR813.2
+BL_PWR_SRC: C246.1 C247.1 C296.1 JLVDS1.5 JLVDS1.6 JLVDS1.7 Q21.1 Q21.2 Q21.5 Q21.6
+CAMERA_VDD: C299.1 C300.1 JCAM1.4 Q23.1
+CAP_LDO: C714.1 U46.B46
+COINCELL: JRTC1.1 PR1.1
+DC_IN: PC8.2 PC14.1 PL5.2 PQ4.1 PQ4.2 PQ4.3 PQ6.3 PR18.1 PR22.1 PR732.1 PR835.1
+DC_IN_SS: PC13.1 PD700.2 PD701.3 PQ4.5 PQ4.6 PQ4.7 PQ4.8 PQ700.5 PQ700.6 PQ700.7 PQ700.8 PQ822.3 PR20.1 PR831.1 PR840.2
+DCIN: PC707.1 PR742.2 PU700.20
+DCIN_JACK: PC12.1 PJPDC1.1 PJPDC1.2 PL5.1
+DDR_CHG: Q72.1 R927.2
+DIMM1_VREF_CA: CD15.1 CD16.1 JDIMM1.126 RD5.2 RD13.2
+DIMM1_VREF_DQ: CD1.1 CD2.1 JDIMM1.1 RD1.2 RD3.2
+DIMM2_VREF_CA: CD37.1 CD38.1 JDIMM2.126 RD10.2 RD23.2
+DIMM2_VREF_DQ: CD23.1 CD24.1 JDIMM2.1 RD8.2 RD9.2
+DOCK_PWR_BAR: C702.1 C703.1 CE6.1 D33.2 D33.3 JDOCK1.146 JDOCK1.147 JDOCK1.148 JDOCK1.149 JDOCK1.150 JDOCK1.151 PD701.2 PD808.2 PD808.3 PQ810.5 PQ810.6 PQ810.7 PQ810.8 PQ826.5 PQ826.6 PQ826.7 PQ826.8 PR814.2 PR832.2
+GPU_CORE: CV78.1 CV79.1 CV80.1 CV81.1 CV82.1 CV83.1 CV84.1 PC606.1 PC628.1 PC629.1 PC677.1 PC927.1 PC928.1 PC929.1 PC930.1 PC931.1 PC932.1 PC933.1 PC934.1 PC944.1 PC945.1 PC946.1 PC947.1 PC948.1 PC949.1 PC950.1 PC951.1 PC963.1 PC964.1 PC965.1 PC966.1 PC970.1 PC971.1 PC972.1 PL600.1 PL601.1 PR624.1 PR626.2 PR650.1 PR654.1 PR656.2 UV1.AA12 UV1.AA15 UV1.M11 UV1.M13 UV1.M15 UV1.M16 UV1.M17 UV1.M18 UV1.M20 UV1.M21 UV1.N12 UV1.N15 UV1.N17 UV1.N20 UV1.R13 UV1.R16 UV1.R18 UV1.T12 UV1.T15 UV1.T17 UV1.T20 UV1.U11 UV1.U13 UV1.U16 UV1.U18 UV1.V15 UV1.V17 UV1.V20 UV1.V21 UV1.Y13 UV1.Y16 UV1.Y18 UV1.Y21
+LCDVDD: C298.1 C455.2 C727.1 JLVDS1.38 JLVDS1.39 U56.5 U148.1
+LOM_VCT: C701.1 JDOCK1.116 JDOCK1.118
+NBDOCK_DC_IN_SS: JDOCK1.41 PQ801.1 PQ814.3 PQ823.1 PR827.2
+PBATT: PL2.2 PL3.2 PQ811.1 PQ811.2 PQ811.3 PQ830.3 PR833.2 PR838.2
+PBATT_C: PBATT1.8 PBATT1.9 PC5.1 PL2.1 PL3.1
+PBATT_IN_SS: PD806.2 PD806.3 PD807.2 PQ809.5 PQ809.6 PQ809.7 PQ809.8 PQ811.5 PQ811.6 PQ811.7 PQ811.8 PR817.1
+PCH_DCPRTC: CH54.1 UH1.P14 UH1.P16
+PCH_VCC: CH63.1 CH64.1 RH246.2 UH1.AP45
+PCH_VCCCFUSE: CH66.1 RH242.2 UH1.P18 UH1.P20
+PCH_VCCCLK: CH67.1 CH68.1 CH69.1 CH70.1 CH71.1 RH244.2 UH1.AA30 UH1.AA32 UH1.AD34 UH1.AD35 UH1.AD36 UH1.AE30 UH1.AE32 UH1.AG30 UH1.AG32 UH1.Y32
+PCH_VCCCLK3_3: CH72.1 CH73.1 CH74.1 CH75.1 RH245.2 UH1.L26 UH1.L29 UH1.M26 UH1.M29 UH1.U32 UH1.V32
+PCH_VCCDSW: RH232.2 UH1.U14
+PCH_VCCDSW3_3: CC19.1 CH44.1 JAPS1.3 R566.2 RC5.1 RC12.1 RH80.1 RH92.1 RH112.1 RH216.2 RH237.2 RH238.2 RP17.2 RPH21.1 UC1.5 UH1.A16
+PCH_VCCDSW_R: CH40.1 RH232.1
+PCH_VCCSST: CH46.1 UH1.AA14
+PECI_VREF: C740.1 R866.1 U51.B51
+PWR_SRC: C297.1 PC731.1 PC732.1 PC737.1 PC738.1 PC739.1 PJP200.2 PJP300.1 PJP500.2 PJP600.1 PL103.2 PL504.2 PL602.2 PL700.1 PR716.4 Q21.4 R422.1 R930.1 RV67.1
+PWR_SRC_AC: PC724.1 PC728.1 PC807.1 PD808.1 PJP700.1 PL701.2 PQ810.1 PQ810.2 PQ810.3 PR701.1 PR877.2
+RSVD_VCC3P3_1: R553.2 U31.1
+RTC_CELL: CH55.1 CH56.1 CH57.1 PC3.1 PD3.1 R830.1 R1703.1 RH5.1 RH42.1 RH43.1 RH44.1 RH67.2 RP15.5 RP15.6 RP15.7 RP15.8 UH1.A6
+RTC_CELL_VBAT: C724.1 R830.2 U51.B64
+SA_DIMM1_VREFDQ: RD1.1 RD17.2 RD18.1 RD19.2
+SA_DIMM_VREFDQ: JCPU1.F16 QD6.1 RD26.1 RD27.1
+SA_DIMM_VREFDQ_Q: CD47.1 QD6.6 RD17.1 RD26.2
+SB_DIMM2_VREFDQ: RD8.1 RD14.2 RD15.2 RD16.1
+SB_DIMM_VREFDQ: JCPU1.F13 QD6.4 RD30.1 RD31.2
+SB_DIMM_VREFDQ_Q: CD46.1 QD6.3 RD14.1 RD31.1
+SDC_IN: PC700.1 PC720.1 PD700.1 PQ700.1 PQ700.2 PQ700.3 PR701.4 PR713.2 PR854.1 PU700.3 PU703.3
+SIM_PWR: C616.1 C636.1 C639.1 JMINI1.8 JSIM1.1
+SM_VREF: JCPU1.AM3 QD7.3 RD28.1 RD29.1
+SM_VREF_DIMM: RD13.1 RD20.2 RD21.1 RD22.2 RD23.1
+SM_VREF_Q: CD48.1 QD7.1 RD20.1 RD29.2
+SW_LX: R3883.2 U27.17
+SWR_V12: C109.1 C110.1 C111.1 C112.1 R3883.1 U27.11 U27.15 U27.43
+TRM_CT1: C479.1 T156.3
+TRM_CT2: C480.1 T156.4
+TRM_CT3: C483.1 T156.9
+TRM_CT4: C484.1 T156.10
+TSVDD: CV92.1 CV93.1 CV98.1 LV16.2 UV1.AD17
+UIM_VPP: C628.1 JMINI1.16 JSIM1.6
+UTLGND: R104.1 U27.16
+V_DDR_REF: PC209.1 PU200.4 RD3.1 RD5.1 RD9.1 RD10.1
+VCHGR: PC717.1 PC718.1 PC719.1 PD800.1 PQ800.1 PQ800.2 PQ800.3 PR716.1
+VCOMP_OUT: JCPU1.F22 RC1.1 RC73.1
+VDISPLAY_VCC: C46.1 C47.1 JHDMI1.18 R69.1 R70.1 U89.3
+VGA_B+: PC601.1 PC602.1 PC603.1 PC604.1 PC619.1 PC621.1 PC622.1 PJP600.2 PL602.1 PQ600.1 PQ601.1 PR643.2
+VGA_PCIE: CV69.1 CV70.1 CV71.1 CV72.1 CV73.1 CV74.1 CV75.1 CV76.1 CV77.1 CV199.1 CV202.1 CV204.1 LV21.2 PJP610.1 RV296.2 RV298.2 UV1.AD14 UV1.L23 UV1.L24 UV1.L25 UV1.L26 UV1.M22 UV1.N22 UV1.N23 UV1.N24 UV1.R21 UV1.R22 UV1.T22 UV1.U21 UV1.U22 UV1.V22
+VGA_PCIE_SPLL_VDDC: CV223.1 CV224.1 CV225.1 LV21.1 UV1.H8
+VGA_PCIEP: PC661.1 PC662.1 PC663.1 PC664.1 PC668.1 PJP610.2 PL603.2 PR683.1
+VR_CAP: C779.1 U51.B12
+VREFC1: CV208.2 CV326.1 RV110.1 RV139.2 UV4.J14
+VREFC2: CV328.2 CV329.1 RV183.2 RV184.1 UV5.J14
+VREFC3: CV349.1 CV350.2 RV193.2 RV194.1 UV3.J14
+VREFC4: CV353.1 CV354.2 RV197.2 RV198.1 UV6.J14
+VREFD1_1: CV207.1 CV322.2 RV109.2 RV128.1 UV4.A10
+VREFD1_2: CV323.2 CV324.1 RV129.2 RV131.1 UV4.U10
+VREFD2_1: CV325.2 CV327.1 RV140.2 RV181.1 UV5.A10
+VREFD2_2: CV330.2 CV331.1 RV185.2 RV186.1 UV5.U10
+VREFD3_1: CV209.2 CV210.1 RV119.2 RV120.1 UV3.A10
+VREFD3_2: CV332.1 CV333.2 RV191.2 RV192.1 UV3.U10
+VREFD4_1: CV351.1 CV352.2 RV195.2 RV196.1 UV6.A10
+VREFD4_2: CV355.1 CV356.2 RV203.2 RV205.1 UV6.U10
+VREFOUT: R1145.2 R1146.2 U74.23
-DCIN_JACK: PJP1.1 PJPDC1.3 PJPDC1.4
A_ON: PR308.1 R424.2 U36.3 U51.B24
AC_DIS: PQ6.5 PR828.1 U46.B12
AC_PRESENT: RP17.7 U51.A54 UH1.E6
ACAV_DOCK_SRC#: JDOCK1.42 PR846.2 PR847.1
ACAV_IN: PQ710.2 PQ825.2 PR717.1 PR741.2 PR743.1 PU800.8 U51.A64
ACAV_IN#: PQ819.5 PQ825.1 PR864.2 PU806.2
ACAV_IN_NB: PR737.2 PU800.24 U51.B20
ACAVDK_SRC: PR847.2 PU800.4
ADBIA0: UV1.L18 UV4.J4 UV5.J4
ADBIA1: UV1.K16 UV3.J4 UV6.J4
ALW_PWRGD_3V_5V: PR118.1 U51.A1
ALWON: PR110.1 U51.A60
AND_PWRGD: R3772.2 U46.A4 U50.4
AUD_HP_NB_SENSE: C972.1 C1247.1 JHP1.6 Q324.2 R1088.1 U46.A41
AUD_HP_OUT_L: R1677.2 U74.33
AUD_HP_OUT_L1: L707.1 R1677.1
AUD_HP_OUT_L2: D81.3 JHP1.1 L707.2
AUD_HP_OUT_R: R1679.2 U74.32
AUD_HP_OUT_R1: L706.1 R1679.1
AUD_HP_OUT_R2: D82.2 JHP1.2 L706.2
AUD_NB_MUTE#: C967.1 R40.1 R1099.2 U46.A39 U74.47
AUD_PC_BEEP: C1105.2 C1106.2 U74.12
AUD_SENSE_A: R1086.1 U74.13
AUD_SENSE_B: R1079.1 R1080.1 U74.14
AUX_EN_WOWL: RP20.5 U46.B67 U57.3
BAT1_LED#: Q83.1 R953.1 U46.B64
BAT1_LED#_Q: Q83.6 R951.1
BAT2_LED#: Q83.4 R958.1 U46.A9
BAT2_LED#_Q: Q83.3 R949.1
BATDRV#: PQ800.4 PR722.2
BATT_WHITE#: JLED1.3 R949.2
BATT_WHITE_LED#: JLVDS1.2 R958.2
BATT_YELLOW#: JLED1.2 R951.2
BATT_YELLOW_LED#: JLVDS1.3 R953.2
BAY_SMBCLK: JSATA2.30 RP10.4 U51.A7
BAY_SMBDAT: JSATA2.29 RP10.3 U51.B7
BBS_BIT0_R: QH2.1 RH13.1 RH37.2 UH1.AU2
BBS_BIT1: RH119.1 UH1.C10
BC_CLK_ECE1117: JKB1.9 U51.A20
BC_CLK_ECE5048: U46.A30 U51.A43
BC_DAT_ECE1117: JKB1.7 R817.2 U51.B21
BC_DAT_ECE5048: RP16.1 U46.B31 U51.B45
BC_INT#_ECE1117: JKB1.6 U51.A19
BC_INT#_ECE5048: U46.A29 U51.A42
BCM5882_ALERT#: JUSH1.14 U46.B62
BEEP: R1120.2 U51.B19
BIA_PWM_CVT: D9.2 U27.19
BIA_PWM_EC: D9.3 U51.B25
BIA_PWM_LVDS: R429.1 R3762.2 U56.4
BIA_PWM_PCH: R114.2 U27.21 UH1.N36
BLUE_CRT: JIO1.7 U6.22
BLUE_DOCK: JDOCK1.45 U6.21
BOARD_ID: C744.1 R875.2 U51.B10
BOOT: PR715.1 PU700.17
BOOT1: PR550.2 PU500.18
BOOT1_1_VGA: PC623.1 PR649.2
BOOT1_VGA: PR649.1 PU600.19
BOOT2: PR534.2 PU500.27
BOOT2_2_VGA: PC605.1 PR614.2
BOOT2_VGA: PR614.1 PU600.30
BOOT_1.35V: PR200.2 PU200.18
BOOT_D: PC709.1 PD702.1 PR715.2
BQ24715_REGN: PC706.1 PD702.2 PR735.1 PR741.1 PR746.1 PU700.16
BREATH_LED#: JDOCK1.98 Q84.1 R955.1 U46.B39
BREATH_LED#_Q: LED1.1 Q84.6
BREATH_WHITE_LED#: JLVDS1.4 R955.2
BREATH_WHITE_LED_SNIFF: LED1.2 R957.1
BST_3V: PR108.2 PU100.9
BST_5V: PR107.1 PU100.17
BST_+1.05VSP: PR301.1 PU300.10
BT_LED#: JMINI2.46 Q89.3 RP13.1
BT_RADIO_DIS#: D36.1 R695.1 U46.A13
BT_RADIO_DIS#_R: D36.2 JMINI2.51 R695.2 R3886.1
CAM_MIC_CBL_DET#: JCAM1.1 RPH6.2 UH1.L15
CARD_RESET#: CE12.1 JEXP1.18 U41.8
CARD_SMBCLK: JEXP1.6 R732.2 U51.A49
CARD_SMBDAT: JEXP1.8 R731.2 U51.B52
CASA0#: UV1.G19 UV4.L3 UV5.G3
CASA1#: UV1.G16 UV3.G3 UV6.L3
CCD_OFF: Q23.2 U46.B43
CD3301_DCIN: PC813.1 PR835.2 PU800.1
CD3301_SDC_IN: PC818.1 PR854.2 PU800.6
CD_PBATT_OFF: PR843.1 PU800.27
CFD_PWRBTN#_XDP: JXDP1.11 RC21.2
CFG0: JCPU1.AT20 T157.1(TP-1)
CFG1: JCPU1.AR20 T158.1(TP-1)
CFG2: JCPU1.AP20 RC76.1
CFG3: JCPU1.AP22 JXDP1.8 RC100.1
CFG4: JCPU1.AT22 RC77.1
CFG5: JCPU1.AN22 RC78.1
CFG6: JCPU1.AT25 RC79.1
CFG7: JCPU1.AN23 RC83.1
CFG8: JCPU1.AR24 T159.1(TP-1)
CFG9: JCPU1.AT23 T160.1(TP-1)
CFG10: JCPU1.AN20 T161.1(TP-1)
CFG11: JCPU1.AP24 T162.1(TP-1)
CFG12: JCPU1.AP26 T163.1(TP-1)
CFG13: JCPU1.AN25 T164.1(TP-1)
CFG14: JCPU1.AN26 T165.1(TP-1)
CFG15: JCPU1.AP25 T166.1(TP-1)
CFG16: JCPU1.AR21 T167.1(TP-1)
CFG17: JCPU1.AP21 T169.1(TP-1)
CFG18: JCPU1.AR23 T168.1(TP-1)
CFG19: JCPU1.AP23 T170.1(TP-1)
CFG_RCOMP: JCPU1.AT31 RC81.1
CHAGER_SRC: PC710.1 PC712.1 PC713.1 PC714.1 PC734.1 PJP700.2 PL701.1 PQ704.5 PQ705.5
CHARGE_EN: RP19.3 U46.A45
CHARGER_CELL_PIN: PD818.2 PR720.2 PR746.2 PR747.2 PU700.10
CHARGER_SMBCLK: PU700.9 RP7.5 U51.B50
CHARGER_SMBDAT: PU700.8 RP7.6 U51.A47
CHG_LGATE: PC735.1 PQ706.4 PQ711.4 PU700.15
CHG_PHASE: PC709.2 PC715.1 PL700.2 PQ704.1 PQ704.2 PQ704.3 PQ705.1 PQ705.2 PQ705.3 PQ706.5 PQ711.5 PU700.19
CHG_UGATE: PQ704.4 PQ705.4 PU700.18
CKEA0: UV1.K20 UV4.J3 UV5.J3
CKEA1: UV1.J17 UV3.J3 UV6.J3
CLK_80H: RH159.2 UH1.F36
CLK_BUF_BCLK: RPH5.3 UH1.AT24
CLK_BUF_BCLK#: RPH5.4 UH1.AR24
CLK_BUF_CKSSCD: RPH20.8 UH1.BC6
CLK_BUF_CKSSCD#: RPH20.7 UH1.BE6
CLK_BUF_DMI: RPH5.1 UH1.AW24
CLK_BUF_DMI#: RPH5.2 UH1.AY24
CLK_BUF_DOT96: RPH19.3 UH1.G33
CLK_BUF_DOT96#: RPH19.4 UH1.H33
CLK_CPU_DMI: RC48.2 UH1.AF40
CLK_CPU_DMI#: RC46.2 UH1.AF39
CLK_CPU_DPLL: RC40.2 UH1.AF36
CLK_CPU_DPLL#: RC38.2 UH1.AF35
CLK_CPU_SSC_DPLL: RC44.2 UH1.AJ39
CLK_CPU_SSC_DPLL#: RC42.2 UH1.AJ40
CLK_DDC2_CRT: JIO1.12 U6.14
CLK_DDC2_DOCK: JDOCK1.48 U6.15
CLK_KBD: JDOCK1.78 RP8.8 U51.A38
CLK_MSE: JDOCK1.71 RP8.6 U51.A39
CLK_PCH_14M: RH146.1 UH1.F45
CLK_PCI_5048: RH158.2 U46.A28
CLK_PCI_DOCK: JDOCK1.121 R3761.1 RH162.2 RH330.1
CLK_PCI_LOOPBACK: RH164.2 UH1.D17
CLK_PCI_MEC: RH160.2 U51.A29
CLK_PCI_TPM: RH155.1 U39.21
CLK_PCIE_EMB: JSATA2.15 UH1.AJ42
CLK_PCIE_EMB#: JSATA2.16 UH1.AJ44
CLK_PCIE_EXP: JEXP1.11 UH1.AF45
CLK_PCIE_EXP#: JEXP1.9 UH1.AF43
CLK_PCIE_LAN: U31.44 UH1.AA42
CLK_PCIE_LAN#: U31.45 UH1.AA44
CLK_PCIE_MINI1: JMINI1.13 UH1.Y45
CLK_PCIE_MINI1#: JMINI1.11 UH1.Y43
CLK_PCIE_MINI2: JMINI2.13 UH1.AE42
CLK_PCIE_MINI2#: JMINI2.11 UH1.AE44
CLK_PCIE_MINI3: JMINI3.13 UH1.AD45
CLK_PCIE_MINI3#: JMINI3.11 UH1.AD43
CLK_PCIE_MMI: U38.3 UH1.AB45
CLK_PCIE_MMI#: U38.2 UH1.AB43
CLK_PCIE_VGA: UH1.AB36 UV1.AK30
CLK_PCIE_VGA#: UH1.AB35 UV1.AK32
CLK_SIO_14M: RH157.1 U46.A32
CLK_TP_SIO: R902.2 R3736.1 U51.A37
CLKA0: RV187.1 UV1.H26 UV4.J12 UV5.J12
CLKA0#: RV188.1 UV1.H25 UV4.J11 UV5.J11
CLKA1: RV189.1 UV1.G9 UV3.J12 UV6.J12
CLKA1#: RV190.1 UV1.H9 UV3.J11 UV6.J11
CLKRUN#: RH90.2 U39.15 U46.B20 U51.A32 UH1.AN7
CLKTESTA: CV85.1 UV1.K8
CLKTESTB: CV86.1 UV1.L7
COMP: PC525.2 PR539.2 PU500.7
COMP_VGA: PC611.2 PC613.1 PC614.1 PR638.2 PU600.7
CONTACTLESS_DET#: JUSH1.4 RPH19.1 UH1.C16
CPPE#: JMINI2.37 RP20.7 UH1.B13
CPU_B+: PC512.1 PC513.1 PC514.1 PC515.1 PC516.1 PC530.1 PC531.1 PC532.1 PC533.1 PC534.1 PC535.1 PC536.1 PJP500.1 PL504.1 PQ505.5 PQ509.5 PR526.2
CPU_DETECT#: JCPU1.AP32 RP4.6 U46.A3
CPU_DMI: JCPU1.E26 RC48.1
CPU_DMI#: JCPU1.D26 RC46.1
CPU_DPLL: JCPU1.H28 RC40.1
CPU_DPLL#: JCPU1.G28 RC38.1
CPU_EDP_HPD: QC3.2 RC75.1 U27.1
CPU_PLTRST#: RC66.2 UH1.AU4
CPU_PLTRST#_R: JCPU1.AT26 RC23.1 RC64.2 RC66.1
CPU_PWR_DEBUG: JCPU1.H27 RC22.1 RC85.2 RC89.1
CPU_PWR_DEBUG_R: JXDP1.12 RC22.2
CPU_SSC_DPLL: JCPU1.E27 RC44.1
CPU_SSC_DPLL#: JCPU1.F27 RC42.1
CPU_VTT_ON: RP6.2 U46.B17
CPUSB#: CE10.1 JEXP1.2 U41.9
CRT_IREF: RH97.2 UH1.U40
CRT_SWITCH: U6.30 U46.B52
CS_1.35V: PR201.2 PU200.13
CSA0#_0: UV1.H22 UV4.G12 UV5.L12
CSA1#_0: UV1.G13 UV3.L12 UV6.G12
CSS_GC: PR702.1 PU800.10
CSSN_1: PQ701.3 PQ703.2 PR703.1 PR705.2 PR707.1 PR744.2 PU703.5
CSSP_1: PQ702.3 PQ703.5 PR703.2 PR704.2 PR706.1 PR736.1
CVT_LVDS_A0+: JLVDS1.32 U27.41
CVT_LVDS_A0-: JLVDS1.33 U27.42
CVT_LVDS_A1+: JLVDS1.30 U27.39
CVT_LVDS_A1-: JLVDS1.31 U27.40
CVT_LVDS_A2+: JLVDS1.28 U27.37
CVT_LVDS_A2-: JLVDS1.29 U27.38
CVT_LVDS_ACLK+: JLVDS1.25 U27.35
CVT_LVDS_ACLK-: JLVDS1.26 U27.36
CVT_LVDS_B0+: JLVDS1.22 U27.31
CVT_LVDS_B0-: JLVDS1.23 U27.32
CVT_LVDS_B1+: JLVDS1.20 U27.29
CVT_LVDS_B1-: JLVDS1.21 U27.30
CVT_LVDS_B2+: JLVDS1.18 U27.27
CVT_LVDS_B2-: JLVDS1.19 U27.28
CVT_LVDS_BCLK+: JLVDS1.15 U27.25
CVT_LVDS_BCLK-: JLVDS1.16 U27.26
D_CLKRUN#: JDOCK1.111 RP5.4 U46.A19
D_DLDRQ1#: JDOCK1.117 RP5.2 U46.B24
D_LAD0: JDOCK1.97 U46.B29
D_LAD1: JDOCK1.99 U46.B28
D_LAD2: JDOCK1.103 U46.A25
D_LAD3: JDOCK1.105 U46.A24
D_LFRAME#: JDOCK1.109 U46.B23
D_SERIRQ: JDOCK1.115 RP5.3 U46.A20
DAI_12MHZ#: JDOCK1.89 R1654.1
DAI_BCLK#: JDOCK1.77 R1668.1
DAI_DI: JDOCK1.83 U74.24
DAI_DO#: JDOCK1.85 R1097.1
DAI_LRCK#: JDOCK1.79 U74.18
DAT_DDC2_CRT: JIO1.10 U6.12
DAT_DDC2_DOCK: JDOCK1.46 U6.13
DAT_KBD: JDOCK1.80 RP8.7 U51.B41
DAT_MSE: JDOCK1.73 RP8.5 U51.B42
DAT_TP_SIO: R903.2 R3735.1 U51.B40
DC_BLOCK_GC: PR700.2 PU800.7
DC_IN_SS: PC820.1 PR831.2 PU800.34
DDBIA0_0: UV1.H27 UV5.P13
DDBIA0_1: UV1.A27 UV4.D2
DDBIA0_2: UV1.C23 UV5.D2
DDBIA0_3: UV1.C19 UV4.P13
DDBIA1_0: UV1.C15 UV6.D2
DDBIA1_1: UV1.E9 UV3.P13
DDBIA1_2: UV1.C5 UV3.D2
DDBIA1_3: UV1.H4 UV6.P13
DDR3_DRAMRST#_CPU: JCPU1.AN3 QD9.3 RD4.2 RD24.1
DDR3_DRAMRST#_R: JDIMM1.30 JDIMM2.30 RD25.2
DDR_A_BS0: JCPU1.V5 JDIMM1.109
DDR_A_BS1: JCPU1.U5 JDIMM1.108
DDR_A_BS2: JCPU1.AD1 JDIMM1.79
DDR_A_CAS#: JCPU1.U8 JDIMM1.115
DDR_A_D0: JCPU1.AR15 JDIMM1.5
DDR_A_D1: JCPU1.AT14 JDIMM1.7
DDR_A_D2: JCPU1.AM14 JDIMM1.15
DDR_A_D3: JCPU1.AN14 JDIMM1.17
DDR_A_D4: JCPU1.AT15 JDIMM1.4
DDR_A_D5: JCPU1.AR14 JDIMM1.6
DDR_A_D6: JCPU1.AN15 JDIMM1.16
DDR_A_D7: JCPU1.AM15 JDIMM1.18
DDR_A_D8: JCPU1.AM9 JDIMM1.21
DDR_A_D9: JCPU1.AN9 JDIMM1.23
DDR_A_D10: JCPU1.AM8 JDIMM1.33
DDR_A_D11: JCPU1.AN8 JDIMM1.35
DDR_A_D12: JCPU1.AR9 JDIMM1.22
DDR_A_D13: JCPU1.AT9 JDIMM1.24
DDR_A_D14: JCPU1.AR8 JDIMM1.34
DDR_A_D15: JCPU1.AT8 JDIMM1.36
DDR_A_D16: JCPU1.AJ9 JDIMM1.39
DDR_A_D17: JCPU1.AK9 JDIMM1.41
DDR_A_D18: JCPU1.AJ6 JDIMM1.51
DDR_A_D19: JCPU1.AK6 JDIMM1.53
DDR_A_D20: JCPU1.AJ10 JDIMM1.40
DDR_A_D21: JCPU1.AK10 JDIMM1.42
DDR_A_D22: JCPU1.AJ7 JDIMM1.50
DDR_A_D23: JCPU1.AK7 JDIMM1.52
DDR_A_D24: JCPU1.AF4 JDIMM1.57
DDR_A_D25: JCPU1.AF5 JDIMM1.59
DDR_A_D26: JCPU1.AF1 JDIMM1.67
DDR_A_D27: JCPU1.AF2 JDIMM1.69
DDR_A_D28: JCPU1.AG4 JDIMM1.56
DDR_A_D29: JCPU1.AG5 JDIMM1.58
DDR_A_D30: JCPU1.AG1 JDIMM1.68
DDR_A_D31: JCPU1.AG2 JDIMM1.70
DDR_A_D32: JCPU1.J1 JDIMM1.129
DDR_A_D33: JCPU1.J2 JDIMM1.131
DDR_A_D34: JCPU1.J5 JDIMM1.141
DDR_A_D35: JCPU1.H5 JDIMM1.143
DDR_A_D36: JCPU1.H2 JDIMM1.130
DDR_A_D37: JCPU1.H1 JDIMM1.132
DDR_A_D38: JCPU1.J4 JDIMM1.140
DDR_A_D39: JCPU1.H4 JDIMM1.142
DDR_A_D40: JCPU1.F2 JDIMM1.147
DDR_A_D41: JCPU1.F1 JDIMM1.149
DDR_A_D42: JCPU1.D2 JDIMM1.157
DDR_A_D43: JCPU1.D3 JDIMM1.159
DDR_A_D44: JCPU1.D1 JDIMM1.146
DDR_A_D45: JCPU1.F3 JDIMM1.148
DDR_A_D46: JCPU1.C3 JDIMM1.158
DDR_A_D47: JCPU1.B3 JDIMM1.160
DDR_A_D48: JCPU1.B5 JDIMM1.163
DDR_A_D49: JCPU1.E6 JDIMM1.165
DDR_A_D50: JCPU1.A5 JDIMM1.175
DDR_A_D51: JCPU1.D6 JDIMM1.177
DDR_A_D52: JCPU1.D5 JDIMM1.164
DDR_A_D53: JCPU1.E5 JDIMM1.166
DDR_A_D54: JCPU1.B6 JDIMM1.174
DDR_A_D55: JCPU1.A6 JDIMM1.176
DDR_A_D56: JCPU1.E12 JDIMM1.181
DDR_A_D57: JCPU1.D12 JDIMM1.183
DDR_A_D58: JCPU1.B11 JDIMM1.191
DDR_A_D59: JCPU1.A11 JDIMM1.193
DDR_A_D60: JCPU1.E11 JDIMM1.180
DDR_A_D61: JCPU1.D11 JDIMM1.182
DDR_A_D62: JCPU1.B12 JDIMM1.192
DDR_A_D63: JCPU1.A12 JDIMM1.194
DDR_A_DQS0: JCPU1.AP14 JDIMM1.12
DDR_A_DQS1: JCPU1.AP9 JDIMM1.29
DDR_A_DQS2: JCPU1.AK8 JDIMM1.47
DDR_A_DQS3: JCPU1.AG3 JDIMM1.64
DDR_A_DQS4: JCPU1.H3 JDIMM1.137
DDR_A_DQS5: JCPU1.E3 JDIMM1.154
DDR_A_DQS6: JCPU1.C6 JDIMM1.171
DDR_A_DQS7: JCPU1.C12 JDIMM1.188
DDR_A_DQS#0: JCPU1.AP15 JDIMM1.10
DDR_A_DQS#1: JCPU1.AP8 JDIMM1.27
DDR_A_DQS#2: JCPU1.AJ8 JDIMM1.45
DDR_A_DQS#3: JCPU1.AF3 JDIMM1.62
DDR_A_DQS#4: JCPU1.J3 JDIMM1.135
DDR_A_DQS#5: JCPU1.E2 JDIMM1.152
DDR_A_DQS#6: JCPU1.C5 JDIMM1.169
DDR_A_DQS#7: JCPU1.C11 JDIMM1.186
DDR_A_MA0: JCPU1.V8 JDIMM1.98
DDR_A_MA1: JCPU1.AC6 JDIMM1.97
DDR_A_MA2: JCPU1.V9 JDIMM1.96
DDR_A_MA3: JCPU1.U9 JDIMM1.95
DDR_A_MA4: JCPU1.AC5 JDIMM1.92
DDR_A_MA5: JCPU1.AC4 JDIMM1.91
DDR_A_MA6: JCPU1.AD6 JDIMM1.90
DDR_A_MA7: JCPU1.AC3 JDIMM1.86
DDR_A_MA8: JCPU1.AD5 JDIMM1.89
DDR_A_MA9: JCPU1.AC2 JDIMM1.85
DDR_A_MA10: JCPU1.V6 JDIMM1.107
DDR_A_MA11: JCPU1.AC1 JDIMM1.84
DDR_A_MA12: JCPU1.AD4 JDIMM1.83
DDR_A_MA13: JCPU1.V7 JDIMM1.119
DDR_A_MA14: JCPU1.AD3 JDIMM1.80
DDR_A_MA15: JCPU1.AD2 JDIMM1.78
DDR_A_RAS#: JCPU1.U6 JDIMM1.110
DDR_A_WE#: JCPU1.U7 JDIMM1.113
DDR_B_BS0: JCPU1.R7 JDIMM2.109
DDR_B_BS1: JCPU1.P8 JDIMM2.108
DDR_B_BS2: JCPU1.AA9 JDIMM2.79
DDR_B_CAS#: JCPU1.P7 JDIMM2.115
DDR_B_D0: JCPU1.AR18 JDIMM2.5
DDR_B_D1: JCPU1.AT18 JDIMM2.7
DDR_B_D2: JCPU1.AM17 JDIMM2.15
DDR_B_D3: JCPU1.AM18 JDIMM2.17
DDR_B_D4: JCPU1.AR17 JDIMM2.4
DDR_B_D5: JCPU1.AT17 JDIMM2.6
DDR_B_D6: JCPU1.AN17 JDIMM2.16
DDR_B_D7: JCPU1.AN18 JDIMM2.18
DDR_B_D8: JCPU1.AT12 JDIMM2.21
DDR_B_D9: JCPU1.AR12 JDIMM2.23
DDR_B_D10: JCPU1.AN12 JDIMM2.33
DDR_B_D11: JCPU1.AM11 JDIMM2.35
DDR_B_D12: JCPU1.AT11 JDIMM2.22
DDR_B_D13: JCPU1.AR11 JDIMM2.24
DDR_B_D14: JCPU1.AM12 JDIMM2.34
DDR_B_D15: JCPU1.AN11 JDIMM2.36
DDR_B_D16: JCPU1.AR5 JDIMM2.39
DDR_B_D17: JCPU1.AR6 JDIMM2.41
DDR_B_D18: JCPU1.AM5 JDIMM2.51
DDR_B_D19: JCPU1.AM6 JDIMM2.53
DDR_B_D20: JCPU1.AT5 JDIMM2.40
DDR_B_D21: JCPU1.AT6 JDIMM2.42
DDR_B_D22: JCPU1.AN5 JDIMM2.50
DDR_B_D23: JCPU1.AN6 JDIMM2.52
DDR_B_D24: JCPU1.AJ4 JDIMM2.57
DDR_B_D25: JCPU1.AK4 JDIMM2.59
DDR_B_D26: JCPU1.AJ1 JDIMM2.67
DDR_B_D27: JCPU1.AJ2 JDIMM2.69
DDR_B_D28: JCPU1.AM1 JDIMM2.56
DDR_B_D29: JCPU1.AN1 JDIMM2.58
DDR_B_D30: JCPU1.AK2 JDIMM2.68
DDR_B_D31: JCPU1.AK1 JDIMM2.70
DDR_B_D32: JCPU1.L2 JDIMM2.129
DDR_B_D33: JCPU1.M2 JDIMM2.131
DDR_B_D34: JCPU1.L4 JDIMM2.141
DDR_B_D35: JCPU1.M4 JDIMM2.143
DDR_B_D36: JCPU1.L1 JDIMM2.130
DDR_B_D37: JCPU1.M1 JDIMM2.132
DDR_B_D38: JCPU1.L5 JDIMM2.140
DDR_B_D39: JCPU1.M5 JDIMM2.142
DDR_B_D40: JCPU1.G7 JDIMM2.147
DDR_B_D41: JCPU1.J8 JDIMM2.149
DDR_B_D42: JCPU1.G8 JDIMM2.157
DDR_B_D43: JCPU1.G9 JDIMM2.159
DDR_B_D44: JCPU1.J7 JDIMM2.146
DDR_B_D45: JCPU1.J9 JDIMM2.148
DDR_B_D46: JCPU1.G10 JDIMM2.158
DDR_B_D47: JCPU1.J10 JDIMM2.160
DDR_B_D48: JCPU1.A8 JDIMM2.163
DDR_B_D49: JCPU1.B8 JDIMM2.165
DDR_B_D50: JCPU1.A9 JDIMM2.175
DDR_B_D51: JCPU1.B9 JDIMM2.177
DDR_B_D52: JCPU1.D8 JDIMM2.164
DDR_B_D53: JCPU1.E8 JDIMM2.166
DDR_B_D54: JCPU1.D9 JDIMM2.174
DDR_B_D55: JCPU1.E9 JDIMM2.176
DDR_B_D56: JCPU1.E15 JDIMM2.181
DDR_B_D57: JCPU1.D15 JDIMM2.183
DDR_B_D58: JCPU1.A15 JDIMM2.191
DDR_B_D59: JCPU1.B15 JDIMM2.193
DDR_B_D60: JCPU1.E14 JDIMM2.180
DDR_B_D61: JCPU1.D14 JDIMM2.182
DDR_B_D62: JCPU1.A14 JDIMM2.192
DDR_B_D63: JCPU1.B14 JDIMM2.194
DDR_B_DQS0: JCPU1.AP17 JDIMM2.12
DDR_B_DQS1: JCPU1.AP12 JDIMM2.29
DDR_B_DQS2: JCPU1.AP6 JDIMM2.47
DDR_B_DQS3: JCPU1.AK3 JDIMM2.64
DDR_B_DQS4: JCPU1.M3 JDIMM2.137
DDR_B_DQS5: JCPU1.H8 JDIMM2.154
DDR_B_DQS6: JCPU1.C9 JDIMM2.171
DDR_B_DQS7: JCPU1.C15 JDIMM2.188
DDR_B_DQS#0: JCPU1.AP18 JDIMM2.10
DDR_B_DQS#1: JCPU1.AP11 JDIMM2.27
DDR_B_DQS#2: JCPU1.AP5 JDIMM2.45
DDR_B_DQS#3: JCPU1.AJ3 JDIMM2.62
DDR_B_DQS#4: JCPU1.L3 JDIMM2.135
DDR_B_DQS#5: JCPU1.H9 JDIMM2.152
DDR_B_DQS#6: JCPU1.C8 JDIMM2.169
DDR_B_DQS#7: JCPU1.C14 JDIMM2.186
DDR_B_MA0: JCPU1.R8 JDIMM2.98
DDR_B_MA1: JCPU1.Y5 JDIMM2.97
DDR_B_MA2: JCPU1.Y10 JDIMM2.96
DDR_B_MA3: JCPU1.AA5 JDIMM2.95
DDR_B_MA4: JCPU1.Y7 JDIMM2.92
DDR_B_MA5: JCPU1.AA6 JDIMM2.91
DDR_B_MA6: JCPU1.Y6 JDIMM2.90
DDR_B_MA7: JCPU1.AA7 JDIMM2.86
DDR_B_MA8: JCPU1.Y8 JDIMM2.89
DDR_B_MA9: JCPU1.AA10 JDIMM2.85
DDR_B_MA10: JCPU1.R9 JDIMM2.107
DDR_B_MA11: JCPU1.Y9 JDIMM2.84
DDR_B_MA12: JCPU1.AF7 JDIMM2.83
DDR_B_MA13: JCPU1.P9 JDIMM2.119
DDR_B_MA14: JCPU1.AA8 JDIMM2.80
DDR_B_MA15: JCPU1.AG7 JDIMM2.78
DDR_B_RAS#: JCPU1.R6 JDIMM2.110
DDR_B_WE#: JCPU1.P6 JDIMM2.113
DDR_CKE0_DIMMA: JCPU1.AD9 JDIMM1.73
DDR_CKE1_DIMMA: JCPU1.AC9 JDIMM1.74
DDR_CKE2_DIMMB: JCPU1.AF10 JDIMM2.73
DDR_CKE3_DIMMB: JCPU1.AG10 JDIMM2.74
DDR_CS0_DIMMA#: JCPU1.M7 JDIMM1.114
DDR_CS1_DIMMA#: JCPU1.L9 JDIMM1.121
DDR_CS2_DIMMB#: JCPU1.P4 JDIMM2.114
DDR_CS3_DIMMB#: JCPU1.R2 JDIMM2.121
DDR_HVREF_RST_PCH: CD45.1 QD6.2 QD6.5 QD7.2 QD9.2 RC104.2 RH170.2 UH1.N8
DDR_XDP_WAN_SMBCLK: JDIMM1.202 JDIMM2.202 QH4.1 R502.2 RH31.1 U27.13 U88.4
DDR_XDP_WAN_SMBCLK_R2: JXDP2.53 RH31.2
DDR_XDP_WAN_SMBDAT: JDIMM1.200 JDIMM2.200 QH4.4 R501.2 RH30.1 U27.14 U88.6
DDR_XDP_WAN_SMBDAT_R2: JXDP2.51 RH30.2
DEVICE_DET#: JSATA2.8 R1070.2 RP16.3
DGPU_HOLD_RST#: RV33.2 UH1.A12 UV14.1
DGPU_PEX_RST: D71.1 RV18.1 RV29.2 UV14.4
DGPU_PEX_RST_R: RV18.2 UV1.AL27
DGPU_PWR_EN: PQ610.1 PR600.1 PR681.1 PR688.1 PR692.2 PR697.2
DGPU_PWR_EN#: QV5.3 QV6.2 RH328.2 RV82.2 UH1.C12
DGPU_PWR_EN#_Q: CV411.1 PQ610.2 PR697.1 QV2.2 QV5.1 QV6.1 QV11.2 QV12.2 RV81.1
DGPU_PWROK: PR629.1 RPH15.4 U46.A56 UH1.C14
DH_1.35V: PQ201.4 PU200.17
DIMM1_SA0: JDIMM1.197 RD6.2
DIMM1_SA1: JDIMM1.201 RD7.2
DIMM2_SA0: JDIMM2.197 RD11.1
DIMM2_SA1: JDIMM2.201 RD12.1
DIS_BAT_PROCHOT#: PR812.1 U46.B51
DISP_ON: D10.1 JLVDS1.9 R1138.1
DK_AC_OFF: PD815.3 PU800.25
DK_AC_OFF_EN: PR857.1 PU800.22
DK_CSS_GC: PR709.2 PU800.11
DK_PWRBAR: PR832.1 PU800.33
DL_1.35V: PQ203.4 PU200.15
DMI_CRX_PTX_N0: JCPU1.D21 UH1.BD21
DMI_CRX_PTX_N1: JCPU1.C21 UH1.BE20
DMI_CRX_PTX_N2: JCPU1.B21 UH1.BD17
DMI_CRX_PTX_N3: JCPU1.A21 UH1.BE18
DMI_CRX_PTX_P0: JCPU1.D20 UH1.BB21
DMI_CRX_PTX_P1: JCPU1.C20 UH1.BC20
DMI_CRX_PTX_P2: JCPU1.B20 UH1.BB17
DMI_CRX_PTX_P3: JCPU1.A20 UH1.BC18
DMI_CTX_PRX_N0: JCPU1.D18 UH1.AW22
DMI_CTX_PRX_N1: JCPU1.C17 UH1.AR20
DMI_CTX_PRX_N2: JCPU1.B17 UH1.AP17
DMI_CTX_PRX_N3: JCPU1.A17 UH1.AV20
DMI_CTX_PRX_P0: JCPU1.D17 UH1.AY22
DMI_CTX_PRX_P1: JCPU1.C18 UH1.AP20
DMI_CTX_PRX_P2: JCPU1.B18 UH1.AR17
DMI_CTX_PRX_P3: JCPU1.A18 UH1.AW20
DMI_IREF: RH98.1 UH1.BE16
DMI_RCOMP: RH100.2 UH1.AY17
DMIC0: JCAM1.7 U74.4
DMIC_CLK: JCAM1.5 L13.2
DMIC_CLK_L: L13.1 U74.2
DOCK_AC_OFF: JDOCK1.2 PD815.1 PR844.1
DOCK_AC_OFF_EC: PR857.2 PR858.1 U46.A63
DOCK_DCIN_IS+: JDOCK1.134 PQ703.6
DOCK_DCIN_IS-: JDOCK1.136 PQ703.4
DOCK_DET#: D32.2 PQ817.2 PR886.2 PR887.2 PU808.2 R755.1 U46.B41
DOCK_DET_R#: D32.1 JDOCK1.142 JDOCK1.144
DOCK_HP_DET: Q106.2 R1081.2 U46.A7
DOCK_LOM_ACTLED_YEL#: JDOCK1.100 U32.19
DOCK_LOM_SPD10LED_GRN#: JDOCK1.3 U32.40
DOCK_LOM_SPD100LED_ORG#: JDOCK1.4 U32.20
DOCK_LOM_TRD0+: JDOCK1.104 U32.22
DOCK_LOM_TRD0-: JDOCK1.106 U32.23
DOCK_LOM_TRD1+: JDOCK1.110 U32.26
DOCK_LOM_TRD1-: JDOCK1.112 U32.27
DOCK_LOM_TRD2+: JDOCK1.122 U32.31
DOCK_LOM_TRD2-: JDOCK1.124 U32.32
DOCK_LOM_TRD3+: JDOCK1.128 U32.35
DOCK_LOM_TRD3-: JDOCK1.130 U32.36
DOCK_MIC_DET: Q106.5 R1082.2 U46.B8
DOCK_POR_RST#: C737.1 JDOCK1.140 RP9.5 U51.A21
DOCK_PSID: JDOCK1.135 PU1.1
DOCK_PWR_BTN#: C733.1 JDOCK1.139 R825.2
DOCK_PWR_SW#: C734.1 R825.1 RP15.2 U51.A63
DOCK_SMB_ALERT#: JDOCK1.133 PD819.2 PQ7.3 RP2.5 U46.A51
DOCK_SMB_CLK: JDOCK1.127 RP10.2 U51.B4
DOCK_SMB_DAT: JDOCK1.129 RP10.1 U51.A3
DOCKED: U32.13 U46.A38
DP_HDMI_HPD: R1154.2 U46.B4
DPC_CA_DET: JDOCK1.6 Q331.2 R492.2 U20.1 U20.4 U21.2
DPC_CA_DET#: Q331.6 R415.2 U20.10 U20.13 U21.4
DPC_CPU_LANE_N0: C680.1 JCPU1.T34
DPC_CPU_LANE_N0_C: C680.2 RE18.2
DPC_CPU_LANE_N1: C684.1 JCPU1.U35
DPC_CPU_LANE_N1_C: C684.2 RE20.2
DPC_CPU_LANE_N2: C686.1 JCPU1.U32
DPC_CPU_LANE_N2_C: C686.2 RE22.2
DPC_CPU_LANE_N3: C694.1 JCPU1.U33
DPC_CPU_LANE_N3_C: C694.2 RE24.2
DPC_CPU_LANE_P0: C691.1 JCPU1.U34
DPC_CPU_LANE_P0_C: C691.2 RE17.2
DPC_CPU_LANE_P1: C682.1 JCPU1.V35
DPC_CPU_LANE_P1_C: C682.2 RE19.2
DPC_CPU_LANE_P2: C693.1 JCPU1.T32
DPC_CPU_LANE_P2_C: C693.2 RE21.2
DPC_CPU_LANE_P3: C688.1 JCPU1.V33
DPC_CPU_LANE_P3_C: C688.2 RE23.2
DPC_DOCK_AUX: JDOCK1.34 U20.3 U20.11
DPC_DOCK_AUX#: JDOCK1.36 U20.6 U20.8
DPC_DOCK_LANE_N0: JDOCK1.12 RE18.1
DPC_DOCK_LANE_N1: JDOCK1.18 RE20.1
DPC_DOCK_LANE_N2: JDOCK1.24 RE22.1
DPC_DOCK_LANE_N3: JDOCK1.30 RE24.1
DPC_DOCK_LANE_P0: JDOCK1.10 RE17.1
DPC_DOCK_LANE_P1: JDOCK1.16 RE19.1
DPC_DOCK_LANE_P2: JDOCK1.22 RE21.1
DPC_DOCK_LANE_P3: JDOCK1.28 RE23.1
DPC_PCH_DOCK_AUX: C357.2 UH1.K45
DPC_PCH_DOCK_AUX#: C360.2 UH1.K43
DPC_PCH_DOCK_AUX#_C: C360.1 U20.5
DPC_PCH_DOCK_AUX_C: C357.1 U20.2
DPC_PCH_DOCK_HPD: C696.1 JDOCK1.40 R758.1 UH1.K38
DPD_CA_DET: JDOCK1.5 Q331.5 R491.2 U23.1 U23.4 U24.2
DPD_CA_DET#: Q331.3 R416.2 U23.10 U23.13 U24.4
DPD_CPU_LANE_N0: C679.2 JCPU1.P29
DPD_CPU_LANE_N0_C: C679.1 RE8.2
DPD_CPU_LANE_N1: C683.2 JCPU1.N28
DPD_CPU_LANE_N1_C: C683.1 RE10.2
DPD_CPU_LANE_N2: C685.2 JCPU1.P31
DPD_CPU_LANE_N2_C: C685.1 RE14.2
DPD_CPU_LANE_N3: C689.2 JCPU1.N30
DPD_CPU_LANE_N3_C: C689.1 RE16.2
DPD_CPU_LANE_P0: C690.2 JCPU1.R29
DPD_CPU_LANE_P0_C: C690.1 RE7.2
DPD_CPU_LANE_P1: C681.2 JCPU1.P28
DPD_CPU_LANE_P1_C: C681.1 RE9.2
DPD_CPU_LANE_P2: C692.2 JCPU1.R31
DPD_CPU_LANE_P2_C: C692.1 RE13.2
DPD_CPU_LANE_P3: C687.2 JCPU1.P30
DPD_CPU_LANE_P3_C: C687.1 RE15.2
DPD_DOCK_AUX: JDOCK1.33 U23.3 U23.11
DPD_DOCK_AUX#: JDOCK1.35 U23.6 U23.8
DPD_DOCK_LANE_N0: JDOCK1.11 RE8.1
DPD_DOCK_LANE_N1: JDOCK1.17 RE10.1
DPD_DOCK_LANE_N2: JDOCK1.23 RE14.1
DPD_DOCK_LANE_N3: JDOCK1.29 RE16.1
DPD_DOCK_LANE_P0: JDOCK1.9 RE7.1
DPD_DOCK_LANE_P1: JDOCK1.15 RE9.1
DPD_DOCK_LANE_P2: JDOCK1.21 RE13.1
DPD_DOCK_LANE_P3: JDOCK1.27 RE15.1
DPD_PCH_DOCK_AUX: C367.2 UH1.J44
DPD_PCH_DOCK_AUX#: C368.2 UH1.J42
DPD_PCH_DOCK_AUX#_C: C368.1 U23.5
DPD_PCH_DOCK_AUX_C: C367.1 U23.2
DPD_PCH_DOCK_HPD: C695.1 JDOCK1.39 R757.1 UH1.H39
DPRSLPVR_R: PR616.2 PU600.39
DQA0_0: UV1.K27 UV5.M13
DQA0_1: UV1.J29 UV5.N13
DQA0_2: UV1.H30 UV5.T13
DQA0_3: UV1.H32 UV5.U13
DQA0_4: UV1.G29 UV5.U11
DQA0_5: UV1.F28 UV5.T11
DQA0_6: UV1.F32 UV5.N11
DQA0_7: UV1.F30 UV5.M11
DQA0_8: UV1.C30 UV4.F4
DQA0_9: UV1.F27 UV4.F2
DQA0_10: UV1.A28 UV4.E2
DQA0_11: UV1.C28 UV4.E4
DQA0_12: UV1.E27 UV4.A4
DQA0_13: UV1.G26 UV4.B4
DQA0_14: UV1.D26 UV4.B2
DQA0_15: UV1.F25 UV4.A2
DQA0_16: UV1.A25 UV5.F4
DQA0_17: UV1.C25 UV5.F2
DQA0_18: UV1.E25 UV5.E2
DQA0_19: UV1.D24 UV5.E4
DQA0_20: UV1.E23 UV5.B2
DQA0_21: UV1.F23 UV5.A2
DQA0_22: UV1.D22 UV5.B4
DQA0_23: UV1.F21 UV5.A4
DQA0_24: UV1.E21 UV4.M13
DQA0_25: UV1.D20 UV4.M11
DQA0_26: UV1.F19 UV4.N11
DQA0_27: UV1.A19 UV4.N13
DQA0_28: UV1.D18 UV4.T11
DQA0_29: UV1.F17 UV4.U13
DQA0_30: UV1.A17 UV4.T13
DQA0_31: UV1.C17 UV4.U11
DQA1_0: UV1.E17 UV6.F4
DQA1_1: UV1.D16 UV6.F2
DQA1_2: UV1.F15 UV6.E2
DQA1_3: UV1.A15 UV6.E4
DQA1_4: UV1.D14 UV6.A2
DQA1_5: UV1.F13 UV6.B2
DQA1_6: UV1.A13 UV6.A4
DQA1_7: UV1.C13 UV6.B4
DQA1_8: UV1.E11 UV3.N13
DQA1_9: UV1.A11 UV3.N11
DQA1_10: UV1.C11 UV3.M13
DQA1_11: UV1.F11 UV3.M11
DQA1_12: UV1.A9 UV3.T13
DQA1_13: UV1.C9 UV3.U11
DQA1_14: UV1.F9 UV3.T11
DQA1_15: UV1.D8 UV3.U13
DQA1_16: UV1.E7 UV3.F4
DQA1_17: UV1.A7 UV3.E4
DQA1_18: UV1.C7 UV3.B4
DQA1_19: UV1.F7 UV3.A4
DQA1_20: UV1.A5 UV3.B2
DQA1_21: UV1.E5 UV3.F2
DQA1_22: UV1.C3 UV3.A2
DQA1_23: UV1.E1 UV3.E2
DQA1_24: UV1.G7 UV6.M11
DQA1_25: UV1.G6 UV6.M13
DQA1_26: UV1.G1 UV6.N11
DQA1_27: UV1.G3 UV6.N13
DQA1_28: UV1.J6 UV6.T13
DQA1_29: UV1.J1 UV6.T11
DQA1_30: UV1.J3 UV6.U11
DQA1_31: UV1.J5 UV6.U13
DRAM_RST#: RV179.2 UV3.J2 UV4.J2 UV5.J2 UV6.J2
DRAM_RST#_R: CV344.1 RV178.1 RV180.2 UV1.L10
DSWODVREN: RH67.1 RH81.2 UH1.C8
DYN_TUR_CURRNT_SET#: PQ709.2 R1171.2 U51.A35
DYN_TURB_PWR_ALRT#: R796.2 U46.A46
EC5048_TX: JDEG2.9 JMINI2.17 R806.1 RP12.3 U46.B2
EC_32KHZ_ECE5048: U46.B35 U51.B62
EC_WAKE#: RH196.1 RH216.1 U51.B23 UH1.R11
ECE5048_PWRGD: U50.1 U51.A34
EDCA0_0: UV1.H28 UV5.R13
EDCA0_1: UV1.C27 UV4.C2
EDCA0_2: UV1.A23 UV5.C2
EDCA0_3: UV1.E19 UV4.R13
EDCA1_0: UV1.E15 UV6.C2
EDCA1_1: UV1.D10 UV3.R13
EDCA1_2: UV1.D6 UV3.C2
EDCA1_3: UV1.G5 UV6.R13
EDP_COMP: JCPU1.E24 RC73.2
EDP_CPU_AUX: C104.2 JCPU1.N27
EDP_CPU_AUX#: C105.2 JCPU1.M27
EDP_CPU_AUX#_C: C105.1 U27.3
EDP_CPU_AUX_C: C104.1 U27.4
EDP_CPU_LANE_N0: C101.2 JCPU1.P35
EDP_CPU_LANE_N0_C: C101.1 U27.8
EDP_CPU_LANE_N1: C118.2 JCPU1.N34
EDP_CPU_LANE_N1_C: C118.1 U27.10
EDP_CPU_LANE_P0: C100.2 JCPU1.R35
EDP_CPU_LANE_P0_C: C100.1 U27.7
EDP_CPU_LANE_P1: C103.2 JCPU1.P34
EDP_CPU_LANE_P1_C: C103.1 U27.9
EDP_HPD#: JCPU1.P27 QC3.1 RC74.1
EMBCLK_REQ#: JSATA2.26 RPH9.4 UH1.Y3
EN_1.5VSP: PC406.1 PR403.2 PR406.2 PU400.5
EN_+1.05VSP: PC307.1 PR303.2 PR308.2 PU300.3
EN_+1.8V_RUN: PC675.1 PR688.2 PU603.8
EN_DK_PWRBAR: PR866.1 PR874.1 PU800.17
EN_DOCK_PWR_BAR: PR866.2 U46.B37
EN_I2S_NB_CODEC#: U46.B36 U74.48
EN_INVPWR: Q22.2 RP9.7 U51.A25
EN_PCIE: PC665.1 PR681.2 PU602.5
ENVDD_PCH: RH118.2 U46.B38 UH1.G36
ERC1: PC815.1 PU800.3
ERC2: PC817.1 PU800.13
ERC3: PC816.1 PU800.12
ESATA_USB_PWR_EN#: RP4.7 U46.B44 U91.4 U93.4
EXPCLK_REQ#: JEXP1.27 RPH9.3 UH1.V3
EXPRCRD_CPPE#: CE11.1 JEXP1.28 U41.10
EXPRCRD_STBY_R#: R717.2 R734.2 U41.1
EXT_MIC: C1556.1 D82.3 JHP1.4 R3731.2
FAN1_PWM: JFAN1.3 R38.2 U51.A24
FAN1_TACH_FB: C1555.1 JFAN1.2 R30.2 U51.B22
