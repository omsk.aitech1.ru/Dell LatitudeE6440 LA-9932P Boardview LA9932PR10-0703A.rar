# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DOCK_LOM_SPD100LED_ORG#: length 151.5
  TOP w0.102: U32.20 255.4,179.37 255.71,179.06 v3(255.72,179.06)
  IN1 w0.102: v3(118.81,167.25) 119,167.06 130.37,167.06 134.52,171.21 143.91,171.21 145.27,172.57 185.24,172.57 185.78,172.03 191.23,172.03 191.44,172.24 198.53,172.24 200.25,170.53 202.92,170.53 203.61,169.83 225.27,169.83 227,168.09 232.7,168.09 233.48,168.87 236.51,168.87 238.27,170.64 239.24,170.64 239.69,171.1 241.16,171.1 244.67,174.61 244.67,175.31 244.48,175.5 v3(244.48,175.55)
  IN2 w0.127: v3(255.72,179.06) 254.46,177.8 251.79,177.8 249.94,175.95 245.49,175.95 245.18,176.27 244.79,176.27 244.48,175.95 v3(244.48,175.55)
  BOTTOM w0.102: v3(118.81,167.25) 118.34,167.72 JDOCK1.4 ; v1(245.05,174.74) 244.48,175.31 v3(244.48,175.55)
DOCK_LOM_TRD0+: length 128.3
  TOP w0.089: v3(254.32,182.17) 254.27,182.12 254.27,180.86 U32.22
  IN4 w0.089: v3(145.25,170.93) 145.25,170.27 147.47,168.05 154.42,168.05 156.54,170.17 176.24,170.17 182.29,164.12 185.15,164.12 187.58,166.55 195.39,166.55 196.15,167.31 198.38,167.31 199.61,166.08 203.25,166.08 204.49,164.84 223.44,164.84 224.43,165.82 224.43,165.82 224.66,166.05 237.05,166.05 239.12,168.12 239.75,168.12 242.09,170.46 243.68,170.46 247.98,174.76 249.77,174.76 254.31,179.3 254.31,182.15 v3(254.32,182.17)
  BOTTOM w0.089: JDOCK1.104 145.34,170.21 145.25,170.3 v3(145.25,170.93)
DOCK_LOM_TRD0-: length 128.2
  TOP w0.089: v3(253.73,182.17) 253.76,182.17 253.96,181.97 253.96,181.49 253.91,181.44 253.85,181.44 253.76,181.35 U32.23
  IN4 w0.089: v3(145.84,170.93) 145.51,170.6 145.51,170.37 147.57,168.31 154.31,168.31 156.43,170.42 176.34,170.42 182.39,164.37 185.04,164.37 187.48,166.8 195.29,166.8 196.05,167.57 198.48,167.57 199.72,166.33 203.35,166.33 204.59,165.09 223.34,165.09 224.18,165.93 224.18,165.93 224.55,166.31 236.94,166.31 239.01,168.37 239.65,168.37 241.99,170.71 243.57,170.71 247.88,175.02 249.66,175.02 254.05,179.41 254.05,181.87 253.75,182.17 v3(253.73,182.17)
  BOTTOM w0.089: JDOCK1.106 145.84,170.3 145.78,170.36 145.61,170.36 145.54,170.42 145.54,170.64 v3(145.84,170.93)
DOCK_LOM_TRD1+: length 121.1
  TOP w0.089: U32.26 252.26,181.31 252.31,181.37 v3(252.31,181.91)
  IN4 w0.089: v3(252.31,181.91) 252.31,179.65 248.38,175.72 247.51,175.72 243.21,171.41 241.06,171.41 236.65,167 224.26,167 223.48,166.22 223.48,166.22 223.09,165.83 204.84,165.83 201.61,169.07 197.97,169.07 196.42,170.61 194.68,170.61 194.17,171.12 190.23,171.12 189.53,170.42 185.51,170.42 184.81,171.12 156.14,171.12 154.02,169.01 148,169.01 146.8,170.21 v3(146.8,170.91)
  BOTTOM w0.089: v3(146.8,170.91) 146.8,170.3 146.84,170.25 JDOCK1.110
DOCK_LOM_TRD1-: length 121.1
  TOP w0.089: U32.27 251.76,181.41 251.8,181.45 251.95,181.45 252.01,181.52 252.01,181.62 v3(251.72,181.91)
  IN4 w0.089: v3(251.72,181.91) 252.05,181.58 252.05,179.75 248.27,175.97 247.41,175.97 243.1,171.67 240.96,171.67 236.55,167.26 224.16,167.26 223.22,166.32 223.22,166.32 222.99,166.09 204.94,166.09 201.71,169.32 198.08,169.32 196.53,170.87 194.78,170.87 194.28,171.38 190.12,171.38 189.42,170.68 185.61,170.68 184.91,171.38 156.03,171.38 153.92,169.26 148.11,169.26 147.05,170.31 147.05,170.58 v3(147.38,170.91)
  BOTTOM w0.089: JDOCK1.112 147.34,170.3 147.24,170.39 147.16,170.39 147.09,170.47 147.09,170.62 v3(147.38,170.91)
DOCK_LOM_TRD2+: length 116.7
  TOP w0.089: v3(249.77,181.8) 249.62,181.66 249.62,181.44 249.76,181.31 U32.31
  IN4 w0.089: v3(249.77,181.8) 249.56,181.6 249.56,179.11 242.81,172.37 240.67,172.37 237.14,168.84 233.49,168.84 232.75,168.1 223.93,168.1 222.76,166.93 205.09,166.93 201.77,170.25 198.35,170.25 197.03,171.57 195.07,171.57 194.41,172.23 189.61,172.23 188.76,171.38 185.99,171.38 185.14,172.23 155.9,172.23 153.63,169.96 150.22,169.96 149.74,170.44 149.74,171.19 149.61,171.31 149.47,171.31 v3(149.29,171.13)
  BOTTOM w0.089: JDOCK1.122 149.84,170.3 149.94,170.4 149.94,171.07 149.74,171.28 149.44,171.28 v3(149.29,171.13)
DOCK_LOM_TRD2-: length 116.7
  TOP w0.089: v3(249.18,181.8) 249.33,181.66 249.33,181.44 249.26,181.37 U32.32
  IN4 w0.089: v3(249.18,181.8) 249.3,181.68 249.3,179.21 242.71,172.62 240.56,172.62 237.03,169.09 233.39,169.09 232.65,168.35 223.83,168.35 222.66,167.19 205.19,167.19 201.87,170.51 198.45,170.51 197.14,171.82 195.18,171.82 194.52,172.48 189.51,172.48 188.65,171.63 186.1,171.63 185.25,172.48 155.79,172.48 153.52,170.21 150.33,170.21 149.99,170.55 149.99,171.29 149.72,171.57 149.44,171.57 v3(149.29,171.71)
  BOTTOM w0.089: JDOCK1.124 150.34,170.3 150.24,170.4 150.24,171.19 149.86,171.57 149.44,171.57 v3(149.29,171.71)
DOCK_LOM_TRD3+: length 109
  TOP w0.089: v3(247.77,181.74) 247.62,181.6 247.62,181.44 247.76,181.31 U32.35
  IN4 w0.089: v3(247.77,181.74) 247.57,181.55 247.57,179.23 241.66,173.32 240.27,173.32 237.14,170.18 203.21,170.18 202.19,171.21 198.74,171.21 197.43,172.52 195.52,172.52 194.86,173.18 155.48,173.18 153.61,171.31 150.93,171.31 v3(150.81,171.19)
  BOTTOM w0.089: JDOCK1.128 151.34,170.3 151.55,170.51 151.55,171.02 151.23,171.34 150.96,171.34 v3(150.81,171.19)
DOCK_LOM_TRD3-: length 108.9
  TOP w0.089: U32.36 247.26,181.37 247.33,181.44 247.33,181.6 v3(247.18,181.74)
  IN4 w0.089: v3(150.81,171.78) 151.02,171.57 153.5,171.57 155.37,173.44 194.96,173.44 195.62,172.77 197.53,172.77 198.85,171.46 202.29,171.46 203.32,170.44 237.03,170.44 240.17,173.57 241.55,173.57 247.32,179.34 247.32,181.61 247.27,181.65 v3(247.18,181.74)
  BOTTOM w0.089: v3(150.81,171.78) 150.96,171.63 151.35,171.63 151.84,171.14 JDOCK1.130
DOCK_MIC_DET: length 187.5
  TOP w0.102: U46.B8 189.53,67.31 v3(189.1,67.75)
  IN2 w0.102: v3(288.23,155.39) 284.06,151.22 283.89,151.22 275.82,151.22 275.12,150.52 270.73,150.52 269.81,151.44 264.48,151.44 263.52,150.48 254.23,150.48 251.21,147.46 v3(251.21,144.45)
  IN3 w0.127: v3(189.1,67.75) 189.53,68.18 193.98,68.18 194.31,68.51 197.74,68.51 198.58,67.67 207.42,67.67 208.01,67.07 215.95,67.07 217.99,69.12 221.36,69.12 223.28,71.03 223.28,72.27 224.03,73.03 224.85,73.03 229.97,78.15 229.97,103.83 237.77,111.62 238.42,112.28 242.51,116.36 242.51,131.98 246.43,135.9 246.43,137.18 251.21,141.95 v3(251.21,144.45)
  BOTTOM w0.102: R1082.2 275.43,159.88 v1(279.13,156.17) 282.31,156.17 283,155.49 284.88,155.49 285.21,155.82 287.79,155.82 v3(288.23,155.39) 288.23,153.92 287.8,153.49 287.8,152.17 288.09,151.88 Q106.5
DOCK_POR_RST#: length 159.8
  TOP w0.102: RP9.5 221.5,74.42 220.98,73.9 218.3,73.9 C737.1 v1(217.79,75.38) 217.79,75.45 217.43,75.82 216.98,75.82 v3(216.42,76.38) 215.94,76.86 215.77,76.86 215.63,76.86 215.44,77.04 U51.A21
  IN4 w0.102: v3(216.42,76.38) 216.51,76.47 216.51,79.38 217.85,80.72 217.85,97.16 217.42,97.59 217.42,107.02 217.42,107.03 217.42,112.88 216.13,114.17 216.13,115.31 209.72,121.72 206.38,121.72 203.49,124.6 203.49,144.42 206.29,147.21 206.29,152.22 203.74,154.77 203.3,154.77 202.19,155.88 198.69,155.88 197.97,156.61 196.26,156.61 195.32,157.55 181.56,157.55 176.46,162.65 165.7,162.65 163.88,164.48 162.93,164.48 162.65,164.76 162.65,165.73 v3(163.15,166.22)
  BOTTOM w0.102: JDOCK1.140 154.34,170.71 154.75,171.12 162.39,171.12 163.22,170.29 163.22,166.3 v3(163.15,166.22)
DOCK_PSID: length 105.1
  TOP w0.254: v3(222.38,124.45) 222.58,124.24 PU1.1
  IN2 w0.127: v3(163.65,169.6) 164.54,168.71 174.59,168.71 184.22,159.08 187.54,159.08 189.38,157.24 193.12,157.24 196.66,153.7 196.66,152.49 200.24,148.91 200.24,147.71 200.9,147.04 201.92,147.04 212.49,136.48 212.49,131.8 216.28,128.01 216.28,126.65 217.91,125.02 221.81,125.02 v3(222.38,124.45)
  BOTTOM w0.102: JDOCK1.135 153.34,160.13 154.04,159.43 160.89,159.43 162.18,160.71 162.18,163.6 162.72,164.14 163.39,164.14 163.65,164.39 v3(163.65,169.6) ; v3(222.38,124.45) v1(222.38,123.62)
DOCK_PWR_BTN#: length 153.8
  TOP w0.102: v1(201.42,69.54) 201.82,69.14 v3(202.91,69.14) 202.71,68.94 C733.1 203.63,68.38 R825.2
  IN2 w0.127: v3(202.91,69.14) 202.91,69.84 204.24,71.17 204.24,73.43 204.86,74.05 204.86,75.29 204.68,75.47 204.68,75.87 203.98,76.57 202.31,76.57 201.49,77.4 201.49,83 204.5,86.01 204.5,89.08 204.5,89.08 204.5,89.71 204.09,90.12 204.09,92.33 209.51,97.76 209.51,98.39 209.51,113.7 208.35,114.86 207.05,116.16 207.05,126.34 205.18,128.21 205.18,134.28 204.49,134.97 204.49,141.91 201.14,145.27 200.17,145.27 197.4,148.04 197.4,149.6 195.14,151.86 195.14,153.07 194.77,153.44 194.15,153.44 193.99,153.28 191.42,153.28 187.43,157.27 182.66,157.27 174.01,165.92 171.52,165.92 168.38,162.78 164.41,162.78 163.79,162.16 163.79,161.93 161.3,159.43 155.27,159.43 154.41,160.29 v3(154.41,162.61)
  BOTTOM w0.102: v3(154.41,162.61) 154.34,162.55 JDOCK1.139
DOCK_PWR_SW#: length 17.1
  TOP w0.102: U51.A63 v3(203.39,75.54) ; RP15.2 198.71,66.49 198.95,66.73 200.04,66.73 200.78,65.99 202.35,65.99 202.71,66.35 C734.1 203.21,67.43 203.27,67.48 R825.1 204.4,68.23 v3(204.4,69.13)
  IN4 w0.102: v3(204.4,69.13) 203.96,69.56 203.96,74.97 v3(203.39,75.54)
  BOTTOM w0.102: v3(203.39,75.54) 203.41,75.53 v1(203.98,75.53)
DOCK_SMB_ALERT#: length 171.7
  TOP w0.102: v3(182.85,61.7) 183.12,61.96 U46.A51 ; v3(179.49,73.66) 179.4,73.75 RP2.5
  TOP w0.254: PQ7.3 v3(170.56,169.38) 174.21,169.38 v1(184.53,159.06) 186.06,157.53 186.06,149.09 188.34,146.8 188.34,143.94 v3(188.85,143.44) ; PD819.2 v3(186.25,53.94)
  IN1 w0.254: v3(182.85,61.7) 182.56,61.7 181.94,61.08 180.34,61.08 179.52,60.25 179.52,57.14 182.72,53.94 v3(186.25,53.94)
  IN2 w0.254: v3(188.85,143.44) 188.85,142.15 190.48,140.53 190.48,121.86 188.24,119.63 188.24,109.32 185.05,106.13 185.05,100.65 184.08,99.67 184.08,95.77 184.07,95.77 184.07,95.16 184.08,95.15 184.08,92.91 185.16,91.82 185.16,88.77 184.29,87.9 184.29,82.45 180.3,78.46 180.3,76.02 179.65,75.38 179.65,73.83 v3(179.49,73.66)
  IN3 w0.127: v3(153.16,162.61) 153.16,162.74 153.8,163.38 154.69,163.38 155.66,164.34 155.66,169.11 157.16,170.61 169.33,170.61 v3(170.56,169.38)
  IN4 w0.254: v3(182.85,61.7) 181.44,63.11 181.44,65.2 180.21,66.43 180.21,73.11 179.66,73.66 v3(179.49,73.66)
  BOTTOM w0.102: JDOCK1.133 152.84,162.29 v3(153.16,162.61)
DOCK_SMB_CLK: length 169.5
  TOP w0.102: v3(207.2,65.81) 207.38,65.99 208.06,65.99 208.34,66.27 208.34,66.41 208.48,66.54 RP10.2 ; U51.B4 v3(207.18,74.92)
  IN4 w0.102: v3(181.36,77.54) 181.32,77.58 181.32,77.75 181.43,77.86 182.13,77.86 184.05,79.77 184.62,79.77 185.07,80.22 185.76,80.22 186.76,81.21 186.76,87.3 186.23,87.82 186.23,89.77 186.73,90.26 186.73,97.35 185.69,98.39 185.69,102.34 184.84,103.19 184.84,108.04 184.6,108.28 184.6,109.85 180.93,113.51 180.93,119.98 181.55,120.6 181.55,121.49 180.43,122.61 180.43,126.09 183.01,128.67 183.01,135.9 184.64,137.53 184.64,139.1 183.53,140.2 183.53,155.22 178.87,159.89 178.52,159.89 175.98,162.42 163.58,162.42 163.01,163 163.01,163.2 v3(163.22,163.42) ; v3(207.18,74.92) 207.33,74.76 207.33,70.41 207.94,69.81 207.94,66.19 207.74,65.99 207.38,65.99 v3(207.2,65.81)
  BOTTOM w0.102: v3(207.18,74.92) 206.52,74.26 205.4,74.26 204.53,75.14 202.77,75.14 202.31,74.68 201.72,74.68 201.25,74.21 198.96,74.21 197.97,75.2 197.97,75.75 197.25,76.47 184.7,76.47 184.06,77.12 181.26,77.12 181.21,77.16 181.21,77.38 v3(181.36,77.54) ; JDOCK1.127 151.34,160.37 151.48,160.24 151.48,159.98 151.68,159.78 153.04,159.78 153.95,158.87 160.98,158.87 163.04,160.93 163.04,163.24 v3(163.22,163.42)
DOCK_SMB_DAT: length 166.8
  TOP w0.102: v3(207.2,66.4) 207.38,66.22 207.97,66.22 208.11,66.36 208.11,66.41 207.98,66.55 RP10.1 ; U51.A3 206.93,72.79 v3(206.74,72.6)
  IN4 w0.102: v3(207.2,66.4) 207.38,66.22 207.64,66.22 207.71,66.29 207.71,69.71 207.11,70.32 207.11,72.23 v3(206.74,72.6) ; v3(162.64,163.42) 162.78,163.28 162.78,162.9 163.49,162.19 175.89,162.19 178.42,159.66 178.77,159.66 183.31,155.13 183.31,140.11 184.41,139 184.41,137.62 182.78,135.99 182.78,128.76 180.2,126.19 180.2,122.52 181.32,121.4 181.32,120.69 180.7,120.08 180.7,113.41 184.37,109.75 184.37,108.19 184.61,107.95 184.61,103.09 185.46,102.24 185.46,98.29 186.5,97.25 186.5,90.36 186.01,89.86 186.01,87.73 186.53,87.21 186.53,81.3 185.67,80.44 184.97,80.44 184.53,80 183.95,80 182.07,78.11 181.36,78.11 181.09,77.85 v3(180.78,77.54)
  BOTTOM w0.102: v3(180.78,77.54) 180.98,77.33 180.98,77.07 181.16,76.89 183.96,76.89 184.61,76.24 197.16,76.24 197.74,75.66 197.74,75.1 198.86,73.98 201.34,73.98 201.81,74.45 202.4,74.45 202.86,74.91 204.43,74.91 205.29,74.05 206.5,74.05 206.74,73.81 v3(206.74,72.6) ; JDOCK1.129 151.84,160.34 151.7,160.2 151.7,160.08 151.77,160.01 153.13,160.01 153.95,159.2 160.99,159.2 162.82,161.03 162.82,163.24 v3(162.64,163.42)
DOCKED: length 169.6
  TOP w0.102: U32.13 252.26,176.68 v3(252.48,176.46) ; U46.A38 v3(179.64,69.06)
  IN3 w0.127: v3(249.73,137.21) 248.1,137.21 242.76,131.87 242.76,116.26 238.6,112.1 238.02,111.52 230.23,103.72 230.23,78.04 224.96,72.77 224.14,72.77 223.53,72.17 223.53,70.89 221.51,68.86 218.1,68.86 216.05,66.82 207.91,66.82 207.31,67.41 198.39,67.41 197.55,68.25 194.42,68.25 194.09,67.92 190.88,67.92 190.29,67.33 188.92,67.33 187.34,68.91 183.96,68.91 183.5,69.38 181.18,69.38 180.87,69.06 v3(179.64,69.06)
  BOTTOM w0.102: v3(252.48,176.46) v1(252.48,172.94) 252.48,168.05 250.19,165.77 250.19,159.25 249.94,158.99 249.94,158.42 250.26,158.11 250.26,156.71 249.85,156.3 249.85,149.42 248.5,148.08 248.5,138.44 v3(249.73,137.21)
DP_HDMI_HPD: length 7.8
  TOP w0.102: v3(192.89,64.8) 192.98,64.89 R1154.2 ; v3(189.1,66.03) 189.8,65.33 189.99,65.33 190.02,65.31 U46.B4
  IN1 w0.102: v3(192.89,64.8) 192.33,65.36 190.35,65.36 190.12,65.59 189.54,65.59 v3(189.1,66.03)
  BOTTOM w0.102: v3(192.89,64.8) 193.89,64.8 v1(193.99,64.7)
DPC_CA_DET: length 77.2
  TOP w0.102: U21.2 170.49,160.52 R492.2 170.75,160.78 v3(170.75,161.79) v1(170.34,162.2) 166.62,162.2 164.45,160.03 164.45,158.6 164.71,158.34 U20.1 166.77,158.34 v3(167.39,157.72) ; Q331.2 174.37,161.41 v3(173.99,161.79) ; U20.4 166.84,156.39 v3(167.01,156.56)
  IN3 w0.127: v3(173.99,161.79) 173.42,162.36 171.64,162.36 171.07,161.79 v3(170.75,161.79) ; v3(167.01,156.56) 167.39,156.94 v3(167.39,157.72) 167.39,159.18 166.75,159.82 164.15,159.82 163.9,159.57 163.08,159.57 163.07,159.57 153.22,159.57 150.62,162.17 144.34,162.17 143.41,163.1 128.55,163.1 127.32,164.33 125.99,164.33 122.4,167.91 v3(118.84,167.91)
  BOTTOM w0.102: v3(118.84,167.91) JDOCK1.6
DPC_CA_DET#: length 16.5
  TOP w0.102: v1(165.89,160.92) 166.13,161.17 U21.4 167.94,161.17 168.21,160.9 168.21,158.42 168.72,157.91 169.83,157.91 170.09,157.65 v3(170.12,157.65) 170.16,157.69 U20.13 172.5,157.69 172.77,157.97 172.77,158.33 172.33,158.78 R415.2 172.33,160.57 172.52,160.76 Q331.6 ; v3(170.51,155.98) 170.74,155.74 U20.10
  IN3 w0.127: v3(170.51,155.98) 170.64,156.11 170.64,157.13 v3(170.12,157.65)
DPC_CPU_LANE_N0: length 84.8
  TOP w0.102: C680.1 120.16,166.86 120.16,166.49 120.34,166.31 121.58,166.31 v4(122.68,165.22) 124.69,163.2 124.69,162.8 v3(124.88,162.61)
  IN1 w0.089: v3(129.29,109.17) 129.26,109.17 129.1,109.33 129.1,110.59 129.45,110.95 129.45,111.58 129.48,111.6 129.48,111.7
  IN1 w0.114: v3(124.88,162.61) 124.69,162.43 124.69,161.14 122.91,159.36 122.91,158.27 120.98,156.34 120.98,152.36 122.15,151.2 122.96,151.2 123.8,150.36 129.89,150.36 131,149.24 132.28,149.24 132.96,148.56 138.15,148.56 139.71,146.99 139.71,120.78 135.13,116.2 132.77,116.2 129.48,112.9 129.48,111.7
  BOTTOM w0.089: v3(129.29,109.17) 129.74,108.73 JCPU1.T34
DPC_CPU_LANE_N0_C: length 0.9
  TOP w0.102: C680.2 RE18.2
DPC_CPU_LANE_N1: length 84.9
  TOP w0.102: C684.1 122.05,166.97 122.05,166.84 122.59,166.3 123.13,166.3 124.42,165.01 124.42,164.75 v3(124.71,164.45)
  IN1 w0.089: v3(128.47,110.2) 128.22,110.2 128.14,110.27 128.14,110.49 128.33,110.68 128.33,111.73
  IN1 w0.114: v3(124.71,164.45) 124.5,164.24 124.5,163.67 123.8,162.97 123.8,161.89 123.03,161.12 122.68,161.12 122.08,161.71 121.92,161.71 121.67,161.47 121.67,161.31 122.27,160.71 122.27,160.36 121.35,159.44 121.35,157.91 120.26,156.83 120.26,152.06 121.85,150.47 122.66,150.47 123.86,149.28 129.94,149.28 130.7,148.52 131.98,148.52 132.66,147.84 137.33,147.84 138.99,146.18 138.99,121.14 134.9,117.05 132.6,117.05 130.84,115.28 130.06,115.28 128.74,113.97 128.74,113.19 128.74,113.18 128.74,112.28 128.33,111.88 128.33,111.73
  BOTTOM w0.089: v3(128.47,110.2) JCPU1.U35
DPC_CPU_LANE_N1_C: length 0.9
  TOP w0.102: C684.2 RE20.2
DPC_CPU_LANE_N2: length 88
  TOP w0.102: C686.1 123.7,166.84 123.7,166.71 125.04,165.36 126.07,165.36 v3(126.43,165.72)
  IN1 w0.089: 129.97,111.13 129.87,111.03 129.87,109.18 129.48,108.79 129.18,108.79 128.79,108.4 128.79,107.78 128.64,107.63 128.64,107.37 v3(128.47,107.2)
  IN1 w0.114: 129.97,111.13 129.97,112.69 132.2,114.93 134.68,114.93 140.23,120.48 140.23,147.18 138.35,149.06 133.17,149.06 132.49,149.74 131.21,149.74 130.09,150.85 124.01,150.85 123.17,151.69 122.36,151.69 121.48,152.57 121.48,155.89 125.95,160.37 125.95,162.78 125.57,163.17 125.57,165.05 125.88,165.37 126.07,165.37 v3(126.43,165.72)
  BOTTOM w0.089: v3(128.47,107.2) 128.72,107.2 128.94,106.97 JCPU1.U32
DPC_CPU_LANE_N2_C: length 0.9
  TOP w0.102: C686.2 RE22.2
DPC_CPU_LANE_N3: length 87.9
  TOP w0.102: v3(125.62,166.22) 125.43,166.41 125.43,166.8 C694.1
  IN1 w0.089: 127.22,111.73 127.22,111.72 127.21,111.71 127.21,110.94 127.06,110.79 127.06,109.97 127.26,109.78 127.83,109.78 128.08,109.53 128.08,108.53 v3(128.41,108.2)
  IN1 w0.114: v3(125.62,166.22) 125.45,166.06 125.45,165.64 124.87,165.05 124.37,165.05 123.82,165.6 123.64,165.6 123.36,165.32 123.36,165.14 123.6,164.9 123.6,164.53 123.09,164.03 122.72,164.03 122.42,164.33 122.24,164.33 122.02,164.1 122.02,163.92 122.39,163.56 122.39,163.2 120.25,161.06 120.25,158.08 119.54,157.37 119.54,151.76 121.55,149.75 122.36,149.75 123.56,148.55 128.41,148.55 129.17,147.79 131.68,147.79 132.36,147.11 137.03,147.11 138.27,145.88 138.27,121.62 134.46,117.81 132.34,117.81 130.54,116 129.76,116 127.56,113.8 127.56,112.31 127.22,111.98 127.22,111.73
  BOTTOM w0.089: JCPU1.U33 128.47,108.2 v3(128.41,108.2)
DPC_CPU_LANE_N3_C: length 0.9
  TOP w0.102: C694.2 RE24.2
DPC_CPU_LANE_P0: length 85
  TOP w0.102: C691.1 119.95,166.86 119.95,166.4 120.25,166.1 121.5,166.1 122.33,165.27 122.33,165.25 122.71,164.86 122.74,164.86 124.48,163.12 124.48,162.8 v3(124.3,162.61)
  IN1 w0.089: v3(128.47,109.2) 128.8,109.2 128.89,109.29 128.89,110.68 129.25,111.03 129.25,111.68
  IN1 w0.114: v3(124.3,162.61) 124.47,162.44 124.47,161.24 122.68,159.46 122.68,158.36 120.76,156.44 120.76,152.27 122.06,150.97 122.87,150.97 123.71,150.13 129.79,150.13 130.91,149.01 132.19,149.01 132.87,148.33 138.05,148.33 139.49,146.9 139.49,120.87 135.03,116.42 132.68,116.42 129.25,112.99 129.25,111.68
  BOTTOM w0.089: v3(128.47,109.2) 128.73,109.2 128.94,108.99 JCPU1.U34
DPC_CPU_LANE_P0_C: length 0.9
  TOP w0.102: C691.2 RE17.2
DPC_CPU_LANE_P1: length 84.9
  TOP w0.102: v3(124.13,164.45) 124.21,164.53 124.21,164.92 123.04,166.09 122.5,166.09 C682.1
  IN1 w0.089: v3(127.47,110.2) 127.75,110.2 127.94,110.39 127.94,110.57 128.12,110.75 128.12,111.71 128.1,111.72 128.1,111.73
  IN1 w0.114: v3(124.13,164.45) 124.27,164.31 124.27,163.76 123.57,163.06 123.57,161.99 122.93,161.34 122.77,161.34 122.17,161.94 121.82,161.94 121.45,161.56 121.45,161.21 122.04,160.62 122.04,160.45 121.12,159.53 121.12,158.01 120.03,156.92 120.03,151.97 121.76,150.24 122.57,150.24 123.76,149.05 129.85,149.05 130.61,148.29 131.89,148.29 132.57,147.61 137.24,147.61 138.76,146.09 138.76,121.23 134.81,117.27 132.51,117.27 130.74,115.51 129.96,115.51 128.52,114.06 128.52,113.28 128.51,113.28 128.51,112.38 128.1,111.97 128.1,111.73
  BOTTOM w0.089: v3(127.47,110.2) JCPU1.V35
DPC_CPU_LANE_P1_C: length 0.9
  TOP w0.102: C682.2 RE19.2
DPC_CPU_LANE_P2: length 88
  TOP w0.102: v3(126.43,165.14) 126.41,165.15 124.95,165.15 123.49,166.62 123.49,166.88 C693.1
  IN1 w0.089: v3(129.23,107.21) 128.97,107.21 128.84,107.34 128.84,107.55 128.99,107.7 128.99,108.31 129.27,108.58 129.57,108.58 130.07,109.09 130.07,110.94 130.2,111.07
  IN1 w0.114: v3(126.43,165.14) 125.97,165.14 125.8,164.96 125.8,163.27 126.18,162.88 126.18,160.27 121.71,155.8 121.71,152.66 122.45,151.92 123.26,151.92 124.1,151.08 130.19,151.08 131.3,149.96 132.58,149.96 133.26,149.28 138.45,149.28 140.46,147.27 140.46,120.38 134.77,114.7 132.3,114.7 130.2,112.6 130.2,111.07
  BOTTOM w0.089: JCPU1.T32 129.71,106.73 v3(129.23,107.21)
DPC_CPU_LANE_P2_C: length 0.9
  TOP w0.102: C693.2 RE21.2
DPC_CPU_LANE_P3: length 87.9
  TOP w0.102: C688.1 125.22,166.92 125.22,166.41 v3(125.03,166.22)
  IN1 w0.089: v3(127.47,108.2) 127.88,108.61 127.88,109.44 127.74,109.58 127.17,109.58 126.86,109.89 126.86,110.88 127.01,111.03 127.01,111.71 127,111.72 127,111.73
  IN1 w0.114: 127,111.73 127,112.07 127.33,112.41 127.33,113.9 129.66,116.23 130.44,116.23 132.24,118.04 134.36,118.04 138.04,121.71 138.04,145.79 136.94,146.88 132.27,146.88 131.59,147.56 129.08,147.56 128.32,148.33 123.46,148.33 122.27,149.52 121.46,149.52 119.31,151.67 119.31,157.47 120.02,158.17 120.02,161.16 122.16,163.3 122.16,163.46 121.79,163.83 121.79,164.2 122.15,164.56 122.51,164.56 122.82,164.26 123,164.26 123.37,164.63 123.37,164.81 123.13,165.05 123.13,165.42 123.54,165.83 123.91,165.83 124.46,165.28 124.77,165.28 125.22,165.73 125.22,166.03 v3(125.03,166.22)
  BOTTOM w0.089: v3(127.47,108.2) 127.57,108.2 127.94,107.83 JCPU1.V33
DPC_CPU_LANE_P3_C: length 0.9
  TOP w0.102: C688.2 RE23.2
DPC_DOCK_AUX: length 65.7
  TOP w0.102: U20.11 170.82,156.39 170.65,156.56 168.43,156.56 167.94,157.04 U20.3 164.97,157.04 164.87,156.94 164.87,156.76 v3(164.57,156.45)
  BOTTOM w0.102: v3(164.57,156.45) 164.57,156.17 164.47,156.07 164.02,156.07 163.92,156.18 163.92,158.27 164.43,158.78 164.43,163.21 164.78,163.57 164.78,170.21 161.7,173.3 142.09,173.3 140.5,171.71 127.04,171.71 125.97,170.64 125.97,170.3 125.84,170.17 JDOCK1.34
DPC_DOCK_AUX#: length 65.6
  TOP w0.102: U20.8 170.84,154.44 170.47,154.8 166.89,154.8 166.6,155.09 U20.6 164.97,155.09 164.82,155.25 164.66,155.25 v3(164.47,155.06)
  BOTTOM w0.102: JDOCK1.36 126.34,170.2 126.18,170.36 126.18,170.55 127.13,171.5 140.59,171.5 142.18,173.09 161.61,173.09 164.57,170.13 164.57,163.65 164.22,163.3 164.22,158.87 163.7,158.36 163.7,156.09 163.93,155.86 164.39,155.86 164.47,155.79 v3(164.47,155.06)
DPC_DOCK_LANE_N0: length 3.9
  TOP w0.102: RE18.1 120.16,170.23 120.16,171.11 v3(120.38,171.34)
  BOTTOM w0.102: JDOCK1.12 120.34,170.3 120.2,170.44 120.2,171.15 v3(120.38,171.34)
DPC_DOCK_LANE_N1: length 4
  TOP w0.102: RE20.1 121.92,170.25 121.92,170.55 121.79,170.68 121.79,171.25 v3(121.95,171.4)
  BOTTOM w0.102: v3(121.95,171.4) 121.74,171.19 121.74,170.4 121.84,170.3 JDOCK1.18
DPC_DOCK_LANE_N2: length 4.2
  TOP w0.102: RE22.1 123.72,170.23 123.72,170.47 123.26,170.93 123.26,171.21 v3(123.45,171.4)
  BOTTOM w0.102: JDOCK1.24 123.34,170.3 123.2,170.44 123.2,171.15 v3(123.45,171.4)
DPC_DOCK_LANE_N3: length 4.3
  TOP w0.102: RE24.1 125.5,170.23 125.5,170.45 124.91,171.04 124.91,171.23 v3(125.07,171.4)
  BOTTOM w0.102: JDOCK1.30 124.84,170.36 124.72,170.49 124.72,170.68 124.91,170.87 124.91,171.23 v3(125.07,171.4)
DPC_DOCK_LANE_P0: length 3.9
  TOP w0.102: RE17.1 119.95,170.23 119.95,171.19 v3(119.8,171.34)
  BOTTOM w0.102: v3(119.8,171.34) 119.98,171.15 119.98,170.44 119.84,170.3 JDOCK1.10
DPC_DOCK_LANE_P1: length 4.1
  TOP w0.102: RE19.1 121.71,170.21 121.71,170.46 121.58,170.59 121.58,171.18 v3(121.36,171.4)
  BOTTOM w0.102: v3(121.36,171.4) 121.53,171.23 121.53,170.49 121.34,170.3 JDOCK1.16
DPC_DOCK_LANE_P2: length 4.2
  TOP w0.102: v3(122.86,171.4) 123.04,171.22 123.04,170.84 123.51,170.38 123.51,170.23 RE21.1
  BOTTOM w0.102: JDOCK1.22 122.84,170.36 122.98,170.51 122.98,171.28 v3(122.86,171.4)
DPC_DOCK_LANE_P3: length 4.4
  TOP w0.102: RE23.1 125.29,170.23 125.29,170.36 124.7,170.95 124.7,171.19 v3(124.49,171.4)
  BOTTOM w0.102: v3(124.49,171.4) 124.7,171.19 124.7,170.96 124.5,170.77 124.5,170.46 124.34,170.3 JDOCK1.28
DPC_PCH_DOCK_AUX: length 24
  TOP w0.102: C357.2 162.44,156.6 162.26,156.6 162.03,156.37 162.03,155.8 164.13,153.7 165.9,153.7 166.61,153 v4(167.49,153) 168.63,153 169.63,152 171.82,152 172.25,152.43 173.36,152.43 174.01,151.78 174.01,150.6 173.76,150.35 173.76,148.2 173.46,147.91 173.46,147.08 173.02,146.63 172.76,146.63 172.65,146.74 172.65,146.94 v3(172.89,147.18)
  BOTTOM w0.089: v3(172.89,147.18) 172.65,147.43 172.13,147.43 171.77,147.07 UH1.K45
DPC_PCH_DOCK_AUX#: length 24.1
  TOP w0.102: v3(172.28,147.04) 172.44,146.88 172.44,146.65 172.67,146.42 173.1,146.42 173.67,146.99 173.67,147.82 173.97,148.11 173.97,150.26 174.22,150.51 174.22,151.86 173.44,152.64 172.16,152.64 171.74,152.21 169.72,152.21 168.72,153.21 167.78,153.21 167.76,153.23 167.19,153.23 167.17,153.21 166.69,153.21 165.99,153.91 164.21,153.91 162.24,155.88 162.24,156.28 162.35,156.39 162.74,156.39 C360.2
  BOTTOM w0.089: v3(172.28,147.04) 172.17,147.04 172.06,146.93 172.06,146.53 171.83,146.3 171.83,146.13 171.99,145.98 171.99,145.84 171.9,145.76 UH1.K43
DPC_PCH_DOCK_AUX#_C: length 2.2
  TOP w0.102: C360.1 164.16,155.88 164.78,155.88 164.93,155.74 U20.5
DPC_PCH_DOCK_AUX_C: length 2.2
  TOP w0.102: U20.2 164.45,157.69 C357.1
DPC_PCH_DOCK_HPD: length 79.8
  TOP w0.102: R758.1 C696.1 127.45,170.49 v3(127.26,170.68) 127.26,170.93 v1(126.87,171.31)
  IN3 w0.127: v3(172.17,143.89) 173.09,144.81 173.09,145.65 174.63,147.18 174.63,151.29 175.52,152.18 175.52,153.77 177.17,155.42 177.17,158.13 175.03,160.26 164.17,160.26 163.73,159.83 153.33,159.83 150.73,162.42 144.53,162.42 143.56,163.39 128.88,163.39 128.02,164.25 128.02,167.57 127.78,167.8 127.78,170.15 v3(127.26,170.68)
  BOTTOM w0.089: v3(172.17,143.89) 171.82,143.53 UH1.K38
  BOTTOM w0.102: JDOCK1.40 127.34,170.59 v3(127.26,170.68)
DPD_CA_DET: length 92.5
  TOP w0.102: v3(178.31,156.64) 178.56,156.39 U23.4 ; v3(180.13,162.04) 180.01,162.04 R491.2 U24.2 177.17,161.41 177.04,161.54 177.04,162.09 176.64,162.49 173.67,162.49 173.32,162.13 173.32,161.53 173.19,161.41 Q331.5 ; U23.1 178.39,154.44 178.28,154.56 v3(178.28,154.62)
  IN3 w0.127: v3(128.65,165.53) 130.18,164.01 143.77,164.01 144.72,163.06 150.81,163.06 153.54,160.33 163.52,160.33 163.96,160.77 165.04,160.77 167.13,162.87 177.29,162.87 178.5,161.66 179.74,161.66 v3(180.13,162.04)
  BOTTOM w0.102: v3(180.13,162.04) 179.11,161.03 178.25,161.03 176.89,159.67 v1(176.89,158.55) 176.89,157.09 177.33,156.64 v3(178.31,156.64) 177.67,156.01 177.23,156.01 176.88,155.66 176.88,155.12 177.45,154.56 178.22,154.56 v3(178.28,154.62) ; v3(128.65,165.53) 127.83,164.71 125.73,164.71 125.48,164.96 123.64,164.96 122.24,163.57 119.6,163.57 118.84,162.81 JDOCK1.5
DPD_CA_DET#: length 18
  TOP w0.102: v3(176.37,156.33) 176.15,156.33 175.64,156.84 174.99,156.84 174.79,157.04 U23.10 ; U23.13 174.72,155.09 175.31,154.5 v3(175.42,154.5) ; U24.4 Q331.3 174.36,162.06 174.16,162.26 173.78,162.26 173.55,162.03 173.55,160.39 173.74,160.2 174.51,160.2 R416.2 175.22,159.49 v3(175.22,158.75)
  BOTTOM w0.102: v3(175.22,158.75) 175.22,158.46 175.64,158.04 175.78,158.04 176.66,157.17 176.66,156.61 v3(176.37,156.33) 176.65,156.05 176.65,154.93 v1(176.44,154.71) 176.23,154.5 v3(175.42,154.5)
DPD_CPU_LANE_N0: length 76.8
  IN1 w0.089: 131.07,111.48 131.07,111.47 131.05,111.46 131.05,109.98 130.51,109.43 130.51,108.93 130.06,108.48 130.06,104.91 130.18,104.8 130.8,104.8 130.99,104.61 130.99,104.49 131.28,104.2 v3(131.47,104.2)
  IN1 w0.114: 131.07,111.48 131.07,112.28 132.76,113.97 135.13,113.97 141.24,120.09 141.24,148.44 139.68,150.01 133.56,150.01 132.88,150.69 131.6,150.69 130.49,151.81 124.4,151.81 123.56,152.64 122.75,152.64 122.61,152.79 122.61,152.89 v3(122.79,153.06)
  BOTTOM w0.089: v3(131.47,104.2) JCPU1.P29
  BOTTOM w0.102: v3(122.79,153.06) 122.56,153.29 122.56,153.53 122.28,153.81 120.89,153.81 120.12,154.57 120.12,154.73 C679.2
DPD_CPU_LANE_N0_C: length 0.9
  BOTTOM w0.102: C679.1 RE8.2
DPD_CPU_LANE_N1: length 76.8
  IN1 w0.089: 132.04,111.73 132.04,111.71 132.03,111.7 132.03,111.63 132.02,111.62 132.02,110.02 131.64,109.64 131.39,109.64 131.07,109.32 131.07,105.12 131.41,104.78 131.71,104.78 132.07,104.41 132.07,103.6 v3(132.47,103.2)
  IN1 w0.114: v3(124.54,153.06) 124.41,152.93 124.41,152.82 124.7,152.53 130.79,152.53 131.88,151.44 132.44,151.44 132.79,151.79 136.05,151.79 137.1,150.73 140.01,150.73 141.98,148.76 141.98,119.74 135.47,113.24 133.44,113.24 132.04,111.84 132.04,111.73
  BOTTOM w0.089: v3(132.47,103.2) JCPU1.N28
  BOTTOM w0.102: C683.2 121.92,154.75 121.92,154.66 122.07,154.51 122.61,154.51 123.17,153.95 124.11,153.95 124.34,153.72 124.34,153.27 v3(124.54,153.06)
DPD_CPU_LANE_N1_C: length 0.9
  BOTTOM w0.102: C683.1 RE10.2
DPD_CPU_LANE_N2: length 73.2
  IN1 w0.089: 132.92,111.23 132.92,111.21 132.91,111.2 132.91,110.91 132.47,110.47 132.47,109.81 132.11,109.44 132.11,105.77 131.78,105.45 131.62,105.45 v3(131.45,105.27)
  IN1 w0.114: 132.92,111.23 132.92,111.64 133.8,112.51 136.53,112.51 142.71,118.69 142.71,149.06 140.31,151.46 138.24,151.46 136.86,152.84 134.11,152.84 133.69,153.25 125.37,153.25 124.65,153.98 123.83,153.98 123.72,154.08 123.72,154.2 v3(123.95,154.43)
  BOTTOM w0.089: v3(131.45,105.27) 131.9,105.73 JCPU1.P31
  BOTTOM w0.102: v3(123.95,154.43) 123.72,154.67 123.72,154.77 C685.2
DPD_CPU_LANE_N2_C: length 0.9
  BOTTOM w0.102: C685.1 RE14.2
DPD_CPU_LANE_N3: length 73.2
  IN1 w0.089: 133.67,110.97 133.67,110.96 133.65,110.94 133.65,110.24 133.07,109.65 133.07,104.61 132.84,104.38 132.64,104.38 v3(132.47,104.22)
  IN1 w0.114: 133.67,110.97 133.67,111.31 133.94,111.58 136.68,111.58 143.43,118.34 143.43,149.36 140.61,152.18 138.54,152.18 136.87,153.85 134.3,153.85 134.18,153.98 125.67,153.98 125.53,154.12 125.53,154.25 v3(125.71,154.43)
  BOTTOM w0.089: JCPU1.N30 132.94,104.68 v3(132.47,104.22)
  BOTTOM w0.102: v3(125.71,154.43) 125.48,154.66 125.48,154.75 C689.2
DPD_CPU_LANE_N3_C: length 0.9
  BOTTOM w0.102: C689.1 RE16.2
DPD_CPU_LANE_P0: length 76.7
  IN1 w0.089: v3(130.47,104.2) 130.61,104.2 130.78,104.37 130.78,104.53 130.71,104.6 130.09,104.6 129.86,104.83 129.86,108.57 130.3,109.01 130.3,109.51 130.85,110.06 130.85,111.46 130.84,111.47 130.84,111.48
  IN1 w0.114: 130.84,111.48 130.84,112.38 132.66,114.2 135.03,114.2 141.02,120.18 141.02,148.35 139.58,149.78 133.47,149.78 132.79,150.46 131.51,150.46 130.39,151.58 124.31,151.58 123.47,152.42 122.66,152.42 122.38,152.69 122.38,152.89 v3(122.2,153.06)
  BOTTOM w0.089: v3(130.47,104.2) JCPU1.R29
  BOTTOM w0.102: C690.2 119.91,154.73 119.91,154.48 120.8,153.6 122.19,153.6 122.35,153.44 122.35,153.21 v3(122.2,153.06)
DPD_CPU_LANE_P0_C: length 0.9
  BOTTOM w0.102: C690.1 RE7.2
DPD_CPU_LANE_P1: length 76.8
  IN1 w0.089: 131.82,111.73 131.82,110.1 131.56,109.85 131.3,109.85 130.86,109.41 130.86,105.04 131.33,104.57 131.63,104.57 131.87,104.33 131.87,103.6 v3(131.47,103.2)
  IN1 w0.114: v3(123.96,153.06) 124.18,152.84 124.18,152.73 124.61,152.3 130.69,152.3 131.78,151.21 132.54,151.21 132.89,151.56 135.96,151.56 137.01,150.5 139.91,150.5 141.75,148.67 141.75,119.84 135.38,113.46 133.35,113.46 131.82,111.93 131.82,111.73
  BOTTOM w0.089: v3(131.47,103.2) JCPU1.P28
  BOTTOM w0.102: C681.2 121.71,154.71 121.71,154.57 121.99,154.3 122.53,154.3 123.08,153.74 124.02,153.74 124.12,153.63 124.12,153.23 v3(123.96,153.06)
DPD_CPU_LANE_P1_C: length 0.9
  BOTTOM w0.102: C681.1 RE9.2
DPD_CPU_LANE_P2: length 73.2
  IN1 w0.089: 132.69,111.23 132.69,111.21 132.71,111.2 132.71,110.99 132.27,110.56 132.27,109.89 131.9,109.52 131.9,105.86 131.7,105.65 131.57,105.65 131.47,105.76 v3(131.47,106.2)
  IN1 w0.114: 132.69,111.23 132.69,111.73 133.7,112.74 136.43,112.74 142.48,118.79 142.48,148.97 140.21,151.23 138.15,151.23 136.76,152.61 134.01,152.61 133.6,153.03 125.28,153.03 124.56,153.75 123.73,153.75 123.5,153.98 123.5,154.3 v3(123.37,154.43)
  BOTTOM w0.089: JCPU1.R31 131,105.73 v3(131.47,106.2)
  BOTTOM w0.102: v3(123.37,154.43) 123.51,154.57 123.51,154.69 C692.2
DPD_CPU_LANE_P2_C: length 0.9
  BOTTOM w0.102: C692.1 RE13.2
DPD_CPU_LANE_P3: length 73.3
  IN1 w0.089: 133.44,110.97 133.44,110.96 133.45,110.94 133.45,110.32 132.87,109.74 132.87,104.7 132.76,104.59 132.64,104.59 132.41,104.82 v3(132.41,105.16)
  IN1 w0.114: v3(125.12,154.43) 125.3,154.25 125.3,154.03 125.58,153.75 134.08,153.75 134.21,153.62 136.78,153.62 138.45,151.95 140.51,151.95 143.2,149.27 143.2,118.43 136.58,111.81 133.85,111.81 133.44,111.41 133.44,110.97
  BOTTOM w0.089: v3(132.41,105.16) 131.97,104.73 JCPU1.P30
  BOTTOM w0.102: C687.2 125.27,154.71 125.27,154.58 v3(125.12,154.43)
DPD_CPU_LANE_P3_C: length 0.9
  BOTTOM w0.102: C687.1 RE15.2
DPD_DOCK_AUX: length 61.3
  TOP w0.102: U23.3 177.34,155.74 177.26,155.82 175.33,155.82 175.04,156.1 v3(175.04,156.27) 174.88,156.27 174.76,156.39 U23.11
  IN4 w0.114: v3(126.23,163.42) 126.44,163.21 126.44,162.85 126.68,162.61 128.07,162.61 128.42,162.96 133,162.96 135.48,160.48 141.51,160.48 141.92,160.07 143.14,160.07 143.61,160.54 151.35,160.54 151.67,160.23 154.03,160.23 155.59,158.66 161.46,158.66 162.5,157.62 165.01,157.62 165.64,156.99 167.88,156.99 168.48,156.39 174.92,156.39 v3(175.04,156.27)
  BOTTOM w0.102: v3(126.23,163.42) 126.41,163.23 126.41,163.09 125.98,162.66 125.98,162.59 125.95,162.55 125.95,162.41 125.84,162.3 JDOCK1.33
DPD_DOCK_AUX#: length 62.3
  TOP w0.102: U23.6 177.77,157.69 177.17,157.09 176.85,157.09 176.55,157.39 v3(175.81,157.39) 174.86,158.34 U23.8
  IN4 w0.114: v3(175.81,157.39) 175.38,156.96 174.82,156.96 174.47,156.62 168.57,156.62 167.98,157.22 165.74,157.22 165.1,157.85 162.6,157.85 161.56,158.89 155.68,158.89 154.12,160.45 151.77,160.45 151.45,160.77 143.51,160.77 143.04,160.3 142.01,160.3 141.61,160.71 135.57,160.71 133.09,163.19 128.32,163.19 127.97,162.84 126.77,162.84 126.67,162.95 126.67,163.28 v3(126.81,163.42)
  BOTTOM w0.102: JDOCK1.35 126.34,162.3 126.2,162.44 126.2,162.57 126.62,163 126.62,163.23 v3(126.81,163.42)
DPD_DOCK_LANE_N0: length 3.7
  BOTTOM w0.102: JDOCK1.11 120.34,160.2 120.2,160.06 v4(120.2,158.93) 120.2,158.03 RE8.1
DPD_DOCK_LANE_N1: length 3.8
  BOTTOM w0.102: RE10.1 121.86,158.14 121.86,158.32 121.7,158.49 v4(121.7,158.87) 121.7,160.06 121.84,160.2 JDOCK1.17
DPD_DOCK_LANE_N2: length 3.9
  BOTTOM w0.102: RE14.1 123.7,158.08 v4(123.7,158.8) 123.7,159.31 123.2,159.82 123.2,160.26 123.34,160.41 JDOCK1.23
DPD_DOCK_LANE_N3: length 4
  BOTTOM w0.102: RE16.1 125.43,158.12 v4(125.43,158.74) 125.43,159.34 124.7,160.07 124.7,160.18 124.84,160.33 JDOCK1.29
DPD_DOCK_LANE_P0: length 3.7
  BOTTOM w0.102: JDOCK1.9 119.84,160.2 119.98,160.06 119.98,159.25 119.95,159.22 119.95,158.61 119.98,158.58 119.98,158.18 RE7.1
DPD_DOCK_LANE_P1: length 3.8
  BOTTOM w0.102: JDOCK1.15 121.34,160.2 121.48,160.06 121.48,159.18 121.47,159.17 121.47,158.57 121.48,158.55 121.48,158.4 121.65,158.24 121.65,158.06 RE9.1
DPD_DOCK_LANE_P2: length 3.9
  BOTTOM w0.102: JDOCK1.21 122.84,160.41 122.98,160.26 122.98,159.73 123.49,159.22 123.49,159.1 123.47,159.08 123.47,158.53 123.49,158.51 123.49,158.12 RE13.1
DPD_DOCK_LANE_P3: length 4
  BOTTOM w0.102: RE15.1 125.22,158.08 125.22,158.45 125.21,158.47 125.21,159.01 125.22,159.03 125.22,159.25 124.48,159.99 124.48,160.2 124.34,160.35 JDOCK1.27
DPD_PCH_DOCK_AUX: length 20.4
  TOP w0.102: v3(172.66,145.24) 172.5,145.24 172.37,145.11 172.37,144.96 172.51,144.82 172.98,144.82 173.15,144.98 173.15,145.77 173.86,146.48 173.86,147.63 174.46,148.22 174.46,149.56 176.27,151.37 178.22,151.37 178.24,151.39 178.79,151.39 178.8,151.37 178.82,151.37 182.88,155.44 182.88,156.2 182.77,156.31 182.36,156.31 182.26,156.21 C367.2
  BOTTOM w0.089: v3(172.66,145.24) 172.66,145.26 172.27,145.65 172.27,146.09 UH1.J44
DPD_PCH_DOCK_AUX#: length 20.3
  TOP w0.102: C368.2 182.51,156.53 182.85,156.53 183.09,156.29 183.09,155.35 178.9,151.16 v4(178.51,151.16) 176.36,151.16 174.67,149.48 174.67,148.14 174.08,147.54 174.08,146.4 173.36,145.68 173.36,144.9 173.07,144.61 v3(172.18,144.61)
  BOTTOM w0.089: UH1.J42 172.29,145.22 172.29,145.09 172.22,145.02 172.04,145.02 171.95,144.93 171.95,144.84 v3(172.18,144.61)
DPD_PCH_DOCK_AUX#_C: length 2
  TOP w0.102: U23.5 180.39,157.04 180.91,156.52 181.09,156.52 C368.1
DPD_PCH_DOCK_AUX_C: length 2.1
  TOP w0.102: U23.2 180.55,155.09 C367.1
DPD_PCH_DOCK_HPD: length 74.8
  TOP w0.102: C695.1 R757.1 127.95,162.61 v1(128.56,163.22) 128.78,163.44 v3(128.78,164.08)
  IN3 w0.127: v3(173.16,144.13) 173.43,144.4 173.43,145.55 174.88,147.01 174.88,151.18 175.77,152.07 175.77,153.66 177.42,155.31 177.42,158.23 175.13,160.52 164.06,160.52 163.63,160.08 153.43,160.08 150.83,162.68 144.63,162.68 143.64,163.67 129.19,163.67 v3(128.78,164.08)
  BOTTOM w0.089: UH1.H39 v3(173.16,144.13)
  BOTTOM w0.102: JDOCK1.39 127.34,162.64 v3(128.78,164.08)
DPRSLPVR_R: length 6.7
  TOP w0.102: PR616.2 18.47,144.26 v1(18.47,142.53)
  TOP w0.203: PR616.2 18.68,145.39 19.19,145.39 19.98,146.18 19.98,147.08 20.2,147.31 PU600.39
DQA0_0: length 34.5
  BOTTOM w0.089: 83.28,128.53 83.11,128.7 80.4,128.7 UV1.K27 ; UV5.M13 89,105.65 90.21,105.65
  BOTTOM w0.13: 90.21,105.65 90.42,105.65 91.86,107.09 91.86,110.99 90.4,112.45 90.4,123.91 v1(86.68,127.63) 85.28,129.02 84.2,129.02 83.71,128.53 83.28,128.53
DQA0_1: length 31.5
  BOTTOM w0.089: UV1.J29 81.28,128.5 82.97,128.5 83.17,128.29 ; 90.21,106.48 90.2,106.48 89.02,106.48 UV5.N13
  BOTTOM w0.13: 83.17,128.29 83.18,128.29 83.19,128.3 83.92,128.3 84.19,128.56 85.04,128.56 v1(88.39,125.21) 88.77,124.83 88.77,123.67 89.94,122.5 89.94,112.18 91.4,110.72 91.4,107.39 90.49,106.48 90.21,106.48
DQA0_2: length 22.6
  BOTTOM w0.089: UV5.T13 88.2,108.86 88.2,109.46 87.9,109.76 ; 82.94,127.03 81.75,127.03 UV1.H30
  BOTTOM w0.13: 87.9,109.76 87.03,110.63 v1(87.03,112.7) 87.03,120.93 85.99,121.97 85.99,123.65 83.3,126.35 83.3,126.67 82.94,127.03
DQA0_3: length 21.2
  BOTTOM w0.089: UV5.U13 88.6,109.76 ; UV1.H32 82.32,127.26 83.04,127.26
  BOTTOM w0.13: 83.04,127.26 86.45,123.84 86.45,122.16 87.49,121.13 v1(87.49,115.94) 87.49,110.88 88.6,109.76
DQA0_4: length 20.7
  BOTTOM w0.089: UV5.U11 87,109.89 ; 82.89,126.11 82.6,126.11 82.41,126.3 81.28,126.3 UV1.G29
  BOTTOM w0.13: 82.89,126.11 85.53,123.46 85.53,121.78 v1(86.04,121.27) 86.57,120.74 86.57,110.4 87,109.96 87,109.89
DQA0_5: length 21.8
  BOTTOM w0.089: 85.73,109.89 85.73,109.08 85.98,108.83 86.64,108.83 UV5.T11 ; UV1.F28 80.95,125.8 81.25,126.1 82.31,126.1 82.56,125.85 82.56,125.78
  BOTTOM w0.13: 82.56,125.78 84.09,124.26 84.09,124.23 85.07,123.24 85.07,121.59 85.73,120.94 v1(85.73,117.66) 85.73,109.89
DQA0_6: length 22.4
  BOTTOM w0.089: 82.42,125.6 82.38,125.6 UV1.F32
  BOTTOM w0.13: 82.42,125.6 83.83,124.19 83.83,123.84 84.61,123.05 v1(84.61,115.56) 84.61,112.32 84.96,111.97 84.96,107.39 85.09,107.27 85.09,106.87 85.49,106.48 86.59,106.48 UV5.N11
DQA0_7: length 24.2
  BOTTOM w0.089: UV1.F30 81.71,125.8 82.18,125.32 82.37,125.32
  BOTTOM w0.13: UV5.M11 86.62,105.64 84.92,105.64 83.98,106.58 v1(83.98,119.5) 83.98,122.95 83.59,123.33 83.59,124.1 82.37,125.32
DQA0_8: length 24.7
  TOP w0.089: UV4.F4 v3(81,105.66)
  IN1 w0.127: v3(81,105.66) 81.4,105.26 82.76,105.26 83.62,106.12 83.62,106.93 85.74,109.05 85.74,113.21 83.96,114.99 83.96,119.39 v3(81.92,121.43)
  BOTTOM w0.1: UV1.C30 81.76,123.55 81.76,123.29 82.23,122.82 82.23,121.74 v3(81.92,121.43)
DQA0_9: length 29.6
  TOP w0.089: UV4.F2 v3(79.4,104.86)
  IN1 w0.127: v3(79.4,104.86) 79.8,104.46 82.76,104.46 84.08,105.78 84.08,106.74 86.17,108.83 86.17,113.67 84.42,115.41 84.42,121.38 80.41,125.4 v3(80.18,125.4)
  BOTTOM w0.13: UV1.F27 v3(80.18,125.4)
DQA0_10: length 22.2
  TOP w0.089: UV4.E2 v3(79.4,106.46)
  IN1 w0.127: v3(79.4,106.46) 79.8,106.86 82.25,106.86 83.85,108.46 83.85,113.18 83.05,113.99 83.05,119.26 80.57,121.73 v3(80.57,122.68)
  BOTTOM w0.1: v3(80.57,122.68) 80.65,122.75 80.65,123.33 UV1.A28
DQA0_11: length 23.3
  TOP w0.089: UV4.E4 v3(81,106.46)
  IN1 w0.127: v3(81,106.46) 81.4,106.06 82.1,106.06 85.31,109.27 85.31,112.13 84.62,112.82 84.62,113.48 83.51,114.59 83.51,119.28 81.47,121.31 v3(81.47,121.76)
  BOTTOM w0.1: UV1.C28 80.58,123.84 81.01,123.41 81.01,123.24 81.13,123.12 81.13,122.79 81.47,122.45 v3(81.47,121.76)
DQA0_12: length 16.8
  TOP w0.089: UV4.A4 v3(81,109.66)
  IN1 w0.127: v3(81,109.66) 81.09,109.75 81.09,112.59 80.56,113.12 80.56,119.4 80.33,119.62 80.33,120.39 v3(80.46,120.53)
  BOTTOM w0.089: 79.48,123.27 79.48,124.7 UV1.E27
  BOTTOM w0.1: v3(80.46,120.53) 80.46,121.72 79.58,122.6 79.58,123.17 79.48,123.27
DQA0_13: length 19.4
  TOP w0.089: UV4.B4 v3(81,108.86)
  IN1 w0.127: v3(81,108.86) 80.6,109.27 80.6,112.47 79.72,113.35 79.72,120.57 v3(80.07,120.92)
  BOTTOM w0.089: v3(80.07,120.92) 80.07,121.79 79.38,122.47 79.38,123.08 79.28,123.18 79.28,126.3 UV1.G26
DQA0_14: length 17.4
  TOP w0.089: UV4.B2 v3(79.4,108.86)
  IN1 w0.127: v3(79.4,108.86) 79.81,109.27 79.81,112.65 79.14,113.31 79.14,121.61 v3(79.27,121.74)
  BOTTOM w0.089: UV1.D26 78.68,124.3 78.68,123.11 78.61,123.04 78.61,122.71 78.82,122.5 79.06,122.5
  BOTTOM w0.1: v3(79.27,121.74) 79.27,122.28 79.06,122.5
DQA0_15: length 17.5
  TOP w0.089: UV4.A2 v3(79.4,109.66)
  IN1 w0.127: v3(78.86,122.12) 78.57,121.83 78.57,113.28 79.22,112.63 79.22,109.85 v3(79.4,109.66)
  BOTTOM w0.089: v3(78.86,122.12) 78.41,122.58 78.41,123.2 78.48,123.27 78.48,125.5
  BOTTOM w0.1: UV1.F25 78.48,125.5
DQA0_16: length 27.9
  BOTTOM w0.089: 78.31,122.11 78.31,122.27 78.21,122.37 78.21,123.37 UV1.A25 ; UV5.F4 80.92,100.94 78.68,100.94
  BOTTOM w0.13: 78.68,100.94 78.21,101.41 78.21,112.65 81.04,115.48 v1(81.04,118.42) 81.04,119.18 80.39,119.83 80.39,120.03 78.31,122.11
DQA0_17: length 28.5
  BOTTOM w0.089: 78.01,122.08 78.01,123.15 77.88,123.27 77.88,123.54 77.91,123.57 77.91,123.92 77.91,123.93 UV1.C25
  BOTTOM w0.13: UV5.F2 79.41,100.06 78.24,100.06 77.75,100.56 77.75,112.84 80.58,115.68 v1(80.58,116.07) 80.58,119.19 80.08,119.69 80.08,120.01 78.01,122.08
DQA0_18: length 29.9
  BOTTOM w0.089: 78.04,99.37 78.17,99.24 79.38,99.24 UV5.E2 ; UV1.E25 77.68,123.98 77.68,123.17 77.81,123.05 77.81,122.37 77.73,122.29 77.73,121.98
  BOTTOM w0.13: 78.04,99.37 77.29,100.13 77.29,113.03 v1(78.58,114.33) 79.64,115.39 79.64,119.24 79.44,119.44 79.44,120.26 77.73,121.98
DQA0_19: length 32.6
  BOTTOM w0.089: UV5.E4 81.05,99.3 79.71,99.3 79.38,98.96 79.38,98.73 79.13,98.48 78.04,98.48 ; 77.5,122.23 77.01,122.72 77.01,123.08 77.08,123.15 77.08,124.3 UV1.D24
  BOTTOM w0.13: 78.04,98.48 76.83,99.7 v1(76.83,111.5) 76.83,113.22 79.18,115.58 79.18,119.89 77.5,121.57 77.5,122.23
DQA0_20: length 35.4
  BOTTOM w0.089: 79.19,95.85 79.38,96.03 79.38,96.83 UV5.B2 ; 76.8,122.03 76.41,122.42 76.41,123.1 76.28,123.23 76.28,124.3 UV1.E23
  BOTTOM w0.13: 76.8,122.03 76.8,119.56 76.86,119.5 76.86,116.54 v1(75.95,115.62) 74.51,114.19 74.51,98.74 77.73,95.51 78.85,95.51 79.19,95.85
DQA0_21: length 37.3
  BOTTOM w0.089: UV1.F23 76.08,124.57 76.08,123.12 76.21,123 76.21,122.32 76.57,121.96 ; UV5.A2 79.8,95.85 79.8,95.85
  BOTTOM w0.13: 79.8,95.85 79.8,95.73 79.12,95.05 76.77,95.05 74.05,97.78 v1(74.05,112.96) 74.05,114.38 76.4,116.73 76.4,119.82 76.57,119.99 76.57,121.96
DQA0_22: length 39.6
  BOTTOM w0.089: 76.34,121.76 76.34,121.92 75.9,122.36 75.74,122.36 75.38,122.71 75.38,123.05 75.48,123.15 75.48,123.17 75.48,124.3 UV1.D22 ; 80.68,95.85 80.96,96.13 80.96,96.82 UV5.B4
  BOTTOM w0.13: 80.68,95.85 79.43,94.59 76.25,94.59 73.59,97.25 v1(73.59,104.26) 73.59,114.57 75.94,116.92 75.94,119.69 76.34,120.09 76.34,121.76
DQA0_23: length 41.4
  BOTTOM w0.089: 76.11,121.69 76.11,121.88 75.83,122.16 75.64,122.16 75.18,122.62 75.18,123.16 75.28,123.25 75.28,125.5 UV1.F21
  BOTTOM w0.13: 76.11,121.69 76.11,120.18 75.48,119.56 75.48,117.11 73.13,114.76 v1(73.13,99.94) 73.13,97.06 76.06,94.13 79.62,94.13 81.4,95.92 UV5.A4
DQA0_24: length 40.8
  TOP w0.089: UV4.M13 v3(88.2,100.06)
  IN1 w0.127: v3(88.2,100.06) 87.01,101.26 84.63,101.26 82.2,98.82 82.2,98.29 81.96,98.05 80,98.05 78.79,99.25 78.1,99.25 76.84,100.51 76.84,118.83 75.32,120.35 75.32,121.08 v3(74.73,121.67)
  BOTTOM w0.089: UV1.E21 74.48,124.5 74.48,123.16 74.56,123.08 74.56,121.85
  BOTTOM w0.1: 74.56,121.85 v3(74.73,121.67)
DQA0_25: length 39.6
  TOP w0.089: UV4.M11 v3(86.6,100.06)
  IN1 w0.127: v3(86.6,100.06) 86.21,100.46 84.97,100.46 82.66,98.14 82.66,97.95 81.97,97.27 79.83,97.27 78.74,98.35 77.65,98.35 76.24,99.77 76.24,118.89 75.06,120.06 75.06,120.78 v3(74.73,121.11)
  BOTTOM w0.089: 73.88,123.15 73.88,124.3 UV1.D20
  BOTTOM w0.1: 73.88,123.15 73.78,123.05 73.78,122.63 74.27,122.14 74.27,121.58 v3(74.73,121.11)
DQA0_26: length 41.6
  TOP w0.089: UV4.N11 v3(86.6,99.26)
  IN1 w0.127: v3(86.6,99.26) 86.2,99.67 85.26,99.67 82.06,96.47 79.87,96.47 78.93,97.4 77.83,97.4 75.69,99.54 75.69,118.89 v3(74.67,119.91)
  BOTTOM w0.089: UV1.F19 73.69,125.49 73.69,123.23 73.57,123.12
  BOTTOM w0.1: 73.57,123.12 73.57,122.35 74.07,121.86 74.07,120.51 v3(74.67,119.91)
DQA0_27: length 41
  TOP w0.089: UV4.N13 v3(88.2,99.26)
  IN1 w0.127: v3(74.68,119.28) 75.26,118.7 75.26,99.36 78.05,96.58 79.06,96.58 79.51,96.13 82.61,96.13 85.34,98.86 87.8,98.86 v3(88.2,99.26)
  BOTTOM w0.089: UV1.A19 73.38,123.39 73.38,122.26
  BOTTOM w0.1: 73.38,122.26 73.81,121.83 73.81,120.15 v3(74.68,119.28)
DQA0_28: length 46
  TOP w0.089: UV4.T11 v3(86.6,96.86)
  IN1 w0.127: v3(86.6,96.86) 86.2,96.46 86.2,96.45 83.41,93.66 77.69,93.66 71.82,99.54 71.82,119.24 72.5,119.92 v3(73.37,119.92)
  BOTTOM w0.089: UV1.D18 72.28,124.3 72.28,123.15 72.18,123.05 72.18,122.81
  BOTTOM w0.1: v3(73.37,119.92) 72.76,120.53 72.76,122.23 72.18,122.81
DQA0_29: length 49.5
  TOP w0.089: UV4.U13 v3(88.2,96.06)
  IN1 w0.127: v3(71.91,120.23) 70.96,119.28 70.96,99.18 77.34,92.8 83.77,92.8 85.46,94.48 86.74,94.48 88.2,95.94 v3(88.2,96.06)
  BOTTOM w0.089: UV1.F17 72.08,125.12 72.08,123.25 71.98,123.15 71.98,122.73
  BOTTOM w0.1: 71.98,122.73 72.56,122.15 72.56,120.89 v3(71.91,120.23)
DQA0_30: length 49.6
  TOP w0.089: UV4.T13 v3(88.2,96.86)
  IN1 w0.127: v3(71.91,121.42) 70.52,120.04 70.52,99 77.16,92.37 83.95,92.37 85.63,94.05 87.29,94.05 88.61,95.37 88.61,96.45 v3(88.2,96.86)
  BOTTOM w0.089: UV1.A17 71.78,122.64
  BOTTOM w0.1: 71.78,122.64 72.29,122.14 72.29,121.8 v3(71.91,121.42)
DQA0_31: length 45.1
  TOP w0.089: UV4.U11 v3(86.6,96.06)
  IN1 w0.127: v3(86.6,96.06) 86.05,95.51 85.87,95.51 83.59,93.23 77.52,93.23 71.39,99.36 71.39,119.13 72.3,120.05 72.3,121.58 v3(71.91,121.98)
  BOTTOM w0.089: 71.91,122.23 71.58,122.55 71.58,123.17 71.48,123.27 71.48,123.52 71.48,123.53 UV1.C17
  BOTTOM w0.1: 71.91,122.23 v3(71.91,121.98)
DQA1_0: length 26.4
  BOTTOM w0.089: UV1.E17 71.28,124.5 71.28,123.14 71.34,123.01 71.38,122.96 71.38,122.63 71.38,122.15 71.46,122.07
  BOTTOM w0.13: 71.46,122.07 71.46,120.12 71.74,119.84 72.88,119.84 73.02,119.69 73.02,116.87 72.21,116.06 v1(72.21,110.29) 72.21,106.46 70.61,104.87 67.46,104.87 UV6.F4
DQA1_1: length 23.1
  BOTTOM w0.089: 71.18,121.97 70.58,122.57 70.58,123.05 70.68,123.15 70.68,124.3 UV1.D16
  BOTTOM w0.13: 71.18,121.97 71.18,120.07 71.69,119.56 72.33,119.56 72.56,119.33 72.56,117.06 71.75,116.25 v1(71.75,107.43) 71.75,106.92 70.49,105.66 69.06,105.66 UV6.F2
DQA1_2: length 22.8
  BOTTOM w0.089: 70.93,121.9 70.38,122.45 70.38,123.15 70.48,123.25 70.48,125.5 UV1.F15
  BOTTOM w0.13: UV6.E2 69.07,106.47 70.35,106.47 71.29,107.41 v1(71.29,114.8) 71.29,116.44 72.1,117.25 72.1,118.82 70.93,119.99 70.93,121.9
DQA1_3: length 21.1
  BOTTOM w0.089: 70.66,121.82 70.18,122.3 UV1.A15 ; 70.27,107.31 69.41,107.31 69.03,106.93 69.03,106.72 68.72,106.42 67.42,106.42 UV6.E4
  BOTTOM w0.13: 70.27,107.31 70.3,107.31 70.83,107.84 70.83,116.63 71.64,117.44 v1(71.64,117.72) 71.64,118.92 70.66,119.91 70.66,121.82
DQA1_4: length 17.8
  BOTTOM w0.089: 69.78,121.62 69.56,121.85 69.56,122.1 68.98,122.67 68.98,123.02 69.08,123.12 69.08,124.3 UV1.D14 ; UV6.A2 68.27,109.66 68.27,109.85 67.95,110.16 67.47,110.16
  BOTTOM w0.13: 69.78,121.62 69.78,119.49 69.32,119.03 69.32,118.4 67.19,116.27 v1(67.19,111.5) 67.19,110.45 67.47,110.16
DQA1_5: length 20.7
  BOTTOM w0.089: 69.46,121.6 69.31,121.75 69.31,122.02 68.78,122.55 68.78,123.15 68.88,123.25 68.88,125.12 UV1.F13 ; 66.2,110.2 66.8,109.59 67.19,109.59 67.44,109.34 67.44,109.02 67.63,108.83 68.29,108.83 UV6.B2
  BOTTOM w0.13: 66.2,110.2 66.2,115.93 v1(68.51,118.24) 68.86,118.59 68.86,118.9 69.46,119.49 69.46,121.6
DQA1_6: length 17.8
  BOTTOM w0.089: 69.16,121.23 69.16,121.47 69.08,121.55 69.08,121.92 68.58,122.42 UV1.A13
  BOTTOM w0.13: 69.16,121.23 69.16,119.88 68.4,119.13 68.4,118.78 65.53,115.92 v1(65.53,113.43) 65.53,109.02 65.66,108.89 66.7,108.89 UV6.A4
DQA1_7: length 20.1
  BOTTOM w0.089: UV1.C13 68.28,123.53 68.28,123.52 68.28,123.2 68.38,123.1 68.38,122.25 68.86,121.77 68.86,121.35 68.91,121.3 68.91,121.16
  BOTTOM w0.13: UV6.B4 66.67,108.07 65.22,108.07 65.03,108.26 65.03,116.06 v1(66.21,117.24) 67.94,118.97 67.94,118.99 68.91,119.96 68.91,121.16
DQA1_8: length 26.2
  TOP w0.089: UV3.N13 v3(59.46,106.46)
  IN1 w0.127: v3(66.9,121.5) 67.47,120.93 67.47,120.23 68.15,119.56 68.15,113.13 64.26,109.25 64.26,107.05 64.08,106.86 59.86,106.86 v3(59.46,106.46)
  BOTTOM w0.089: UV1.E11 66.48,124.5 66.48,123.12 66.58,123.02 66.58,122.65
  BOTTOM w0.1: 66.58,122.65 66.42,122.49 66.42,121.98 v3(66.9,121.5)
DQA1_9: length 22.7
  TOP w0.089: UV3.N11 v3(61.86,106.46)
  IN1 w0.127: v3(61.86,106.46) 62.26,106.06 63.91,106.06 64.71,106.86 64.71,109.05 68.58,112.92 68.58,120.39 v3(68,120.97)
  BOTTOM w0.089: UV1.A11 66.98,122.5
  BOTTOM w0.1: 66.98,122.5 67.6,121.88 67.6,121.37 v3(68,120.97)
DQA1_10: length 30
  TOP w0.089: UV3.M13 v3(59.46,105.66)
  IN1 w0.127: v3(59.46,105.66) 60.67,104.46 63.95,104.46 65.92,106.42 65.92,107.24 66.54,107.87 66.54,109.58 69.44,112.48 69.44,121.6 68.99,122.06 v3(66.89,122.06)
  BOTTOM w0.089: v3(66.89,122.06) 66.78,122.16 66.78,123.13 66.68,123.23 66.68,123.52 66.68,123.53 UV1.C11
DQA1_11: length 26.8
  TOP w0.089: UV3.M11 v3(61.86,105.66)
  IN1 w0.127: v3(61.86,105.66) 62.26,105.26 64.12,105.26 65.22,106.35 65.22,108.9 69.01,112.7 69.01,121.09 68.58,121.52 v3(67.98,121.52)
  BOTTOM w0.089: 67.28,125.12 67.28,123.25 67.18,123.15 67.18,122.58 67.82,121.94
  BOTTOM w0.1: v3(67.98,121.52) 67.82,121.69 67.82,121.94 ; UV1.F11 67.28,125.12
DQA1_12: length 18.5
  TOP w0.089: UV3.T13 v3(59.46,108.86)
  IN1 w0.127: v3(59.46,108.86) 59.86,109.26 60.69,109.26 60.96,109.53 60.96,110.59 63.6,113.23 63.6,114.67 64.94,116.01 64.94,119.33 65.18,119.56 65.18,120.38 64.91,120.64 v3(64.73,120.64)
  BOTTOM w0.089: UV1.A9 65.38,122.4
  BOTTOM w0.1: 65.38,122.4 v1(65.38,121.59) 65.38,121.3 v3(64.73,120.64)
