# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ALWON: length 47.9
  TOP w0.102: U51.A60 v3(203.46,77.04)
  TOP w0.254: PR110.1 195.21,43.74 v1(194.38,43.74) 193.45,43.74 v4(192.81,43.11)
  IN3 w0.127: v3(203.46,77.04) 202.91,77.04 202.31,76.44 202.31,75.17 202.82,74.67 202.82,72.35 201.25,70.78 v3(200.87,70.78)
  IN4 w0.102: v3(200.87,70.78) 200.48,70.4 200.48,67.54 200.6,67.43 200.6,60.57 199.46,59.43 196.85,59.43 195.59,58.17 193.56,58.17 192.22,56.82 192.22,50.47 193.04,49.65 193.04,43.34 v4(192.81,43.11)
AND_PWRGD: length 36.2
  TOP w0.102: R3772.2 198.63,90.78 198.4,90.56 U50.4 195.99,90.56 195.52,91.02 v1(194.38,91.02) 193.23,91.02 v3(192.5,90.29) ; v3(192.7,66.14) 192.7,65.88 192.38,65.56 U46.A4
  IN4 w0.102: v3(192.7,66.14) 193.08,66.14 193.46,66.53 193.46,67.28 194.63,68.45 194.63,70.37 193.93,71.07 193.93,73.71 191.82,75.82 191.82,78.69 192.81,79.68 192.81,86.83 192.5,87.15 v3(192.5,90.29)
AUD_HP_NB_SENSE: length 197.3
  TOP w0.102: U46.A41 179.72,67.56 179.12,66.96 v3(179.12,66.96)
  TOP w0.254: JHP1.6 289.79,157.8 288.15,156.16 v2(287.99,156.16) 285.55,156.16 285.13,156.58 284.24,156.58 R1088.1 283.58,156.91 283.24,156.57 283.24,156.23 v3(283.08,156.07)
  IN3 w0.127: v3(283.08,156.07) 282.23,156.07 281.59,155.43 v3(281.59,153.08) 280.61,152.1 277.06,152.1 275.76,153.4 275.76,154.02 275.1,154.68 265.05,154.68 264.48,155.25 263.72,155.25 262.7,154.23 262.38,154.23 261.11,152.96 258.74,152.96 256.6,150.81 253.89,150.81 252.74,149.67 252.74,138.91 249.97,136.15 248.12,136.15 244.11,132.13 244.11,116.16 239.04,111.09 232.22,104.28 232.22,90.56 231.24,89.58 231.24,76.2 230.27,75.23 228.85,75.23 225.76,72.14 225.76,71.12 225.01,70.37 224.46,70.37 221.93,67.85 218.52,67.85 215.46,64.79 207.77,64.79 207.05,64.07 205.38,64.07 203.9,65.54 193.38,65.54 193.31,65.47 191.14,65.47 190.04,64.38 188.99,64.38 188.07,65.3 184.22,65.3 183.22,66.3 181.6,66.3 180.43,67.47 179.6,67.47 179.12,66.98 v3(179.12,66.96)
  BOTTOM w0.254: C1247.1 C972.1 280.49,152.01 280.19,151.71 Q324.2 279.72,152.2 280.6,153.08 v3(281.59,153.08)
AUD_HP_OUT_L: length 9.5
  TOP w0.254: U74.33 275.69,158.47 v3(275.91,158.69)
  TOP w0.381: R1677.2 281.29,158.94 v3(281.31,158.93)
  IN1 w0.381: v3(281.31,158.93) 281.09,159.15 276.16,159.15 275.91,158.9 v3(275.91,158.69)
  BOTTOM w0.102: v1(281.67,156.97) 281.67,158.56 v3(281.31,158.93)
AUD_HP_OUT_L1: length 0.9
  TOP w0.381: L707.1 R1677.1
AUD_HP_OUT_L2: length 10.5
  TOP w0.381: JHP1.1 291,165.39 291,164.48 v3(289.59,163.07) D81.3 287.16,161.23 286.92,161.47 286.01,161.47 285.62,161.09 285.05,161.09 284.44,160.48 284.44,160.12 L707.2
AUD_HP_OUT_R: length 13.1
  TOP w0.102: v2(283.71,151.49) 283.71,151.68 v3(284.1,152.07)
  TOP w0.254: v3(276.48,158.11) 276.34,157.97 U74.32
  IN1 w0.381: v3(284.1,152.07) 283.64,152.07 277.61,158.11 v3(276.48,158.11)
  BOTTOM w0.381: R1679.2 283.9,152.28 v3(284.1,152.07)
AUD_HP_OUT_R1: length 3.3
  BOTTOM w0.102: v1(282.54,153.28) 282.77,153.05 282.77,152 R1679.1
  BOTTOM w0.254: L706.1 R1679.1
AUD_HP_OUT_R2: length 20.8
  TOP w0.381: JHP1.2 294.02,157.9 291.56,155.44 v1(291.56,153.8) 291.56,151.45 290.27,150.17 288.62,150.17 D82.2 286.24,151.04 v3(285.31,150.11)
  BOTTOM w0.381: L706.2 285.09,150.33 v3(285.31,150.11)
AUD_NB_MUTE#: length 202.1
  TOP w0.102: U46.A39 179.44,68.56 179.1,68.22 v3(179.1,68.15)
  TOP w0.254: v3(281.19,158.08) 281.46,157.81 281.46,155.86 R40.1 ; v3(265.42,165.68) 265.57,165.53 R1099.2 265.57,164.3 266.05,163.82 266.32,163.82 C967.1 266.83,162.42 267.27,161.98 v1(267.97,161.98) 268.48,161.98 269.29,161.17 U74.47
  IN3 w0.127: v3(265.42,165.68) 264.5,165.68 263.97,165.15 263.46,165.15 262.56,164.25 262.56,159.89 260.86,158.19 260.86,153.47 260.61,153.22 258.64,153.22 258.57,153.15 256.49,151.07 253.73,151.07 252.49,149.83 252.49,139.02 249.87,136.4 248.02,136.4 243.85,132.24 243.85,116.27 238.78,111.2 231.97,104.38 231.97,90.67 230.99,89.69 230.99,77.69 230.15,76.86 230.15,75.88 229.76,75.48 228.74,75.48 225.49,72.23 225.49,71.22 224.9,70.63 224.35,70.63 221.82,68.1 218.41,68.1 215.35,65.04 207.66,65.04 206.95,64.32 205.48,64.32 204.01,65.8 192.93,65.8 192.86,65.72 190.59,65.72 190.19,65.33 188.4,65.33 188.17,65.56 184.33,65.56 182.75,67.13 181.65,67.13 181.06,67.72 179.51,67.72 179.1,68.13 v3(179.1,68.15)
  IN4 w0.254: v3(281.19,158.08) 280.44,158.83 280.44,164.26 278.92,165.79 275.53,165.79 274.84,166.47 273.71,166.47 273.36,166.83 267.6,166.83 266.88,166.11 266.5,166.11 266.07,165.68 v3(265.42,165.68)
AUD_PC_BEEP: length 3.8
  TOP w0.102: C1105.2 C1106.2 v1(266.42,153.79) 266.64,153.79 267.32,154.47 U74.12
AUD_SENSE_A: length 4.2
  TOP w0.254: R1086.1 269.69,150.55 v1(268.96,151.28) 268.57,151.67 268.57,153.18 268.79,153.4 U74.13
AUD_SENSE_B: length 22.8
  TOP w0.254: v3(272.3,151.09) 270.28,151.09 269.29,152.09 v1(269.29,152.52) U74.14
  IN1 w0.254: v3(287.47,150.17) 286.03,151.6 284.8,151.6 284.44,151.25 275.72,151.25 275.06,151.91 273.12,151.91 v3(272.3,151.09)
  BOTTOM w0.254: R1079.1 v3(287.47,150.17) R1080.1
AUX_EN_WOWL: length 180.3
  TOP w0.102: v3(210.07,140.19) 210.07,142.41 209.56,142.92 v1(209.08,142.92) 207.46,144.54 RP20.5 ; v3(248.9,135.73) 248.9,136.24 241.99,143.15 241.99,145.07 243.65,146.74 v3(244.25,146.74) 245.25,146.74 246.05,147.54 246.05,148.16 246.11,148.21 U57.3
  TOP w0.254: U46.B67 189.37,63.81 v3(189.45,63.89)
  IN1 w0.102: v3(210.07,140.19) 214.74,140.19 216.29,141.73 217.42,141.73 218.25,142.57 220.55,142.57 222.99,145.01 v3(230.29,145.01)
  IN3 w0.127: v3(189.45,63.89) 190.36,63.89 190.82,64.35 193.88,64.35 194.57,65.03 203.6,65.03 205.14,63.5 207.3,63.5 208.08,64.28 215.67,64.28 218.73,67.34 224.49,67.34 232.57,75.42 232.57,104.27 244.36,116.06 244.36,132.03 248.06,135.73 v3(248.9,135.73)
  BOTTOM w0.102: v3(244.25,146.74) 242.52,145.01 v3(230.29,145.01)
BAT1_LED#: length 145
  TOP w0.254: U46.B64 187.87,63.9 v3(187.9,63.93)
  IN1 w0.254: v3(187.9,63.93) 187.9,63.23 188.14,62.98 190.12,62.98 190.36,62.74 192.11,62.74 193.02,63.66 196.54,63.66 197.58,64.7 203.52,64.7 205.04,63.17 206.91,63.17 207.72,62.36 208.89,62.36 209.85,63.32 212.02,63.32 215.07,66.37 v3(220.16,66.37)
  IN4 w0.254: v3(220.16,66.37) 220.54,66.76 220.54,68.19 223.23,70.88 223.23,85.05 222.7,85.58 222.7,91.38 226.06,94.75 226.06,100.89 224.61,102.34 224.61,110.59 223.92,111.29 223.92,114.09 224.61,114.79 224.61,118.88 223.21,120.29 223.21,122.86 223.78,123.43 223.78,131.18 225.06,132.46 225.06,142.83 225.24,143.01 225.24,147.1 226.11,147.98 v3(226.11,150.07)
  BOTTOM w0.254: R953.1 226.06,165.55 225.62,165.1 225.62,164.27 225.28,163.93 Q83.1 224.75,163.93 224.3,163.48 v1(224.3,161.33) 224.3,160.19 224.4,160.09 224.4,157.11 225.32,156.19 225.32,154.87 226.04,154.16 226.04,150.15 v3(226.11,150.07)
BAT1_LED#_Q: length 2.5
  BOTTOM w0.102: v1(226.18,161.79) 227,162.61 R951.1
  BOTTOM w0.254: Q83.6 226.95,163.35 227,163.3 R951.1
BAT2_LED#: length 140.5
  TOP w0.279: U46.A9 191.71,68.06 191.81,68.16 192.57,68.16 192.67,68.26 v3(192.67,68.6)
  IN1 w0.254: v3(192.67,68.6) 195.26,68.6 198.15,65.71 204.73,65.71 205.93,64.51 211.65,64.51 214.45,67.31 220.8,67.31 v3(221.29,66.83)
  IN4 w0.254: v3(226.7,150.07) 226.7,148.02 225.62,146.94 225.62,141.85 225.44,141.67 225.44,132.31 224.16,131.02 224.16,123.27 223.6,122.71 223.6,120.43 224.99,119.04 224.99,114.48 224.39,113.87 224.39,111.42 224.99,110.81 224.99,102.5 226.44,101.05 226.44,94.59 223.08,91.22 223.08,85.74 223.61,85.21 223.61,69.48 221.29,67.16 v3(221.29,66.83)
  BOTTOM w0.254: v3(226.7,150.07) 226.7,150.49 226.42,150.76 226.42,154.36 225.71,155.07 225.71,156.39 224.79,157.3 224.79,162.89 226,164.1 226,164.8 226.43,165.23 Q83.4 226.95,166.34 R958.1
BAT2_LED#_Q: length 3
  BOTTOM w0.102: v1(223.52,163.55) 223.6,163.63 R949.1
  BOTTOM w0.254: Q83.3 224.63,165.23 224.61,165.26 223.95,165.26 R949.1
BATDRV#: length 48.3
  TOP w0.254: v3(54.48,157.28) 54.23,157.03 v1(53.6,157.03) 52.52,157.03 52.2,156.71 50.36,156.71 49.85,157.22 PR722.2 ; v3(93.66,155.31) PQ800.4
  IN3 w0.254: v3(54.48,157.28) 56.58,155.18 59.51,155.18 60.18,154.51 69.47,154.51 69.76,154.8 75.21,154.8 75.91,155.5 91.31,155.5 91.63,155.18 93.54,155.18 v3(93.66,155.31)
BATT_WHITE#: length 53.1
  TOP w0.102: v3(225.24,150.1) v2(225.24,150.75) ; v3(254.28,156.87) 254.28,155.54 255.17,154.65 JLED1.3
  IN4 w0.102: v3(254.28,156.87) 253.9,157.25 251.54,157.25 248.27,153.98 242.3,153.98 241.9,154.37 234.02,154.37 229.32,149.67 227.71,149.67 226.89,150.49 225.62,150.49 v3(225.24,150.1)
  BOTTOM w0.102: R949.2 222.68,160.65 223.42,159.91 223.42,159.72 223.69,159.45 223.69,156.78 224.18,156.29 224.18,154.41 224.88,153.71 224.88,150.46 v3(225.24,150.1)
BATT_WHITE_LED#: length 12
  BOTTOM w0.102: JLVDS1.2 221.04,169.14 221.04,167.71 222.71,166.04 224.84,166.04 225.31,166.51 225.31,166.94 225.6,167.24 225.6,168.3 225.82,168.52 v2(226.44,168.52) 226.7,168.52 226.95,168.27 R958.2
BATT_YELLOW#: length 49.2
  TOP w0.102: v3(253.35,158.07) 253.84,158.07 254.92,157 254.92,155.44 255.67,154.69 JLED1.2 ; v3(227.9,150.07) v2(227.9,150.83)
  IN4 w0.102: v3(227.9,150.07) 229.4,150.07 233.93,154.6 242,154.6 242.39,154.21 248.13,154.21 252,158.07 v3(253.35,158.07)
  BOTTOM w0.102: v3(227.9,150.07) 226.72,151.25 226.72,154.55 226.01,155.26 226.01,156.54 225.71,156.85 225.71,162.47 R951.2
BATT_YELLOW_LED#: length 13.7
  BOTTOM w0.102: JLVDS1.3 220.54,167.19 219.91,166.56 219.91,164.43 v1(220.22,164.12) 221.08,164.12 222.77,165.81 224.98,165.81 225.59,166.42 225.59,166.79 R953.2
BAY_SMBCLK: length 75.3
  TOP w0.102: U51.A7 v3(208.93,72.63) ; RP10.4 209.48,66.37 209.34,66.24 209.34,65.88 208.62,65.16 206.83,65.16 v3(206.67,64.99)
  IN4 w0.102: v3(208.93,72.63) 208.88,72.63 208.48,72.24 208.48,69.58 209.74,68.32 209.74,66.79 208.13,65.17 206.85,65.17 v3(206.67,64.99) ; JSATA2.30 167.62,47.5 167.62,48.41 166.28,49.75 165.05,49.75 164.42,50.38 164.42,58.36 165.04,58.98 165.24,58.98 v3(165.42,58.8)
  BOTTOM w0.102: v3(165.42,58.8) 165.56,58.94 167.71,58.94 168.63,59.86 184.12,59.86 184.5,60.23 184.5,60.64 184.67,60.82 184.67,61.61 186.3,63.23 186.95,63.23 187.43,63.7 187.43,64.86 187.93,65.36 201.9,65.36 202.03,65.23 206.43,65.23 v3(206.67,64.99)
BAY_SMBDAT: length 78
  TOP w0.102: v3(206.67,65.58) 206.86,65.39 208.53,65.39 209.11,65.97 209.11,66.24 208.98,66.37 RP10.3 ; U51.B7 v3(208.68,74.86)
  IN4 w0.102: v3(208.68,74.86) 208.47,74.65 208.47,72.82 208.25,72.61 208.25,69.49 209.51,68.23 209.51,66.88 208.03,65.4 206.85,65.4 v3(206.67,65.58) ; JSATA2.29 166.71,47.05 167.39,47.72 167.39,48.31 166.18,49.52 164.95,49.52 164.19,50.28 164.19,58.46 164.94,59.21 165.24,59.21 v3(165.42,59.39)
  BOTTOM w0.102: v3(206.67,65.58) 206.55,65.46 202.12,65.46 202,65.59 187.83,65.59 187.2,64.95 187.2,63.8 186.86,63.46 186.2,63.46 184.44,61.7 184.44,60.91 184.27,60.73 184.27,60.32 184.03,60.09 168.53,60.09 167.62,59.17 165.63,59.17 v3(165.42,59.39)
BBS_BIT0_R: length 70
  TOP w0.102: v3(155.7,121.34) 156.02,121.66 QH2.1
  IN3 w0.127: v3(201.84,113.21) 201.11,113.21 200.66,112.77 185.84,112.77 184.1,114.51 173.81,114.51 173.54,114.77 170.57,114.77 169.45,115.89 167.61,115.89 165.87,117.63 164.83,117.63 163.62,118.84 161.18,118.84 161.1,118.93 160.53,119.49 160.53,120.09 159.28,121.34 v3(155.7,121.34)
  BOTTOM w0.089: UH1.AU2 160.9,128.41 160.9,127.89 160.49,127.47 160.49,126.62
  BOTTOM w0.102: RH13.1 200.95,107.65 200.61,107.99 200.61,111.4 201.84,112.63 v3(201.84,113.21) ; 160.49,126.62 160.49,126.4 158.88,124.79 158.88,123.05 158.56,122.74 158.12,122.74 158.12,122.74 158.05,122.67 157.84,122.67 157.61,122.44 RH37.2 v1(156.34,121.61) 155.97,121.61 v3(155.7,121.34)
BBS_BIT1: length 8.8
  BOTTOM w0.089: 177.15,132.21 176.08,132.21 175.9,132.39 175.68,132.39 175.35,132.07 UH1.C10
  BOTTOM w0.102: RH119.1 182.54,132.12 180.14,132.12 179.83,131.82 178.68,131.82 v1(178.55,131.94) 178.39,132.11 177.25,132.11 177.15,132.21
BC_CLK_ECE1117: length 49.5
  TOP w0.102: JKB1.9 194.59,102.89 196.05,104.35 201.97,104.35 203.52,102.8 204.98,102.8 207.2,100.57 v1(209.87,100.57) 210.19,100.57 v3(210.38,100.76) ; v3(215.84,76.37) 215.76,76.45 215.46,76.45 215.36,76.54 U51.A20
  IN4 w0.102: v3(210.38,100.76) 211.96,100.76 216.94,95.78 216.94,84.53 215.46,83.05 215.46,77.33 215.84,76.95 v3(215.84,76.37)
BC_CLK_ECE5048: length 36.7
  TOP w0.102: U51.A43 208.43,84.82 v3(208.64,85.02) ; U46.A30 183.12,74.18 v3(183.49,74.56)
  IN1 w0.102: v3(183.49,74.56) 183.63,74.56 183.96,74.22 183.96,73.78 184.4,73.34 186.7,73.34 187.07,73.71 187.07,74.36 186.63,74.81 186.63,75.92 187.21,76.51 188.39,76.51 192.01,80.13 192.01,81.68 194.7,84.37 197.3,84.37 198.22,85.3 204.45,85.3 205.2,86.05 207.62,86.05 v3(208.64,85.02)
BC_DAT_ECE1117: length 53.6
  TOP w0.102: v3(213.03,76.75) 213.41,76.38 213.81,76.38 213.89,76.29 U51.B21 ; v3(210.31,99.18) 208.02,99.18 v1(207.2,100) 204.81,102.39 203.35,102.39 201.8,103.94 198.12,103.94 196.59,102.42 JKB1.7 ; R817.2 217.36,73.4 v3(217.11,73.65)
  IN1 w0.102: v3(213.03,76.75) 213.47,76.32 214.25,76.32 216.92,73.65 v3(217.11,73.65)
  IN4 w0.102: v3(213.03,76.75) 213.03,76.82 213.41,77.19 213.83,77.19 215.05,78.42 215.05,83.22 216.54,84.7 216.54,95.61 214.17,97.98 211.51,97.98 v3(210.31,99.18)
BC_DAT_ECE5048: length 45.4
  TOP w0.102: U51.B45 208.68,82.64 v3(209.17,82.15) ; U46.B31 183.37,71.77 v3(183.45,71.68) ; v3(197.92,82.73) 198.19,82.73 198.29,82.63 198.29,80.09 197.72,79.52 197.72,79.21 195.9,77.4 RP16.1
  IN1 w0.102: v3(183.45,71.68) 183.45,71.69 184.63,72.88 187.65,72.88 188.29,73.52 188.29,74.78 188.79,75.28 188.79,76.33 192.52,80.07 192.52,81.61 193.87,82.96 197.69,82.96 v3(197.92,82.73) 198.52,82.73 198.96,83.18 200.32,83.18 201.92,84.78 206.61,84.78 207.81,83.57 208.01,83.57 208.6,82.98 208.6,82.72 v3(209.17,82.15)
BC_INT#_ECE1117: length 51.3
  TOP w0.102: v3(216.42,75.56) 216.42,75.56 216.01,75.96 215.58,75.96 215.5,76.04 U51.A19 ; v3(218.44,98.86) v1(211.84,98.86) 210.82,98.86 210.69,98.73 207.46,98.73 204.44,101.76 203.41,101.76 201.67,103.5 198.25,103.5 197.59,102.84 JKB1.6
  IN4 w0.102: v3(216.42,75.56) 216.97,75.56 218.31,76.89 218.31,96.64 218.85,97.18 218.85,98.45 v3(218.44,98.86)
BC_INT#_ECE5048: length 36.1
  TOP w0.102: U51.A42 208.93,84.58 209.04,84.7 209.04,85.29 v3(208.71,85.62) ; v3(183.53,73.97) 183.62,73.89 U46.A29
  IN3 w0.127: v3(183.53,73.97) 183.19,73.97 183.01,74.16 183.01,74.73 184.49,76.22 186.17,76.22 186.56,76.61 195.05,76.61 195.43,76.99 198.38,76.99 200.66,79.27 200.66,80.08 202.21,81.62 203.68,81.62 204.44,82.38 204.44,82.72 205.68,83.96 207.6,83.96 208.03,84.38 208.03,85.23 208.42,85.62 v3(208.71,85.62)
  BOTTOM w0.102: v1(182.63,73.07) 183.53,73.97 v3(183.53,73.97)
BCM5882_ALERT#: length 190.3
  TOP w0.102: U46.B62 186.87,63.69 v3(186.69,63.87) ; JUSH1.14 46.77,92.29 48.73,90.33 53.57,90.33 54.34,91.1 v1(54.68,91.1) 72.3,91.1 72.47,91.27 v3(72.47,92.72)
  IN3 w0.127: v3(72.47,92.72) 72.69,92.49 77.45,92.49 78.14,93.18 79.65,93.18 80.04,92.79 85.12,92.79 89.64,88.27 89.64,81.63 87.81,79.8 87.81,63.02 90.67,60.15 105.9,60.15 115.58,50.47 150.26,50.47 154.79,55.01 161.54,55.01 162.33,55.81 164.91,55.81 166.79,57.69 175.49,57.69 178.16,60.36 178.16,64.16 178.89,64.89 180.22,64.89 181.66,63.45 186.36,63.45 186.69,63.78 v3(186.69,63.87)
BEEP: length 115.8
  TOP w0.102: R1120.2 261.82,153.79 261.53,153.49 261.53,152.34 260.05,150.87 v1(256.86,150.87) 254.15,150.87 251.33,153.69 v3(251.32,153.69) ; U51.B19 213.94,75.29 213.74,75.49 213.39,75.49 v3(212.98,75.9)
  IN3 w0.127: v3(251.32,153.69) 251.44,153.58 251.44,150.68 250.71,149.95 250.71,146.16 248.44,143.9 248.44,141.06 244.54,137.16 244.54,136.24 240.96,132.66 240.96,123.09 235.14,117.27 230.11,117.27 227.73,114.89 227.73,106.73 223.42,102.42 223.42,82.65 220.67,79.9 217.75,79.9 217.46,79.62 215.64,79.62 214.57,78.54 214.57,76.76 214.12,76.32 213.4,76.32 v3(212.98,75.9)
BIA_PWM_CVT: length 20.8
  TOP w0.102: U27.19 201.62,159.2 v3(201.7,159.12) ; v3(208.93,154.22) 209.16,153.99 209.16,152.88 209.77,152.26 v1(210.72,152.26) 210.95,152.26 212.04,153.36 D9.2
  IN3 w0.127: v3(201.7,159.12) 203.32,160.74 207.99,160.74 209.68,159.06 209.68,154.97 v3(208.93,154.22)
BIA_PWM_EC: length 94.3
  TOP w0.102: D9.3 212.87,152.06 213.55,151.37 v1(216.23,151.37) 216.46,151.37 216.98,150.85 216.98,147.95 216.47,147.44 216.47,142.67 214.75,140.95 212.36,140.95 207.74,136.33 v3(207.18,136.33) ; v3(212.8,78.45) 213.22,78.03 213.67,78.03 213.93,78.29 U51.B25
  IN2 w0.127: v3(212.8,78.45) 212.8,78.49 213.19,78.87 214.08,78.87 214.91,79.71 214.91,83.42 216.22,84.72 216.22,101.93 218.03,103.74 218.03,109.54 219.09,110.6 219.09,114.85 216.22,117.72 215.58,117.72 214.62,118.69 213.42,118.69 209.97,122.14 209.97,123.55 209.34,124.19 209.34,127.29 208.26,128.37 208.26,135.25 v3(207.18,136.33)
BIA_PWM_LVDS: length 12.8
  TOP w0.102: v3(212.54,163.12) 211.46,162.04 v1(211.46,160.96) 211.46,159.18 209.62,157.34 R429.1 210.95,155.9 211.15,155.69 211.76,155.69 211.9,155.83 U56.4
  BOTTOM w0.102: v3(212.54,163.12) 212.54,163.78 212.76,164.01 R3762.2
BIA_PWM_PCH: length 60.5
  TOP w0.102: U27.21 202.42,159.63 202.94,159.12 203.85,159.12 R114.2 205.56,157.41 207.66,157.41 208.29,156.77 208.29,155.24 207.99,154.93 207.99,151.52 206.18,149.71 196.58,149.71 v1(194.15,147.28) 192.28,145.41 192.28,142.7 193.36,141.62 v3(193.36,140.26)
  IN3 w0.089: v3(171.33,142.6) 171.45,142.48 174.76,142.48 175.21,142.03 178.31,142.03
  IN3 w0.127: 178.31,142.03 181.86,142.03 182.7,141.19 189.69,141.19 190.62,140.26 v3(193.36,140.26)
  BOTTOM w0.089: UH1.N36 171.04,142.6 v3(171.33,142.6)
BLUE_CRT: length 150.1
  IN4 w0.102: v3(129.59,155.48) 129.43,155.64 122.48,155.64 121.82,154.97 113.2,154.97 112.31,154.08 108.73,154.08 102.59,147.94 88.88,147.94 88.45,148.37 80.9,148.37 79.12,146.59 72.33,146.59 71.69,147.22 64.83,147.22 61.77,150.28 58.89,150.28 58.12,151.06 52.21,151.06 45.27,158 44.93,158 38.72,164.21 35.11,164.21 33.56,165.76 29.87,165.76 18.29,177.35 8.32,177.35 6.67,179 3.81,179 v3(3.49,178.68)
  BOTTOM w0.102: JIO1.7 3.07,178.25 v3(3.49,178.68) ; U6.22 132.53,154.3 131.85,154.97 131.25,154.97 v1(130.86,155.36) 130.7,155.53 129.64,155.53 v3(129.59,155.48)
BLUE_DOCK: length 10.5
  TOP w0.102: v3(130.56,154.8) 130.56,155.69 128.84,157.41 v1(128.84,158.99) v3(128.84,159.88)
  BOTTOM w0.102: v3(130.56,154.8) 131,154.36 132.06,154.36 132.53,153.9 U6.21 ; v3(128.84,159.88) JDOCK1.45
BOARD_ID: length 12.7
  TOP w0.102: v3(211.45,68.25) 211.45,67.8 211.13,67.48 R875.2 C744.1 ; U51.B10 210.18,74.48 210.06,74.6 210.06,75.01 v3(209.62,75.46)
  IN2 w0.127: v3(209.62,75.46) 209.78,75.46 210.06,75.17 210.06,73.4 210.66,72.8 210.66,68.8 211.2,68.25 v3(211.45,68.25)
  BOTTOM w0.102: v1(211.23,68.79) 211.45,68.57 v3(211.45,68.25)
BOOT:
  vias: v1(54.48,162.68)
BOOT1:
  vias: v1(126.77,140.59)
BOOT1_1_VGA: length 1.8
  TOP w0.102: v1(28.69,153.85) PC623.1
BOOT1_VGA: length 2.2
  TOP w0.102: PR649.1 27.43,151.5 28.2,152.26 28.74,152.26 v2(29,152.01)
BOOT2:
  vias: v1(121.99,142.89)
BOOT2_2_VGA: length 2.4
  TOP w0.102: v1(17.4,154.68) 17.59,154.49 PR614.2
BOOT2_VGA: length 1.7
  TOP w0.102: PR614.1 18.56,153.09 v1(18.2,153.44)
BOOT_1.35V: length 1.6
  TOP w0.102: v1(171.58,87.9) 172.18,87.3 PR200.2
BOOT_D:
  vias: v1(58.1,163.63)
BQ24715_REGN: length 213.4
  TOP w0.254: PR735.1 219.55,142.99 219.2,143.34 219.2,144.97 v3(219.29,145.06) ; v3(47.12,163.76) 47.12,162.6 PR746.1 ; v3(48.63,166.68) PR741.1
  IN1 w0.254: v3(48.63,166.68) 48.63,165.59 47.12,164.07 v3(47.12,163.76)
  IN2 w0.254: v3(48.63,166.68) 50.34,168.39 55.93,168.39 56.69,167.63 66.07,167.63 66.37,167.92 76.11,167.92 79.58,164.46 82.77,164.46 83.58,165.27 87.58,165.27 88.05,164.8 95.51,164.8 97.06,163.25 103.73,163.25 106.84,160.14 115.47,160.14 116.87,161.53 126.46,161.53 128.09,163.16 139.33,163.16 141.35,165.19 141.35,165.61 142.12,166.38 148.9,166.38 150.45,167.93 151.18,167.93 152.56,169.31 155.15,169.31 156.83,170.99 173.84,170.99 184.67,160.16 191.73,160.16 197.74,154.15 197.74,153.22 202.31,148.64 202.31,148.21 208.74,141.79 214.89,141.79 218.16,145.06 v3(219.29,145.06) ; v3(47.12,163.76) 47.12,163.07 48.15,162.04 49.66,162.04 51.56,160.14 v3(54.55,160.14)
  vias: v1(54.55,160.77)
BREATH_LED#: length 195.3
  TOP w0.102: v3(223.47,118.64) 223.71,118.4 223.71,114.23 R955.1 223.38,113.9 223.38,113.39 Q84.1 ; v3(181.93,69.93) 181.81,69.81 U46.B39
  IN2 w0.127: v3(181.93,69.93) 181.04,70.82 181.04,72.54 180.73,72.85 180.73,74.93 185.04,79.24 186.33,79.24 187.73,80.64 187.73,86.31 188.29,86.86 188.29,93.27 191.11,96.1 191.11,104.4 191,104.51 191,118.6 v3(191.07,118.67) 191.68,119.28 191.68,131.1 193.94,133.36 193.94,139.14 193.4,139.67 193.16,139.67 191.73,141.1 191.73,145.42 188.06,149.09 181.71,149.09 180.06,150.74 177.53,150.74 176.8,151.46 166.81,151.46 v3(165.17,153.1)
  IN3 w0.127: v3(223.47,118.64) 223.43,118.68 220.58,118.68 219.31,117.4 213.04,117.4 212.75,117.11 209.83,117.11 208.62,118.32 199.07,118.32 198.85,118.54 197.42,118.54 197.29,118.41 191.33,118.41 v3(191.07,118.67)
  BOTTOM w0.102: JDOCK1.98 143.84,171.01 145.44,172.61 v1(158.24,172.61) 161.22,172.61 164.09,169.74 164.09,163.85 163.74,163.5 163.74,159.07 163.22,158.56 163.22,155.05 v3(165.17,153.1)
BREATH_LED#_Q: length 122.9
  TOP w0.102: v3(230.35,116.41) 230.3,116.46 227.08,116.46 226.02,115.41 226.02,113.19 225.9,113.06 Q84.6 ; v3(252.16,154.35) 252.16,153.53 254.1,151.59 260.11,151.59 261.07,152.55 261.07,161.05 262.96,162.94 262.96,165.2 263.57,165.82 263.57,167.74 268.8,172.96 268.8,176.9 v1(269.3,177.4) 270.84,178.95 270.84,184.76 271.63,185.54 271.63,193.89 276.54,198.8 276.54,200.1 LED1.1
  IN3 w0.127: v3(252.16,154.35) 252.16,151.04 250.96,149.85 250.96,146.06 248.7,143.79 248.7,140.95 245.42,137.67 245.42,136.4 241.47,132.45 241.47,122.88 235.35,116.77 230.71,116.77 v3(230.35,116.41)
BREATH_WHITE_LED#: length 59.2
  TOP w0.102: v3(225.5,115.31) 225.5,114.61 225.05,114.15 R955.2
  BOTTOM w0.102: JLVDS1.4 220.04,167.23 219.58,166.78 219.58,162.47 222.84,159.22 222.84,154.63 223.42,154.04 223.42,153.19 v1(223.8,152.81) 223.84,152.77 223.84,120.39 224.66,119.56 224.66,116.14 v3(225.5,115.31)
BREATH_WHITE_LED_SNIFF: length 8.4
  TOP w0.102: R957.1 272.91,193.4 v1(274.73,195.22) 277.14,197.63 LED1.2
BST_3V:
  vias: v1(199.01,35.42)
BST_5V:
  vias: v1(199.76,40.68)
BST_+1.05VSP: length 1.6
  TOP w0.102: v2(175.9,92.64) 175.58,92.95 PR301.1
BT_LED#: length 6.8
  TOP w0.102: Q89.3 213.79,145.33 v3(213.68,145.21) 213.23,144.77 212.6,144.77 212.33,144.5 RP13.1
  BOTTOM w0.102: v3(213.68,145.21) 213.55,145.34 v1(213.55,146.17) 213.55,147.69 JMINI2.46
BT_RADIO_DIS#: length 101.6
  TOP w0.102: v3(202.26,134.36) 204.28,134.36 205.36,135.44 207.49,135.44 212.55,140.49 214.94,140.49 217.35,142.9 v1(217.35,144.31) 217.35,145.09 217.57,145.3 217.57,151.17 216.1,152.63 R695.1 217.44,154.61 D36.1 ; v3(192.62,70.57) 192.62,70.5 192.18,70.06 U46.A13
  IN2 w0.127: v3(202.26,134.36) 202.26,130.22 202.58,129.9 202.58,123.01 201.39,121.81 201.39,117.94 199.96,116.52 199.96,106.5 199.2,105.74 199.2,94.95 196.11,91.86 196.11,84.9 194.42,83.2 194.42,79.74 194.28,79.6 194.28,76.25 194.31,76.22 194.31,71.88 193.42,71 193.05,71 v3(192.62,70.57)
BT_RADIO_DIS#_R: length 11
  TOP w0.102: v3(215.58,155.44) 215.37,155.23 D36.2 215.37,153.46 R695.2
  BOTTOM w0.102: v3(215.58,155.44) 216.14,155.44 216.65,155.95 JMINI2.51 216.98,158.04 217.93,158.99 219.66,158.99 219.94,159.27 v1(219.94,159.82) 219.86,159.9 R3886.1
CAM_MIC_CBL_DET#: length 101.1
  TOP w0.089: 177.99,134.88 177.97,134.85 177.36,134.85 176.96,134.45 176.16,134.45 175.43,135.18 173.52,135.18 173.46,135.12 173.13,135.12 172.77,134.76 172.43,134.76 171.62,133.95 171.62,133.6 171.61,133.6 v3(171.61,133.61)
  TOP w0.102: 177.99,134.88 178.97,135.85 179.33,135.85 179.95,136.48 180.7,136.48 180.85,136.32 180.85,135.77 180.71,135.62 RPH6.2
  IN3 w0.127: v3(171.61,133.61) 171.62,133.61 171.62,133.96 172.87,135.21 173.22,135.21 175.58,137.57 175.58,139.03 176.72,140.17 182.2,140.17 182.62,140.59 189.12,140.59 190.69,139.02 193.72,139.02 194.49,138.26 207.32,138.26 208.68,136.9 228.12,136.9 228.28,137.06 v3(228.97,137.06)
  BOTTOM w0.089: v3(171.61,133.61) 171.61,133.69 171.48,133.82 UH1.L15
  BOTTOM w0.102: JCAM1.1 228.21,160.14 230.21,158.14 230.21,154.55 228.94,153.28 v1(228.94,143.37) 228.94,137.08 v3(228.97,137.06)
CARD_RESET#: length 38.8
  TOP w0.102: JEXP1.18 224.01,34.15 222.6,35.56 v2(222.12,35.56) 221.1,35.56 v3(221.01,35.65) ; U41.8 v3(231.84,62.98) 231.65,63.17 230.96,63.17 CE12.1
  IN1 w0.102: v3(231.84,62.98) 232.22,62.6 232.22,61.97 231.98,61.73 231.76,61.73 222.39,52.37 222.39,38.43 221.48,37.52 221.48,36.12 v3(221.01,35.65)
CARD_SMBCLK: length 75.8
  TOP w0.102: JEXP1.6 223.64,31.15 R732.2 222.81,31.26 220.19,31.26 219.94,31.5 219.94,31.9 v3(219.76,32.08) ; U51.A49 203.96,82.54 203.46,83.05 v3(203.46,83.18)
  IN4 w0.102: v3(219.76,32.08) 219.94,32.26 219.94,33.68 220.35,34.09 220.35,38.57 220.26,38.66 220.26,49.82 223.81,53.37 223.81,58.82 218.48,64.15 206.09,64.15 204.95,65.29 204.95,69.52 204.68,69.79 204.68,72.8 204.82,72.94 204.82,75.14 203.86,76.1 203.86,82.39 203.71,82.54 203.71,82.92 v3(203.46,83.18)
CARD_SMBDAT: length 75.7
  TOP w0.102: U51.B52 204.79,82.79 204.72,82.86 204.4,82.86 v3(204.09,83.18) ; v3(220.35,32.08) 220.17,31.9 220.17,31.6 220.28,31.49 222.77,31.49 R731.2 223.57,31.71 223.57,31.62 223.81,31.38 223.97,31.38 224.24,31.65 JEXP1.8
  IN4 w0.102: v3(220.35,32.08) 220.17,32.26 220.17,33.59 220.58,33.99 220.58,38.67 220.49,38.76 220.49,49.72 224.04,53.28 224.04,58.91 218.57,64.38 206.19,64.38 205.18,65.38 205.18,69.61 204.91,69.88 204.91,72.71 205.05,72.84 205.05,75.23 204.09,76.19 204.09,82.48 203.94,82.63 203.94,83.02 v3(204.09,83.18)
CASA0#: length 35.8
  TOP w0.089: UV4.L3 v3(81,101.66)
  IN4 w0.089: 78.16,102.04 80.36,102.04 80.36,102.04 80.63,102.04 81,101.66 v3(81,101.66)
  IN4 w0.127: 78.16,102.04 76.9,102.04 75.91,103.03 75.91,111.9 73.43,114.38 73.43,114.99 73.56,115.12 74.34,115.12 74.46,115.24 74.46,115.52 74.34,115.65 73.56,115.65 73.43,115.78 73.43,116.06 73.56,116.18 74.34,116.18 74.46,116.31 74.46,116.59 74.34,116.72 73.56,116.72 73.43,116.84 73.43,119.08 73.85,119.5 73.85,122 73.41,122.45 73.41,123.72 73.01,124.12 73.01,124.94 v3(72.65,125.3)
  BOTTOM w0.089: UV4.L3 v3(81,101.66) ; v3(72.65,125.3) 72.9,125.55 72.9,126.32 UV1.G19
CASA1#: length 33
  TOP w0.089: UV3.G3 v3(67.46,101.66)
  IN4 w0.127: v3(67.46,101.66) 65.02,101.66 63.87,102.81 63.87,108.45 68.46,113.04 68.46,125.66 68.93,126.13 v3(68.93,126.35)
  BOTTOM w0.089: UV3.G3 v3(67.46,101.66)
  BOTTOM w0.13: UV1.G16 70.67,126.38 70.41,126.12 69.16,126.12 v3(68.93,126.35)
CCD_OFF: length 149.6
  TOP w0.102: U46.B43 v3(181.93,67.81)
  IN2 w0.127: v3(201.58,126.15) 201.58,122.72 200.85,122 200.85,118.13 199.46,116.73 199.46,106.71 198.54,105.8 198.54,95.01 195.61,92.07 195.61,85.11 193.28,82.79 193.28,80.23 193.77,79.75 193.77,76.79 192.62,75.64 192.62,74.6 191.9,73.88 191.9,71.81 191.2,71.11 191.2,70.18 190.04,69.02 188.52,69.02 188,68.51 184.01,68.51 182.85,67.35 182.39,67.35 181.93,67.81 v3(181.93,67.81)
  IN3 w0.127: v3(201.58,126.15) 201.96,126.53 203.16,126.53 203.33,126.37 207.09,126.37 207.1,126.38 209.15,126.38 211.3,124.23 220.28,124.23 220.92,124.87 228.17,124.87 v3(229.32,126.03)
  BOTTOM w0.102: Q23.2 229.08,168.99 227.78,167.69 227.78,162.77 225.99,160.98 225.99,156.94 226.26,156.66 226.26,155.36 226.95,154.68 226.95,152.06 228.54,150.48 v1(228.54,145.91) 228.54,136.58 229.04,136.08 229.04,126.31 v3(229.32,126.03)
CD3301_DCIN: length 6.1
  TOP w0.102: v1(33.97,136.96) 34.38,137.37 PR835.2
  TOP w0.254: PU800.1 35.9,139.33 PC813.1 34.76,138.99 PR835.2
CD3301_SDC_IN: length 4.4
  TOP w0.254: PR854.2 41.53,136.98 PC818.1 41.34,137.56 41.12,137.56 40.84,137.84 40.84,138.58 40.82,138.6 PU800.6
CD_PBATT_OFF: length 3.7
  TOP w0.102: PR843.1 37.03,147.3 v1(36.69,146.95)
  TOP w0.254: PU800.27 38.32,146.82 38.2,146.94 38.2,146.94 PR843.1
CFD_PWRBTN#_XDP: length 1.6
  BOTTOM w0.102: JXDP1.11 95.09,77.23 95.23,77.08 RC21.2
CFG0: length 1.8
  TOP w0.089: 108.74,94.47 v3(109.47,95.2)
  TOP w0.102: T157.1 108.74,94.47
  BOTTOM w0.102: JCPU1.AT20 v3(109.47,95.2)
CFG1: length 1.2
  TOP w0.089: v3(110.47,95.2) 110.18,94.91 T158.1
  BOTTOM w0.089: v3(110.47,95.2) JCPU1.AR20
CFG2: length 7.8
  TOP w0.089: 108.74,93.75 109.3,94.31 110.59,94.31 v3(111.47,95.2)
  TOP w0.102: RC76.1 105.17,94.22 105.65,93.74 v1(106.57,93.74) 108.73,93.74 108.74,93.75
  BOTTOM w0.089: v3(111.47,95.2) JCPU1.AP20
CFG3: length 39.3
  TOP w0.089: 108.74,96.89 110.25,96.89 110.32,96.82 110.63,96.82 111,97.2 v3(111.47,97.2)
  TOP w0.102: 108.74,96.89 106.78,96.89 105.9,96 RC100.1
  IN1 w0.089: v3(111.47,97.2) 110.97,96.7 109.03,96.7 108.74,96.41
  IN1 w0.102: 108.74,96.41 108.52,96.19 108.21,96.19 97.16,85.14 96.63,85.14 95.39,83.9 95.39,81.94 93.61,80.16 93.61,76.71 v3(93.12,76.22)
  BOTTOM w0.089: v3(111.47,97.2) JCPU1.AP22
  BOTTOM w0.102: v3(93.12,76.22) 93.61,75.73 JXDP1.8
CFG4: length 5.1
  BOTTOM w0.089: JCPU1.AT22 108.99,96.73 108.74,96.47
  BOTTOM w0.102: RC77.1 v1(106.17,95.81) 108.08,95.81 108.74,96.47
CFG5: length 8.8
  TOP w0.089: v3(112.47,97.2) 111.85,96.58 108.74,96.58
  TOP w0.102: RC78.1 105.87,95.11 v1(106.52,95.76) 107.33,96.58 108.74,96.58
  BOTTOM w0.089: v3(112.47,97.2) JCPU1.AN22
CFG6: length 4.8
  BOTTOM w0.089: JCPU1.AT25 108.74,99.73
  BOTTOM w0.102: RC79.1 105.32,99.73 v1(106.17,99.73) 108.74,99.73
CFG7: length 12.8
  TOP w0.089: v3(112.47,98.2) 112.47,98.2 v1(112.98,97.69) 112.98,94.58 112.16,93.75 109.44,93.75 109.02,93.34 108.74,93.34
  TOP w0.102: RC83.1 108.74,93.34
  BOTTOM w0.089: v3(112.47,98.2) JCPU1.AN23
CFG8: length 2.8
  TOP w0.089: v3(110.47,99.2) 110.12,99.2 109.69,99.63 108.74,99.63
  TOP w0.102: 108.74,99.63 108.69,99.63 T159.1
  BOTTOM w0.089: v3(110.47,99.2) JCPU1.AR24
CFG9: length 3.9
  BOTTOM w0.089: 108.74,97.73 JCPU1.AT23
  BOTTOM w0.102: T160.1 106.16,97.73 108.74,97.73
CFG10: length 1.6
  TOP w0.089: T161.1 111.93,94.65 v3(112.47,95.2)
  BOTTOM w0.089: v3(112.47,95.2) JCPU1.AN20
CFG11: length 6.1
  TOP w0.089: v3(111.47,99.2) 110.87,98.6 108.74,98.6
  TOP w0.102: 108.74,98.6 107.59,98.6 T162.1
  BOTTOM w0.089: v3(111.47,99.2) JCPU1.AP24
CFG12: length 6.1
  TOP w0.089: v3(111.47,101.2) 111.04,101.63 108.74,101.63
  TOP w0.102: 108.74,101.63 107.55,101.63 T163.1
  BOTTOM w0.102: v3(111.47,101.2) JCPU1.AP26
CFG13: length 6.1
  TOP w0.089: 108.74,100.58 112.19,100.58 112.47,100.31 v3(112.47,100.2)
  TOP w0.102: T164.1 107.93,100.58 108.74,100.58
  BOTTOM w0.102: v3(112.47,100.2) JCPU1.AN25
CFG14: length 5.2
  TOP w0.089: v3(112.47,101.2) 111.85,101.82 109.18,101.82 108.74,102.26
  TOP w0.102: T165.1 108.74,102.26
  BOTTOM w0.102: v3(112.47,101.2) JCPU1.AN26
CFG15: length 7
  TOP w0.102: T166.1 106.29,100.15 109.79,100.15 110.21,99.74 111.01,99.74 v3(111.47,100.2)
  BOTTOM w0.102: v3(111.47,100.2) JCPU1.AP25
CFG16: length 2.8
  TOP w0.089: 108.74,96.09 109.01,95.82 109.63,95.82 110,96.2 v3(110.47,96.2)
  TOP w0.102: T167.1 108.74,96.09
  BOTTOM w0.089: v3(110.47,96.2) JCPU1.AR21
CFG17: length 1.3
  TOP w0.089: T169.1 111.77,95.9 v3(111.47,96.2)
  BOTTOM w0.089: v3(111.47,96.2) JCPU1.AP21
CFG18: length 2.3
  TOP w0.089: v3(110.47,98.2) 108.79,98.2 T168.1
  BOTTOM w0.089: v3(110.47,98.2) JCPU1.AR23
CFG19: length 5.9
  TOP w0.089: 108.74,97.6 110.87,97.6 v3(111.47,98.2)
  TOP w0.102: 108.74,97.6 107.12,97.6 T170.1
  BOTTOM w0.089: v3(111.47,98.2) JCPU1.AP23
CFG_RCOMP: length 6.8
  BOTTOM w0.254: RC81.1 105.17,101.98 v1(106.08,102.89) 108.92,105.73 JCPU1.AT31
CHAGER_SRC:
  vias: v1(66.3,153.85)
CHARGE_EN: length 12.5
  TOP w0.102: U46.A45 179.42,65.56 178.76,64.9 176.68,64.9 175.8,64.02 v1(175.21,64.02) RP19.3
CHARGER_CELL_PIN: length 251.2
  TOP w0.254: PD818.2 227.52,75.49 226.94,76.08 225.54,76.08 225.05,76.57 224.07,76.57 223.23,77.41 223.23,84.93 221.81,86.36 221.81,88.95 218.81,91.95 v3(218.71,91.95) ; v3(58.99,148.63) 58.99,149.89 v1(58.04,150.84) 57.82,151.06 55.62,151.06 54.61,152.07 54.61,154.87 53.34,156.14 49.91,156.14 48.2,157.85 48.2,158.63 48.78,159.21 48.78,160.45 48.66,160.58 PR747.2 PR720.2 PR746.2 49.02,162.36 49.07,162.31 PU700.10
  IN3 w0.254: v3(58.99,148.63) 59.55,148.07 61.16,148.07 61.48,148.39 64.33,148.39 68.39,144.33 79.63,144.33 81.6,146.29 81.6,146.29 81.61,146.31 83.38,146.31 84.16,147.09 88.69,147.09 89.1,147.51 93.17,147.51 93.62,147.97 103.17,147.97 108.42,153.23 115.08,153.23 115.4,153.55 126.38,153.55 126.87,153.06 132.62,153.06 134.32,151.35 136.39,151.35 136.98,150.75 139.43,150.75 143.07,147.12 143.07,125.14 156.64,111.57 162.13,111.57 163.58,110.12 165.76,110.12 168.57,107.31 178.55,107.31 180.53,105.34 196.67,105.34 198.1,103.9 204.07,103.9 209.34,98.64 212.7,98.64 215.94,95.39 215.94,93.49 217.48,91.95 v3(218.71,91.95)
CHARGER_SMBCLK: length 215
  TOP w0.102: PU700.9 49.11,162.81 48.97,162.95 48.61,162.95 48.22,163.34 47.89,163.34 v3(47.71,163.16) ; v3(206.28,82.5) 206.18,82.6 U51.B50 ; RP7.5 206.83,89.91 206.97,89.78 206.97,89.61 206.87,89.51 206.45,89.51 v3(206.27,89.69)
  IN1 w0.102: v3(136.16,143.59) 136.36,143.79 136.36,144.17 135,145.53 131.96,145.53 131.35,146.14 128.67,146.14 127.73,147.08 123.05,147.08 121.78,148.35 120.97,148.35 118.25,151.07 115.13,151.07 112.9,153.29 104.04,153.29 102.33,151.58 91.5,151.58 91,152.07 81.3,152.07 79.75,153.63 76.73,153.63 76.08,152.98 70.37,152.98 69.07,154.28 68.74,154.28 56.35,154.28 52.3,158.32 50.27,158.32 48.39,160.2 48.39,163.19 48.24,163.34 47.89,163.34 v3(47.71,163.16)
  IN4 w0.102: v3(206.28,82.5) 206.31,82.53 206.31,87.57 207.02,88.28 207.02,89.23 206.75,89.51 206.46,89.51 v3(206.27,89.69)
  BOTTOM w0.102: v3(136.16,143.59) 136.34,143.76 136.34,143.96 136.61,144.24 137.83,144.24 140.97,141.09 140.97,134.63 145.86,129.74 145.86,122.55 155.93,112.48 165.57,112.48 170.39,107.66 174.27,107.66 186.25,95.68 192.6,95.68 195.32,92.97 201.59,92.97 204.99,89.56 206.14,89.56 206.14,89.56 v3(206.27,89.69)
CHARGER_SMBDAT: length 212.7
  TOP w0.102: RP7.6 207.33,89.91 207.2,89.78 207.2,89.53 206.96,89.28 206.45,89.28 v3(206.27,89.11) ; v3(47.71,163.74) 47.89,163.57 48.32,163.57 48.71,163.18 48.97,163.18 49.11,163.31 PU700.8 ; v3(205.89,85.51) 205.88,85.51 206.43,84.96 U51.A47
  IN1 w0.102: v3(136.74,143.59) 136.59,143.74 136.59,144.27 135.1,145.76 132.05,145.76 131.44,146.37 128.77,146.37 127.83,147.31 123.14,147.31 121.88,148.57 121.07,148.57 118.34,151.3 115.22,151.3 113,153.52 103.95,153.52 102.24,151.81 91.59,151.81 91.1,152.3 81.4,152.3 79.84,153.86 76.63,153.86 75.99,153.21 70.46,153.21 69.17,154.5 68.84,154.5 68.84,154.5 56.44,154.5 52.39,158.55 50.36,158.55 48.62,160.3 48.62,163.28 48.33,163.57 47.89,163.57 v3(47.71,163.74)
  IN4 w0.102: v3(205.89,85.51) 205.98,85.51 206.08,85.61 206.08,87.66 206.8,88.38 206.8,89.14 206.66,89.28 206.45,89.28 v3(206.27,89.11)
  BOTTOM w0.102: v3(206.27,89.11) 206.14,89.24 206.05,89.33 204.9,89.33 201.49,92.74 195.23,92.74 192.51,95.45 186.15,95.45 174.18,107.43 170.3,107.43 165.48,112.26 155.83,112.26 145.63,122.46 145.63,129.64 140.74,134.53 140.74,141 137.73,144.01 136.71,144.01 136.56,143.86 136.56,143.76 v3(136.74,143.59)
CHG_LGATE: length 6.3
  TOP w0.102: v3(53.02,160.9) 53.02,160.39 v1(52.77,160.14)
  IN2 w1.016: 62.23,161.22 56.77,161.22
  vias: v3(53.02,161.48) v3(63.12,161.03) v3(63.07,155.4) v3(63.7,155.4) v3(63.76,161.03)
CHG_PHASE: length 13.3
  IN2 w1.016: 68.95,163.87 68.62,164.2 55.75,164.2
  vias: v1(71.6,159.96) v3(54.1,163.91) v3(54.69,163.91) v4(69.98,164.2) v4(69.98,163.57) v4(69.98,162.93) v4(69.98,157.81) v4(69.98,157.17) v4(69.98,156.54) v4(70.04,160.71) v4(70.04,160.07) v4(70.04,159.44) v4(70.61,164.2) v4(70.61,163.57) v4(70.61,162.93) v4(70.61,157.17) v4(70.61,156.54) v4(71.25,164.2) v4(71.25,163.57) v4(71.25,162.93) v4(71.25,157.17) v4(71.25,156.54) v4(71.88,164.2) v4(71.88,163.57) v4(71.88,162.93)
CHG_UGATE: length 13.8
  IN2 w1.016: 67.63,160.96 65.53,163.06 55.69,163.06
  BOTTOM w0.102: v3(68.18,155.4) 68.18,154.78 v1(68.44,154.51)
  vias: v3(54.1,163.32) v3(54.69,163.32) v3(68.71,161.09) v3(68.81,155.4) v3(69.34,161.09)
CKEA0: length 35.3
  TOP w0.089: UV4.J3 v3(81,103.26)
  IN4 w0.127: v3(75.11,128.62) 75.38,128.35 75.38,125 76.56,123.82 76.56,122.52 77.03,122.05 77.03,120.95 78.4,119.58 78.4,115.53 78.58,115.34 78.76,115.34 79.09,115.68 79.27,115.68 79.47,115.49 79.47,115.31 79.13,114.97 79.13,114.79 79.33,114.59 79.51,114.59 79.76,114.84 79.94,114.84 80.14,114.64 80.14,114.46 79.89,114.21 79.89,114.03 82.64,111.28 82.64,109.84 83.43,109.05 83.43,103.93 82.36,102.86 81.41,102.86 81,103.26 v3(81,103.26)
  BOTTOM w0.089: UV1.K20 74.73,129 v3(75.11,128.62) ; UV4.J3 v3(81,103.26)
CKEA1: length 33
  TOP w0.089: UV3.J3 v3(67.46,102.46)
  IN4 w0.089: 69.78,125.23 69.98,125.43 69.98,126.17 69.8,126.35 69.8,127.5 70.05,127.75 70.46,127.75 v3(71.43,128.72)
  IN4 w0.127: v3(67.46,102.46) 67.07,102.85 65.6,102.85 65.15,103.3 65.15,106.1 66.13,107.08 66.13,108.88 69.78,112.53 69.78,125.23
  BOTTOM w0.089: UV3.J3 v3(67.46,102.46)
  BOTTOM w0.13: UV1.J17 71.97,128.2 71.45,128.72 v3(71.43,128.72)
CLK_80H: length 3.4
  TOP w0.089: v3(173.62,143.05) 173.67,143.1 v1(174.13,143.1) 175.42,143.1 RH159.2
  BOTTOM w0.089: UH1.F36 173.87,142.8 v3(173.62,143.05)
CLK_BUF_BCLK: length 8.5
  TOP w0.102: v3(161.25,138.11) 160.87,138.5 159.07,138.5 158.9,138.33 156.55,138.33 156.28,138.61 154.84,138.61 154.58,138.86 154.28,138.86 154.15,138.74 RPH5.3
  BOTTOM w0.089: UH1.AT24 160.9,137.77 v3(161.25,138.11)
CLK_BUF_BCLK#: length 9.2
  TOP w0.102: RPH5.4 154.15,139.23 154.27,139.12 154.69,139.12 154.94,138.86 156.38,138.86 156.66,138.59 v4(156.91,138.59) 158.8,138.59 158.91,138.7 161.22,138.7 v3(161.84,138.08)
  BOTTOM w0.089: v3(161.84,138.08) 161.5,137.74 UH1.AR24
CLK_BUF_CKSSCD: length 8.2
  BOTTOM w0.089: 156.58,129.02 156.58,129.75 156.92,130.09 157.53,130.09 157.87,130.44 UH1.BC6
  BOTTOM w0.102: 156.58,129.02 156.58,126.72 155.98,126.13 153.99,126.13 153.83,125.97 RPH20.8
CLK_BUF_CKSSCD#: length 7.1
  BOTTOM w0.089: UH1.BE6 157.09,130.34 156.82,130.34 156.34,129.85 156.34,129.03 156.33,129.01
  BOTTOM w0.102: 156.33,129.01 156.33,126.83 155.88,126.38 153.98,126.38 153.89,126.47 RPH20.7
CLK_BUF_DMI: length 7.2
  TOP w0.102: RPH5.1 154.14,137.74 154.26,137.85 v4(155.58,137.85) 156.09,137.85 156.3,137.64 157.67,137.64 157.9,137.87 158.74,137.87 158.92,137.69 159.53,137.69 159.53,137.69 v3(159.95,138.11)
  BOTTOM w0.089: v3(159.95,138.11) 159.95,137.9 UH1.AW24
CLK_BUF_DMI#: length 6.3
  TOP w0.102: RPH5.2 154.15,138.24 154.28,138.1 156.19,138.1 156.4,137.89 157.57,137.89 157.8,138.12 v4(158.37,138.12) 158.84,138.12 158.87,138.1 159.28,138.1 v3(159.3,138.11)
  BOTTOM w0.089: v3(159.3,138.11) 159.11,137.93 UH1.AY24
CLK_BUF_DOT96: length 24.9
  TOP w0.089: 178.2,142.22 178.16,142.18 176.67,142.18 176.16,141.67 v4(174.92,141.67) 173.88,141.67 173.69,141.86 v3(173.69,142.09)
  TOP w0.102: RPH19.3 187.5,136.21 187.69,136.02 187.69,135.77 188.14,135.32 188.67,135.32 189.13,135.78 189.13,140.43 187.48,142.08 183.3,142.08 182.97,142.41 178.39,142.41 178.2,142.22
  BOTTOM w0.089: UH1.G33 173.48,141.78 173.69,141.98 v3(173.69,142.09)
CLK_BUF_DOT96#: length 24.1
  TOP w0.089: 178.31,141.98 178.3,141.97 178.29,141.97 178.26,141.94 176.84,141.94 v4(176.63,141.73) 176.33,141.43 173.78,141.43 173.67,141.54 173.63,141.54 v3(173.07,142.11)
  TOP w0.102: 178.31,141.98 178.35,142.02 178.36,142.02 178.49,142.15 182.87,142.15 183.2,141.82 187.37,141.82 188.88,140.32 188.88,135.88 188.56,135.57 188.25,135.57 188,135.82 RPH19.4
  BOTTOM w0.089: UH1.H33 173.07,141.96 173.07,142.1 173.06,142.1 v3(173.07,142.11)
CLK_CPU_DMI: length 59.7
  TOP w0.102: RC48.2 143.32,112.59 143.32,113.91 144.02,114.61 144.02,135.67 144.86,136.51 144.86,146.21 146.05,147.4 146.05,148.3 146.33,148.58 146.51,148.58 v3(146.77,148.84)
  IN4 w0.089: v3(164.72,144.45) 164.4,144.77 164.4,145.34 163,146.74 157.8,146.74 157.37,146.31 155.15,146.31 155.14,146.32 155.13,146.32
  IN4 w0.114: 155.13,146.32 154.85,146.32 154.31,146.87 153.04,146.87 152.81,147.09 151.69,147.09 151.18,146.58 150.73,146.58 148.61,148.69 146.92,148.69 v3(146.77,148.84)
  BOTTOM w0.089: v3(164.72,144.45) 165,144.73 UH1.AF40
CLK_CPU_DMI#: length 59.4
  TOP w0.102: RC46.2 143.58,112.59 143.58,113.81 144.27,114.5 144.27,135.56 145.11,136.4 145.11,146.1 146.31,147.3 146.31,148.2 146.43,148.33 146.7,148.33 v3(146.77,148.26)
  IN4 w0.089: 155.13,146.03 155.14,146.03 155.15,146.04 157.48,146.04 157.91,146.47 162.89,146.47 164.14,145.23 164.14,144.48 v3(164.72,143.89)
  IN4 w0.114: 155.13,146.03 154.73,146.03 154.19,146.57 152.92,146.57 152.69,146.8 151.82,146.8 151.3,146.28 150.61,146.28 148.49,148.4 146.92,148.4 v3(146.77,148.26)
  BOTTOM w0.089: UH1.AF39 164.98,143.9 164.72,143.9 164.72,143.9 v3(164.72,143.89)
CLK_CPU_DPLL: length 67.3
  TOP w0.102: RC40.2 139.77,112.59 139.77,112.83 142.48,115.55 142.48,136.27 143.38,137.17 143.38,147.8 144.36,148.77 145.04,148.77 145.18,148.91 145.18,149.35 v3(145.01,149.52)
  IN4 w0.089: v3(164.72,142.57) 164.72,142.55 164.93,142.34 165.02,142.34 165.12,142.44 165.12,144.99 165.41,145.28 165.41,145.85
  IN4 w0.114: v3(145.01,149.52) 145.42,149.1 145.87,149.1 145.99,149.22 146.41,149.22 146.86,149.68 151.02,149.68 153.14,147.55 162.98,147.55 163.27,147.27 164.09,147.27 165.41,145.96 165.41,145.85
  BOTTOM w0.089: UH1.AF36 165.09,142.94 v3(164.72,142.57)
CLK_CPU_DPLL#: length 67.3
  TOP w0.102: v3(145.59,149.52) 145.43,149.35 145.43,148.8 145.14,148.52 144.46,148.52 143.64,147.69 143.64,137.07 142.74,136.17 142.74,115.44 140.02,112.73 140.02,112.59 RC38.2
  IN4 w0.089: 165.7,145.85 165.7,145.84 165.69,145.83 165.69,145.73 165.67,145.72 165.67,145.17 165.39,144.88 165.39,142.33 165.13,142.07 164.85,142.07 v3(164.77,142)
  IN4 w0.114: v3(145.59,149.52) 146.29,149.52 146.74,149.97 151.14,149.97 153.26,147.85 163.11,147.85 163.39,147.56 164.21,147.56 165.7,146.08 165.7,145.85
  BOTTOM w0.089: UH1.AF35 165.02,142.34 164.77,142.09 v3(164.77,142)
CLK_CPU_SSC_DPLL: length 61.6
  TOP w0.102: RC44.2 141.8,112.27 141.68,112.39 141.68,112.63 141.48,112.83 141.48,113.04 143.51,115.07 143.51,135.9 144.38,136.76 144.38,147.37 144.76,147.75 145.37,147.75 v3(145.54,147.58)
  IN4 w0.089: 155.13,144.91 155.14,144.91 155.15,144.92 155.94,144.92 156.98,143.88 158.84,143.88 159.77,144.81 159.77,145.53 159.94,145.71 162.77,145.71 163.22,145.26 163.22,144.92 163.13,144.83 163.13,144.22 163.35,144 163.43,144 163.65,144 v3(163.77,143.88)
  IN4 w0.114: v3(145.54,147.58) 145.68,147.72 145.9,147.72 146.01,147.6 146.01,147.06 146.39,146.68 149.09,146.68 150.87,144.91 155.13,144.91
  BOTTOM w0.089: UH1.AJ39 164.02,144.13 v3(163.77,143.88)
CLK_CPU_SSC_DPLL#: length 61.6
  TOP w0.102: RC42.2 141.23,113.15 143.26,115.18 143.26,136 144.12,136.87 144.12,147.48 144.65,148.01 145.39,148.01 v3(145.54,148.16)
  IN4 w0.089: 155.13,145.2 155.14,145.2 155.15,145.19 156.05,145.19 157.09,144.15 158.73,144.15 159.5,144.92 159.5,145.64 159.83,145.97 162.88,145.97 163.49,145.37 163.49,144.8 163.37,144.69 163.37,144.35 163.46,144.26 163.54,144.26 v3(163.76,144.48)
  IN4 w0.114: v3(145.54,148.16) 145.7,148.01 146.02,148.01 146.31,147.72 146.31,147.18 146.51,146.97 149.22,146.97 150.99,145.2 155.13,145.2
  BOTTOM w0.089: UH1.AJ40 164.23,144.72 163.99,144.48 v3(163.76,144.48)
CLK_DDC2_CRT: length 152.9
  IN4 w0.102: v3(7.57,179.86) 7.77,179.66 7.77,179.22 8.67,178.32 18.53,178.32 30.23,166.62 33.92,166.62 35.46,165.07 39.07,165.07 45.28,158.86 45.62,158.86 52.57,151.92 58.47,151.92 59.21,151.18 65.41,151.18 68.37,148.22 72.17,148.22 72.89,147.5 78.61,147.5 80.34,149.23 80.44,149.23 88.81,149.23 89.24,148.8 102.23,148.8 108.37,154.94 110.83,154.94 111.72,155.84 121.46,155.84 122.14,156.52 129.78,156.52 131.62,154.67 131.62,154.11 134.34,151.4 135.48,151.4 135.7,151.18 135.7,150.92 135.2,150.42 v3(135.19,150.42)
  BOTTOM w0.102: v3(135.19,150.42) 135.13,150.49 U6.14 ; JIO1.12 7.04,179.25 7.17,179.11 7.33,179.11 7.54,178.91 7.67,178.91 7.75,178.99 7.75,179.69 v3(7.57,179.86)
CLK_DDC2_DOCK: length 27.1
  TOP w0.102: v3(129.42,167.83) 129.24,167.66 129.24,166.88 127.95,165.59 127.95,163.56 126.18,161.78 v4(126.18,158.36) 126.18,154.99 127.76,153.41 129.63,153.41 133,150.04 134.18,150.04 v3(134.56,150.42)
  BOTTOM w0.102: v3(134.56,150.42) 134.73,150.59 U6.15 ; v3(129.42,167.83) 129.26,167.99 129.26,168.12 129.34,168.2 JDOCK1.48
CLK_KBD: length 140.6
  TOP w0.102: v3(211.58,85.53) 211.53,85.53 210.93,84.93 U51.A38 ; v3(211.58,89.33) 211.38,89.54 RP8.8
  IN1 w0.102: v3(137.92,170.78) 138.28,170.43 138.28,169.39 139.92,167.75 139.92,163.52 139.51,163.11 139.51,158.96 140.11,158.37 140.11,155.25 144.38,150.99 144.38,141.87 145.1,141.15 145.1,134.68 144.99,134.57 144.87,134.57 v3(144.69,134.75)
  IN4 w0.102: v3(211.58,85.53) 211.3,85.53 211.11,85.72 211.11,88.17 211.3,88.36 211.3,89.06 v3(211.58,89.33)
  BOTTOM w0.102: v3(137.92,170.78) 138.05,170.66 138.05,170.45 137.84,170.24 JDOCK1.78 ; v3(144.69,134.75) 144.84,134.6 146.14,134.6 148.15,132.59 148.15,123.18 153.33,118 153.33,117.06 155.76,114.62 157,114.62 158.22,113.4 165.95,113.4 170.77,108.58 174.65,108.58 186.63,96.6 192.98,96.6 195.7,93.88 203.16,93.88 206.25,90.8 210.7,90.8 211.41,90.09 211.41,89.61 211.41,89.51 v3(211.58,89.33)
CLK_MSE: length 134.5
  TOP w0.102: U51.A39 v3(210.43,85.02) ; v3(210.36,89.34) 210.18,89.51 210.18,89.54 210.38,89.74 RP8.6
  IN1 w0.102: v3(144.69,132.95) 144.51,132.77 144.41,132.77 144.15,133.03 144.15,150.89 140.26,154.78 137.7,154.78 137.07,155.41 137.07,159.09 137.42,159.44 137.6,159.44 v3(137.8,159.24)
  IN4 w0.102: v3(210.43,85.02) 210.43,83.93 210.25,83.75 209.87,83.75 209.78,83.84 209.78,86.96 210.18,87.36 210.18,89.16 v3(210.36,89.34)
  BOTTOM w0.102: v3(144.69,132.95) 144.89,132.74 146.53,132.74 147.69,131.58 147.69,122.81 152.66,117.85 152.66,116.43 156.15,112.94 165.76,112.94 170.58,108.12 174.46,108.12 186.44,96.14 192.79,96.14 195.51,93.42 202.76,93.42 205.86,90.33 209.77,90.33 210.18,89.91 210.18,89.51 v3(210.36,89.34) ; v3(137.8,159.24) 137.62,159.42 136.91,159.42 136.48,159.85 136.48,160.06 136.34,160.2 JDOCK1.71
CLK_PCH_14M: length 5.3
  BOTTOM w0.102: UH1.F45 173.42,146.94 174.66,148.19 174.94,148.19 176.26,149.51 176.26,149.95 RH146.1
CLK_PCI_5048: length 81.7
  TOP w0.102: v3(184.6,145.45) v1(183.83,145.45) 182.6,145.45 RH158.2 ; v3(184.47,74.67) 184.02,74.22 184.02,73.78 184.12,73.69 U46.A28
  IN4 w0.102: v3(184.47,74.67) 185.23,75.43 185.23,75.51 189.75,80.04 189.75,89.57 190.15,89.96 190.15,94.9 192.34,97.09 192.34,111.37 190.06,113.64 190.06,127.45 190.62,128 190.62,139.3 187.03,142.88 187.03,143.01 v3(184.6,145.45)
CLK_PCI_DOCK: length 43.3
  TOP w0.102: RH330.1 174.96,146.93 RH162.2 175.33,147.96 v3(175.33,149.27)
  IN4 w0.102: v3(150.81,159.34) 152.78,159.34 152.91,159.21 152.91,157.71 153.04,157.58 153.44,157.58 153.55,157.69 153.55,159.21 153.65,159.31 153.95,159.31 154.05,159.21 154.05,157.69 154.15,157.58 154.63,157.58 157.41,154.8 161.8,154.8 161.95,154.65 167.18,154.65 168.02,153.81 172.51,153.81 173.46,152.86 173.46,152.58 174.22,151.82 174.22,150.37 v3(175.33,149.27)
  BOTTOM w0.102: R3761.1 v1(153.07,158.78) 152.68,159.17 150.98,159.17 v3(150.81,159.34) 149.84,160.31 JDOCK1.121
CLK_PCI_LOOPBACK: length 32.8
  IN4 w0.102: v3(181.48,146.74) 182.69,146.74 182.82,146.61 182.82,142.98 182.69,142.85 181.23,142.85 181.1,142.73 181.1,142.47 181.23,142.34 182.65,142.34 182.75,142.24 182.75,141.94 182.65,141.84 181.14,141.84 181.04,141.73 181.04,141.43 181.14,141.33 182.65,141.33 182.75,141.23 182.75,140.92 182.65,140.82 181.14,140.82 181.04,140.72 181.04,140.41 181.14,140.31 182.7,140.31 182.82,140.19 182.82,139.88 182.7,139.75 178.69,139.75 178.56,139.63 178.56,136.45 178.44,136.32 177.42,136.32 176.8,135.71 v3(176.8,134.83)
  BOTTOM w0.089: UH1.D17 174.96,134.91 175.22,134.65 175.53,134.65 175.69,134.8 176.78,134.8 v3(176.8,134.83)
  BOTTOM w0.102: v3(181.48,146.74) 181.48,147.12 v1(181.2,147.41) 180.85,147.76 RH164.2
CLK_PCI_MEC: length 97.3
  TOP w0.102: v3(216.57,81.89) 216.57,81.37 216.25,81.04 U51.A29
  IN4 w0.102: v3(185.57,149.69) 187.17,148.09 187.17,145.4 188.25,144.32 188.25,143.38 191.84,139.8 191.84,113.59 193.56,111.87 193.56,103.74 192.95,103.13 192.95,96.84 191.4,95.3 v3(191.4,93.6)
  BOTTOM w0.102: v3(191.4,93.6) 192.87,92.13 198.24,92.13 200.14,90.22 202.88,90.22 205.6,87.51 214.7,87.51 216.89,85.31 216.89,82.63 216.57,82.3 v3(216.57,81.89) ; RH160.2 184.2,150.27 185,150.27 v1(185.03,150.23) v3(185.57,149.69)
CLK_PCI_TPM: length 71.2
  TOP w0.102: U39.21 212.66,108.38 213.35,109.08 213.36,109.08 v3(213.43,109.15)
  IN1 w0.102: v3(192.95,111.18) 201.72,111.18 203.09,109.81 212.76,109.81 v3(213.43,109.15)
  IN4 w0.102: v3(184.74,149.66) 186.56,147.84 186.56,145.15 187.64,144.07 187.64,143.13 191.23,139.55 191.23,127.75 190.67,127.19 190.67,113.9 192.95,111.62 v3(192.95,111.18)
  BOTTOM w0.102: RH155.1 180.38,149.05 v1(181.42,149.05) 184.62,149.05 184.74,149.18 v3(184.74,149.66)
CLK_PCIE_EMB: length 162.1
  TOP w0.102: JSATA2.15 166.17,31 166.52,30.66 167.17,30.66 167.43,30.91 170.75,30.91 171.07,31.23 171.86,31.23 v3(172.02,31.07)
  IN1 w0.114: v3(172.02,31.07) 172.15,31.19 172.56,31.19 172.85,31.49 172.85,32.03 172.53,32.34 172.53,36.79 168.07,41.25 163.56,41.25 158.57,46.24 158.57,49.55 157.79,50.33 157.79,78.09 155.2,80.68 155.2,101.36 157.49,103.66 157.49,107.86 151.7,113.65 151.7,114.66 147.68,118.67 147.68,139.18 150.51,142.01 150.51,149.23 150.84,149.56 155.86,149.56 157.1,150.8 160.37,150.8 161.32,151.76 162.32,151.76 v3(162.47,151.61)
  BOTTOM w0.089: 164.17,146.92 164.16,146.9 164.16,146.53 164.33,146.35 164.33,146.07 164.05,145.8 UH1.AJ42
  BOTTOM w0.102: v3(162.47,151.61) 162.47,150.51 163.52,149.46 163.52,149 164.15,148.37 164.15,147.2 164.17,147.18 164.17,146.92
CLK_PCIE_EMB#: length 161.7
  TOP w0.102: JSATA2.16 166.44,31.52 166.44,31.1 166.62,30.91 167.07,30.91 167.32,31.17 170.65,31.17 170.97,31.49 171.86,31.49 171.91,31.54 v3(172.02,31.65)
  IN1 w0.114: v3(172.02,31.65) 172.19,31.49 172.44,31.49 172.56,31.61 172.56,31.91 172.24,32.22 172.24,36.67 167.95,40.96 163.44,40.96 158.28,46.12 158.28,49.42 157.49,50.21 157.49,77.97 154.9,80.56 154.9,101.48 157.2,103.78 157.2,107.74 151.41,113.53 151.41,114.53 147.39,118.55 147.39,139.3 150.22,142.13 150.22,149.35 150.72,149.85 155.73,149.85 156.98,151.09 160.25,151.09 161.2,152.05 162.32,152.05 v3(162.47,152.19)
  BOTTOM w0.089: 163.9,147.07 163.95,147.02 163.95,146.39 163.98,146.36 163.98,146.26 UH1.AJ44
  BOTTOM w0.102: v3(162.47,152.19) 162.06,151.79 162.06,151.44 162.22,151.29 162.22,150.41 163.27,149.35 163.27,148.89 163.9,148.26 163.9,147.07
