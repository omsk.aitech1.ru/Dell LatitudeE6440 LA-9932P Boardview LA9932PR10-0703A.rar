# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_CTX_GRX_C_P5: length 78
  IN4 w0.089: 141.51,111.73 141.51,111.63 141.53,111.62 141.53,106.4 140.95,105.83 139.63,105.83 139.63,105.82 139.32,105.82 139.31,105.83 139.21,105.83 139.2,105.82 138.94,105.56 138.8,105.42 138.8,105.41 138.59,105.2 v3(138.47,105.2)
  IN4 w0.127: 141.51,111.73 141.51,112.39 141.37,112.53 141.37,112.54 136.53,117.37 111.38,117.37 109.92,118.82 107.56,118.82 106.08,120.31 106.07,120.31 105.04,121.34 100.66,121.34 100.53,121.47 100.53,121.47 98.17,123.83 98.17,132.07 98.17,132.08 98.17,133.23 98.42,133.48 98.73,133.48 v3(98.94,133.7)
  BOTTOM w0.089: v3(138.47,105.2) 138,104.73 JCPU1.H30
  BOTTOM w0.127: CC11.2 91.8,132.43 91.92,132.43 94.55,135.05 96.46,135.05 97.96,133.56 98.81,133.56 v3(98.94,133.7)
PEG_CTX_GRX_C_P6: length 75.5
  IN4 w0.089: v3(143.47,107.2) 143.29,107.38 143.06,107.38 142.87,107.58 142.87,111.61 142.85,111.63 142.85,111.73
  IN4 w0.127: 142.85,111.73 142.85,112.11 142.26,112.7 142.26,112.7 142.12,112.84 142.12,112.85 136.84,118.12 111.69,118.12 110.23,119.57 107.88,119.57 106.39,121.06 106.38,121.06 105.35,122.09 105.35,122.09 105.27,122.16 100.9,122.16 100.84,122.22 100.84,122.22 98.92,124.14 98.92,131.76 99.26,132.1 99.53,132.1 v3(99.7,132.27)
  BOTTOM w0.089: JCPU1.B33 143.94,107.67 v3(143.47,107.2)
  BOTTOM w0.127: CC13.2 88.6,132.31 88.97,131.94 89.46,131.94 90.15,131.26 93.26,131.26 93.87,131.87 97.15,131.87 97.39,132.11 99.54,132.11 v3(99.7,132.27)
PEG_CTX_GRX_C_P7: length 72
  IN4 w0.127: v3(99.67,131.09) 99.77,130.99 100.14,130.99 100.44,130.69 100.44,124.21 101.45,123.21 105.76,123.21 108.41,120.56 110.65,120.56 112.1,119.11 137.25,119.11 137.26,119.1 137.85,119.1 139.72,117.24 139.72,117.24 140.11,116.85 140.11,116.85 144.18,112.78 144.18,106.45 v3(144.4,106.23)
  BOTTOM w0.089: v3(144.4,106.23) 144.9,106.73 JCPU1.A32
  BOTTOM w0.127: v3(99.67,131.09) 99.59,131.02 94.2,131.02 93.29,130.11 91.77,130.11 CC15.2
PEG_CTX_GRX_N0: length 11
  BOTTOM w0.089: UV1.AE31 81.73,141.05 81.73,141.2 81.82,141.3 81.95,141.3 82.1,141.16 84.09,141.16 84.84,141.91 84.84,142.43 84.85,142.45 84.85,142.52 84.87,142.54 84.87,142.55
  BOTTOM w0.127: 84.87,142.55 84.87,143.09 v4(85.84,144.06) 86.9,145.12 88.13,146.34 88.78,146.34 CC2.1
PEG_CTX_GRX_N1: length 13.4
  BOTTOM w0.089: UV1.AD28 80.84,140.46 81.22,140.46 81.3,140.54 81.47,140.54 81.55,140.47 82,140.47 82.24,140.71 84.39,140.71 84.97,141.28
  BOTTOM w0.127: CC4.1 91.11,144.9 89.1,144.9 88.74,144.54 v4(87.91,144.54) 87.44,144.54 85.92,143.01 85.92,142.18 85.15,141.4 85.12,141.41 85.07,141.35 85.04,141.35 84.97,141.28
PEG_CTX_GRX_N2: length 10.5
  BOTTOM w0.089: UV1.AC31 81.73,139.4 81.63,139.5 81.63,139.63 81.72,139.72 81.92,139.72 82.07,139.57 83.09,139.57 83.24,139.72 84.18,139.72 84.2,139.7 84.21,139.7
  BOTTOM w0.127: 84.21,139.7 84.59,139.7 v4(85.96,141.07) 86.88,141.99 86.88,142.82 87.47,143.41 87.82,143.76 89.01,143.76 CC6.1
PEG_CTX_GRX_N3: length 12.5
  BOTTOM w0.089: UV1.AB28 80.83,138.85 81.17,138.85 81.22,138.9 82.12,138.9 82.3,139.08 84.92,139.08 84.94,139.06 84.97,139.06
  BOTTOM w0.127: CC8.1 90.99,142.55 90.67,142.55 90.16,142.04 v4(89.43,142.04) 88.07,142.04 87.53,141.5 85.09,139.06 84.97,139.06
PEG_CTX_GRX_N4: length 13.4
  BOTTOM w0.089: 84.02,138.13 84,138.13 83.98,138.15 83.23,138.15 83.08,138 82.05,138 81.93,138.12 81.73,138.12 81.61,138.01 81.61,137.88 81.7,137.8 UV1.AA31
  BOTTOM w0.127: 84.02,138.13 85.3,138.13 88.4,141.23 v4(90.74,141.23) 92.75,141.23 CC10.1
PEG_CTX_GRX_N5: length 13.3
  BOTTOM w0.089: UV1.Y28 80.83,137.24 81.19,137.24 81.26,137.32 81.46,137.32 81.51,137.27 82,137.27 82.21,137.48 83.17,137.48 83.35,137.29 83.98,137.29 84,137.27 84.02,137.27
  BOTTOM w0.127: CC12.1 90.29,132.14 90.11,132.14 89.36,132.88 87.86,132.88 v4(87.31,133.44) 86.34,134.41 86.34,135.54 85.35,136.52 85.34,136.53 85.34,136.53 84.6,137.27 84.02,137.27
PEG_CTX_GRX_N6: length 10
  BOTTOM w0.089: 83.58,136.32 83.56,136.32 83.55,136.34 83.47,136.34 83.47,136.35 82.06,136.35 81.88,136.53 81.62,136.53 81.54,136.44 81.54,136.35 81.69,136.2 UV1.W31
  BOTTOM w0.127: 83.58,136.32 84.1,136.32 85.26,135.16 85.26,132.88 v4(86.09,132.05) 86.59,131.54 87.58,131.54 CC14.1
PEG_CTX_GRX_N7: length 14.1
  BOTTOM w0.089: 83.4,135.62 83.38,135.62 83.36,135.64 83.12,135.64 82.92,135.84 82.18,135.84 82,135.67 81.52,135.67 81.47,135.72 81.29,135.72 81.21,135.64 80.83,135.64 UV1.V28
  BOTTOM w0.127: 83.4,135.62 83.46,135.62 84.22,134.87 v4(84.22,132.98) 84.22,132.57 84.99,131.79 86.91,129.87 90.2,129.87 CC16.1
PEG_CTX_GRX_P0: length 11
  BOTTOM w0.089: UV1.AF30 81.65,141.53 82.05,141.53 82.19,141.39 83.99,141.39 84.61,142 84.61,142.52 84.61,142.53 84.61,142.55
  BOTTOM w0.127: CC1.1 89.27,146.61 88.02,146.61 v4(86.71,145.31) 84.61,143.2 84.61,142.55
PEG_CTX_GRX_P1: length 13.4
  BOTTOM w0.089: 84.97,141.63 84.96,141.62 84.93,141.62 84.77,141.46 84.77,141.43 84.72,141.38 84.72,141.35 84.3,140.94 82.14,140.94 81.91,140.7 81.64,140.7 81.57,140.77 81.21,140.77 81.13,140.69 80.95,140.69 80.87,140.77 80.87,140.89 UV1.AE29
  BOTTOM w0.127: 84.97,141.63 85.01,141.67 85.04,141.67 85.65,142.29 v4(85.65,142.6) 85.65,143.12 87.33,144.8 88.63,144.8 88.99,145.16 91,145.16 CC3.1
PEG_CTX_GRX_P2: length 10.5
  BOTTOM w0.089: 84.21,139.97 84.19,139.97 84.17,139.95 83.15,139.95 83,139.8 82.16,139.8 82.01,139.94 81.63,139.94 UV1.AD30
  BOTTOM w0.127: 84.21,139.97 84.48,139.97 v4(84.65,140.13) 86.62,142.1 86.62,142.93 87.71,144.03 89.03,144.03 CC5.1
PEG_CTX_GRX_P3: length 12.5
  BOTTOM w0.089: 84.97,139.33 84.94,139.33 84.92,139.31 82.2,139.31 82.13,139.24 81.99,139.1 81.14,139.1 81.08,139.05 80.97,139.05 80.86,139.16 80.86,139.27 80.98,139.4 UV1.AC29
  BOTTOM w0.127: CC7.1 91,142.81 90.56,142.81 90.05,142.31 87.96,142.31 v4(87.35,141.69) 84.98,139.33 84.97,139.33
PEG_CTX_GRX_P4: length 13.4
  BOTTOM w0.089: 84.02,138.39 84,138.39 83.98,138.37 83.17,138.37 83,138.2 82.13,138.2 82.01,138.32 81.66,138.32 UV1.AB30
  BOTTOM w0.127: CC9.1 92.79,141.5 88.29,141.5 85.19,138.39 v4(84.92,138.39) 84.02,138.39
PEG_CTX_GRX_P5: length 13.4
  BOTTOM w0.089: UV1.AA29 80.88,137.8 80.79,137.71 80.79,137.59 80.9,137.47 81.09,137.47 81.17,137.55 81.56,137.55 81.61,137.5 81.91,137.5 82.12,137.71 83.26,137.71 83.45,137.52 83.98,137.52 84,137.54 84.02,137.54
  BOTTOM w0.127: CC11.1 90.3,132.4 90.22,132.4 89.47,133.15 87.97,133.15 86.6,134.52 86.6,135.65 v4(85.54,136.71) 84.71,137.54 84.02,137.54
PEG_CTX_GRX_P6: length 10
  BOTTOM w0.089: 83.58,136.59 82.16,136.59 81.98,136.77 81.61,136.77 UV1.Y30
  BOTTOM w0.127: CC13.1 87.17,131.81 86.7,131.81 85.52,132.99 v4(85.52,134.56) 85.52,135.27 84.21,136.59 83.58,136.59
PEG_CTX_GRX_P7: length 14.1
  BOTTOM w0.089: 83.4,135.89 83.39,135.89 83.37,135.87 83.22,135.87 83.01,136.07 82.08,136.07 81.91,135.9 81.62,135.9 81.57,135.95 81.19,135.95 81.12,135.87 80.93,135.87 80.86,135.95 80.86,136.1 80.96,136.2 UV1.W29
  BOTTOM w0.127: CC15.1 90.26,130.14 v4(88.71,130.14) 87.02,130.14 84.48,132.68 84.48,134.98 83.57,135.89 83.4,135.89
PH2_VGA: length 14.3
  IN2 w1.016: 8.89,157.15 10.67,157.15 13.02,154.8 17.64,154.8 18.72,153.72 20.83,153.72 20.96,153.6
  BOTTOM w0.102: v3(21.88,152.72) 21.88,153.3 v1(21.78,153.41)
  vias: v3(8.5,155.95) v3(9.08,155.95) v3(21.88,152.14)
PHASE1: length 36
  TOP w0.102: PR553.1 v1(132.4,136.34)
  TOP w0.254: v3(131.6,137.48) 131.71,137.59 PR553.1
  IN1 w0.254: v3(131.6,137.48) 132.58,137.48 136.15,133.91 136.15,125.18 135.29,124.32 133.02,124.32 132.83,124.13 v3(132.83,123.75)
  IN4 w1.016: 125.41,139.31 128.91,135.82 128.91,130.36
  BOTTOM w0.254: PL503.2 132.65,124.07 132.83,123.89 v3(132.83,123.75) ; v3(131.6,137.48) 132.28,137.48 PR553.1
  vias: v3(125.34,140.83) v3(125.34,140.25) v3(128.64,129.09) v3(129.22,129.09)
PHASE1_VGA: length 13.6
  TOP w0.254: v3(28.01,159.12) 28.13,158.99 28.13,158.16 31.18,155.11 31.18,153.74 PR652.1 PR651.1
  IN2 w1.016: 25.59,156.26 25.59,153.79
  BOTTOM w0.254: PL601.2 27.81,159.63 28.01,159.44 v3(28.01,159.12)
  vias: v1(22.8,160.07) v3(25.59,157.86) v3(25.59,157.28) v3(25.55,152.78) v3(25.55,152.2)
PHASE2: length 63.1
  TOP w0.102: v3(122.81,141.77) 122.81,141.99 v2(123.2,142.38)
  TOP w0.254: v3(134.48,137.34) 134.23,137.59 PR538.1
  IN1 w0.254: v3(114.37,124.4) 114.47,124.3 120.3,124.3 120.72,123.88 120.72,120.58 121.48,119.81 123.77,119.81 124.47,119.12 133.83,119.12 136.69,121.98 136.69,134.06 134.58,136.16 134.58,137.24 v3(134.48,137.34)
  IN2 w1.016: 121.6,140.58 113.92,132.9 113.92,130.42
  BOTTOM w0.254: v3(114.37,124.4) PL502.2 ; PR538.1 134.24,137.59 134.49,137.34 v3(134.48,137.34)
  vias: v3(113.65,129.34) v3(114.24,129.34) v3(122.23,141.77)
PHASE2_VGA: length 36
  TOP w0.254: v3(16.51,164.48) 16.51,164.46 16.66,164.3 16.66,163.99 17.08,163.57 23.31,163.57 23.65,163.22 32.25,163.22 33.85,161.63 33.85,153.66 34.4,153.11 34.4,150.86 PR623.1 PR619.1
  BOTTOM w0.254: PL600.2 16.28,166.49 16.7,166.07 16.7,164.67 v3(16.51,164.48)
  vias: v1(10.86,166.68)
PLTRST_EMB#: length 97.2
  TOP w0.102: RH113.1 158.14,120.34 v1(158.14,119.05) v3(158.14,117.02)
  IN4 w0.102: v3(158.14,117.02) 157.93,116.8 157.93,115.49 161.74,111.68 161.74,111.11 164.5,108.35 169.66,108.35 170.4,107.61 173.58,107.61 180.85,100.34 180.85,91.8 181.09,91.56 181.09,82.5 180.27,81.68 179.88,81.68 175.13,76.94 173.15,76.94 170.47,74.27 170.47,55.83 169.66,55.02 169.66,46.4 168.87,45.6 JSATA2.28
PLTRST_GPU#: length 102.3
  TOP w0.102: v3(140.29,148.03) 139.05,148.03 138.24,148.83 v1(133.67,148.83) 133.3,148.83 129.52,152.61 122.02,152.61 120.54,151.13 117.99,151.13 114.77,147.91 89.37,147.91 88.77,147.31 86.36,147.31 85.9,147.78 84.73,147.78 84.46,147.5 UV14.2 ; RH114.1 157.13,120.21 148.89,120.21 145.72,123.38 145.72,143.09 v3(146.18,143.55)
  IN4 w0.102: v3(146.18,143.55) 144.77,143.55 v3(140.29,148.03)
PLTRST_LAN#: length 124.5
  TOP w0.102: RH111.1 160.28,120.3 159.11,119.14 159.11,117.87 159.39,117.59 161.04,117.59 v3(161.16,117.72) ; v3(232.78,157.5) 232.78,158.84 234.93,160.99 235.55,160.99 236.24,161.68 U31.36
  IN1 w0.102: v3(230,126.04) 225.39,121.43 225.39,118.95 223.59,117.15 222.41,117.15 218.31,113.05 209.04,113.05 207.89,111.9 201.1,111.9 200.92,111.71 180.11,111.71 179.78,112.04 169.95,112.04 167.43,114.57 166.25,114.57 165.25,115.57 163.04,115.57 162.35,116.27 162.35,116.6 161.95,117 161.82,117 161.16,117.66 v3(161.16,117.72)
  BOTTOM w0.102: v3(232.78,157.5) 230.7,155.41 v1(230.7,154.74) 230.7,154.35 229.52,153.17 229.52,126.51 v3(230,126.04)
PLTRST_MMI#: length 130.4
  TOP w0.102: v3(158.82,117.03) 158.63,117.22 v1(158.63,117.66) 158.63,119.93 RH110.1 ; U38.15 184.99,22.44 v3(184.95,22.41)
  IN4 w0.102: v3(184.95,22.41) 184.95,22.42 181.22,26.15 178.63,26.15 174.75,30.03 174.75,34.03 174.21,34.57 174.21,36.11 170.14,40.18 170.14,54.63 171.3,55.78 171.3,74.41 173.35,76.46 175.33,76.46 180.08,81.2 180.7,81.2 181.57,82.08 181.57,91.58 181.69,91.7 181.69,95.95 181.33,96.3 181.33,100.54 173.78,108.09 170.6,108.09 169.86,108.83 164.7,108.83 162.73,110.8 162.73,115.05 162.22,115.56 159.05,115.56 158.46,116.16 158.46,116.56 158.82,116.92 v3(158.82,117.03)
PLTRST_USH#: length 187.3
  TOP w0.102: RH109.1 149.09,120.69 146.21,123.58 v3(146.21,142.89) ; v3(60.01,145.91) 58.49,144.4 58.49,141.06 56.3,138.86 55.18,138.86 53.21,136.9 53.21,126.11 46.67,119.57 46.67,105.44 v1(44.56,103.32) 42.23,100.99 42.23,96.18 42.77,95.64 JUSH1.6
  IN4 w0.102: v3(146.21,142.89) 144.59,142.89 137.95,149.53 132.41,149.53 130.86,151.09 113.33,151.09 112.75,150.51 109.37,150.51 103.19,144.33 97.44,144.33 96.81,144.96 91.85,144.96 89.23,142.35 86.75,142.35 85.01,144.09 82.39,144.09 81.48,143.18 79.83,143.18 78.66,142.01 72.23,142.01 70.13,144.11 61.82,144.11 60.01,145.93 v3(60.01,145.91)
PM_APWROK: length 80.8
  TOP w0.102: U51.A9 v3(209.93,72.57)
  IN4 w0.102: v3(199.26,122.55) 198.71,121.99 198.71,118.84 199.14,118.41 199.14,115.82 198.38,115.06 198.38,93.87 199.72,92.52 199.72,88.84 201.44,87.12 202.05,87.12 202.9,86.27 202.9,85.45 204.5,83.85 204.5,78.91 205.18,78.22 206.56,78.22 209.17,75.61 209.17,74.35 209.93,73.59 v3(209.93,72.57)
  BOTTOM w0.102: v3(199.26,122.55) 197.8,124.01 187.83,124.01 185.8,126.04 v1(182.88,126.04) 182.2,126.04 RH87.1 181.05,124.89 180.42,124.89 179.92,125.39 UH2.2
PM_APWROK_R: length 22.1
  IN1 w0.089: 177.22,128.95 176.56,128.95 175.38,127.76 171.36,127.76 170.36,128.77 168.09,128.77 167.66,129.2 167.66,130.43 v3(167.28,130.81)
  IN1 w0.102: v3(181.92,128.58) 181.66,128.32 181.29,128.32 180.67,128.95 177.22,128.95
  BOTTOM w0.089: v3(167.28,130.81) 167.03,130.81 UH1.AB7
  BOTTOM w0.102: v3(181.92,128.58) 181.92,127.92 v1(182.02,127.82) 182.02,126.77 RH87.2 181.12,126.37 180.57,125.82 UH2.4
PM_DRAM_PWRGD: length 156
  TOP w0.102: RC13.2 v1(100.83,49.77) 100.3,50.3 v3(100.3,50.62)
  IN4 w0.102: v3(173.53,56) 173.53,59.29 174.44,60.2 174.44,73.55 177.52,76.63 178.98,76.63 179.57,77.22 179.57,78.04 180.86,79.32 181.57,79.32 184.8,82.55 184.8,90.36 185.29,90.86 185.29,96.47 184.25,97.52 184.25,101.74 183.34,102.66 182.6,103.4 182.6,108.59 177.7,113.48 177.7,117.62 177.26,118.06 177.26,121.64 178.25,122.63 v3(178.25,122.67)
  BOTTOM w0.102: v3(173.53,56) 165.84,56 160.66,50.82 108.35,50.82 107.86,50.34 101.31,50.34 101.18,50.2 100.71,50.2 v3(100.3,50.62) ; v3(178.25,122.67) 178.25,123.1 RH104.1
PM_DRAM_PWRGD_A: length 12.1
  TOP w0.102: UC1.2 104.78,48.25 104.49,47.97 103.55,47.97 RC13.1 102.19,47.55 v1(101.16,47.55) 100.78,47.55 99.63,48.69 99.63,50.66 100.07,51.1 101.28,51.1 RC12.2
PM_DRAM_PWRGD_CPU: length 80.1
  TOP w0.102: QC5.3 108.52,48.7 109.09,49.27 109.09,53.01 v2(108.59,53.52) 106.48,55.63 RC10.1 105.6,56.57 104.27,57.9 95.84,57.9 v3(95.58,58.16)
  IN4 w0.089: 108.74,90.8 114.87,90.8 115.89,89.78 117.54,89.78 118.05,90.29 120.78,90.29 121.41,89.65 121.41,88.57 121.86,88.13 121.86,84.57 122.23,84.2 v3(122.47,84.2)
  IN4 w0.102: v3(95.58,58.16) 96.39,58.97 96.39,79.13 101.16,83.89 101.16,83.94 108.02,90.8 108.74,90.8
  BOTTOM w0.089: JCPU1.AC10 122.94,84.67 v3(122.47,84.2)
PM_DRAM_PWRGD_R: length 8.5
  BOTTOM w0.089: 173.74,126.62 173.74,126.81 173.49,127.06 173.49,127.41 173,127.89 173,128.12 172.59,128.53 UH1.H3
  BOTTOM w0.102: RH104.2 178.06,124.64 v1(177.61,125.09) 176.25,126.45 174.79,126.45 174.67,126.33 173.98,126.33 173.74,126.57 173.74,126.62
PM_LANPHY_ENABLE: length 114.2
  TOP w0.102: v3(249.67,158.01) 249.67,158.56 250.15,159.04 250.15,162.63 249.89,162.89 247.73,162.89 v1(247.05,162.22) 246.69,161.85 R555.1 ; RPH21.8 186.58,132.57 v3(185.89,133.26)
  IN3 w0.089: 178.75,130.67 176.21,130.67 174.7,132.18 172.93,132.18 v3(172.45,132.66)
  IN3 w0.127: v3(249.67,158.01) 249.67,157.88 249.12,157.34 248.67,157.34 246.64,155.31 246.64,154.68 245.93,153.97 239.79,153.97 238.76,152.94 238.76,148.92 239.76,147.91 239.76,138.69 237.97,136.9 236.17,136.9 233.82,134.55 218.67,134.55 217.95,133.82 213.02,133.82 211.21,132.02 206.79,132.02 205.71,133.1 191.39,133.1 190.17,134.32 186.37,134.32 185.89,133.84 v3(185.89,133.26) 185.89,132.01 185.49,131.6 183,131.6 182.7,131.31 179.63,131.31 179,130.67 178.75,130.67
  BOTTOM w0.089: v3(172.45,132.66) 172.1,133.01 172.08,133.01 UH1.K13
POWER_SW#_MB: length 199.1
  TOP w0.102: v3(203.49,69.14) 203.65,69.29 R811.2 C721.1 ; v3(231.08,98.48) 231.16,98.4 JAPS1.11 ; v3(261.43,170.73) 261.43,171.19 C1558.1 262.53,172.29 262.53,176.06 261.33,177.26 260.95,177.26 260.03,178.17 260.03,184.58 261.49,186.05 264.29,186.05 265.55,187.3 265.55,194.16 266,194.62 271.5,194.62 v2(272.11,195.22) 273.04,196.16 SW1.2 SW1.4
  IN1 w0.102: v3(221.93,66.86) 221.17,67.62 213.15,67.62 212.92,67.39 205.22,67.39 203.49,69.12 v3(203.49,69.14)
  IN4 w0.102: v3(221.93,66.86) 221.93,67.05 223.04,68.15 224.9,68.15 225.17,68.42 225.17,75.55 227.78,78.16 228.54,78.16 230.25,79.87 230.25,97.51 231.05,98.3 231.08,98.3 v3(231.08,98.48) 230.7,98.86 230.7,104.94 227.97,107.67 227.97,118.1 228.14,118.28 228.14,138.2 230.32,140.37 234.28,140.37 244.53,150.62 247.66,150.62 247.87,150.83 248.72,150.83 249.21,151.32 249.21,153.63 251.75,156.17 254.16,156.17 254.95,156.97 254.95,157.98 254.07,158.87 254.07,163.12 257.05,166.11 260.29,166.11 261.71,167.53 261.71,170.44 v3(261.43,170.73)
POWER_SW_IN#: length 21.8
  TOP w0.102: RP15.3 199.21,65.78 199.46,65.53 203.37,65.53 206.19,68.35 206.19,71.62 v3(205.51,72.29) 205.2,72.29 204.66,71.76 C722.1 R811.1 ; v3(206.33,75.96) 206.33,75.96 205.66,75.29 U51.B67
  IN4 w0.102: v3(206.33,75.96) 205.92,75.56 205.65,75.56 205.28,75.18 205.28,72.53 v3(205.51,72.29)
PROCHOT#_EC: length 8.5
  TOP w0.102: Q47.2 205.36,89.33 205.17,89.14 v1(205.17,88.76) 205.17,87.42 R812.2 ; R812.2 R1180.1 R1179.2 ; R812.2 206.19,86.4 206.19,85.91 206.93,85.16 U51.A46
PROCHOT_GATE: length 133.9
  TOP w0.102: RP4.8 189.62,59.67 v3(189.69,59.73) ; v3(182.74,61.08) 182.44,61.38 182.44,61.85 182.62,62.03 U46.A50
  TOP w0.254: v3(232.47,139.44) 233.04,140.01 PU704.2
  IN1 w0.102: v3(182.74,61.08) 183.07,61.08 183.26,60.89 183.26,60.52 184.56,59.22 189.18,59.22 v3(189.69,59.73)
  IN2 w0.254: v3(193.13,88.66) 193.55,89.08 193.55,91.65 195.37,93.47 195.37,100.29 196.95,101.88 196.95,117.85 197.36,118.26 197.36,125.22 199.75,127.61 199.75,138.39 v3(200.59,139.23)
  IN3 w0.254: v3(232.47,139.44) 230.83,137.8 227.98,137.8 227.72,137.54 211.8,137.54 210.77,138.57 201.24,138.57 v3(200.59,139.23)
  IN4 w0.102: v3(193.13,88.66) 193.13,87.22 193.27,87.08 193.27,79.49 192.29,78.51 192.29,76.1 194.39,74.01 194.39,71.26 195.09,70.56 195.09,68.26 194.65,67.83 194.65,65.39 189.99,60.73 189.99,60.03 v3(189.69,59.73)
  BOTTOM w0.102: v3(182.74,61.08) v1(182.09,61.08)
PS2_CLK_TS: length 25.8
  TOP w0.102: JKB1.2 201.59,100.3 201.33,100.04 201.33,97.3 200.26,96.23 v4(199.63,96.23) 193.95,96.23 192.62,97.56 192.62,104.92 192.06,105.49 189.16,105.49 188.94,105.27 JTP1.7
PS2_DAT_TS: length 25.6
  TOP w0.102: JTP1.6 188.94,105.77 188.99,105.72 192.15,105.72 192.85,105.02 192.85,97.65 194.04,96.46 v4(195.45,96.46) 200.17,96.46 201.11,97.4 201.11,99.94 200.98,100.07 200.73,100.07 200.59,100.2 JKB1.3
PS_0: length 15.2
  BOTTOM w0.089: UV1.AC19 73.13,139.4 72.46,140.07 72.46,141.98 72.14,142.29 72.14,144.77 70.8,146.11 68.97,146.11
  BOTTOM w0.102: 68.97,146.11 68.07,147.01 CV357.1 67.48,147.23 66.93,147.78 66.93,148.41 v3(67.25,148.73) 67.38,148.86 RV243.1 RV244.2
PS_1: length 13.6
  BOTTOM w0.089: 71.11,146.36 71.95,146.36 73.03,145.28 73.03,142.42 72.81,142.2 72.81,140.57 UV1.AD19
  BOTTOM w0.102: 71.11,146.36 CV342.1 RV238.1 68.76,147.69 68.76,148.83 69.15,149.23 RV237.2 v1(70.12,149.52)
PS_2: length 9.1
  TOP w0.089: v3(71.38,141.34) 71.95,141.34 v1(73.15,142.55) 73.47,142.87 CV340.1 73.47,143.88 72.84,144.52 72.84,146.17
  TOP w0.102: RV239.2 RV240.1 72.84,146.5 72.84,146.17
  BOTTOM w0.15: UV1.AE17 71.72,141 v3(71.38,141.34)
PS_3: length 11.3
  BOTTOM w0.089: 73.87,146.15 73.87,145.37 73.85,145.35 73.85,141.53 UV1.AE20
  BOTTOM w0.102: 73.87,146.15 73.87,146.4 v1(73.25,147.02) 73.04,147.23 CV341.1 RV242.1 70.74,147.74 70.74,148.52 71.06,148.83 RV241.2
PS_ID: length 62
  TOP w0.102: U51.A55 203.47,79.54 v3(203.42,79.49)
  TOP w0.254: v3(219.43,120.13) 219.43,120.58 219.88,121.02 v1(220.09,121.02) 220.45,120.67 221.06,120.67 221.28,120.89 PU1.4
  IN2 w0.127: v3(207.77,120.42) 207.67,120.32 207.67,116.26 210.92,113.01 210.92,97.75 207.18,94 207.18,91.43 205.26,89.51 205.26,81.55 203.42,79.71 v3(203.42,79.49)
  IN3 w0.127: v3(219.43,120.13) 215.55,120.13 214.37,118.94 212.47,118.94 210.99,120.42 v3(207.77,120.42)
PSATA_PRX_DTX_N0_C: length 183.7
  IN4 w0.114: v3(158.92,53.01) 158.57,52.65 158.08,52.65 157.99,52.75 157.99,54.48 160.57,57.06 160.57,61.23 164.72,65.38 164.72,75.15 170.36,80.79 174.68,80.79 177.47,83.58 177.47,84.68 177.83,85.05 177.83,88.6 178.05,88.81 178.05,89.53 177.81,89.77 177.81,98.41 172.85,103.37 170.34,103.37 168.52,105.18 160.71,105.18 159.45,106.44 159.45,108.77 153.26,114.96 153.26,115.86 152.39,116.73 152.39,125.6 153.62,126.83 153.62,128.73 v3(153.98,129.08)
  BOTTOM w0.089: 156.05,130.03 156.06,130.04 156.25,130.04 157.01,130.8 157.17,130.8 157.63,131.25 158.08,131.25 UH1.BC8
  BOTTOM w0.102: C385.2 89.08,57.39 91.89,57.39 92.5,56.78 99.5,56.78 100.33,57.6 147.41,57.6 152.23,52.78 158.69,52.78 v3(158.92,53.01) ; 156.05,130.03 155.59,129.57 155.4,129.57 155.1,129.28 154.17,129.28 153.98,129.09 v3(153.98,129.08)
PSATA_PRX_DTX_P0_C: length 183.7
  IN4 w0.114: v3(158.92,52.42) 157.99,52.42 157.76,52.65 157.76,54.57 160.34,57.15 160.34,61.32 164.49,65.48 164.49,75.25 170.26,81.02 174.58,81.02 177.24,83.67 177.24,84.78 177.6,85.14 177.6,88.69 177.82,88.91 177.82,89.44 177.58,89.68 177.58,98.31 172.75,103.14 170.25,103.14 168.43,104.96 160.61,104.96 159.22,106.35 159.22,108.67 153.03,114.87 153.03,115.76 152.16,116.63 152.16,125.69 153.4,126.93 v3(153.4,129.08)
  BOTTOM w0.089: UH1.BE8 157.07,131.36 156.92,131.36 156.85,131.28 156.85,131.18 156.91,131.12 156.91,130.99 156.16,130.24 155.97,130.24 155.92,130.19 155.91,130.19 155.9,130.18
  BOTTOM w0.102: v3(158.92,52.42) 158.78,52.57 152.15,52.57 147.32,57.39 100.41,57.39 99.59,56.57 92.41,56.57 91.81,57.18 89.08,57.18 C386.2 ; 155.9,130.18 155.51,129.78 155.31,129.78 155.02,129.49 153.8,129.49 v3(153.4,129.08)
PSATA_PTX_DRX_N0_C: length 183.1
  IN4 w0.089: v3(159.77,130.32) 159.77,128.77 159.2,128.2 157.93,128.2 157.17,127.44 157.17,126.62
  IN4 w0.114: 157.17,126.62 157.17,125.76 154.94,123.53 154.94,118.51 157.31,116.14 157.31,115.42 160.79,111.94 160.79,111.17 164.1,107.86 169.46,107.86 170.2,107.12 173.38,107.12 180.36,100.14 180.36,91.6 180.6,91.36 180.6,83.1 175.47,77.96 171.14,77.96 168.37,75.19 168.37,63.5 163.57,58.71 163.57,55.92 162.09,54.44 162.09,53.37 161.86,53.14 v3(161.28,53.14)
  BOTTOM w0.089: v3(159.77,130.32) 159.71,130.39 UH1.AW8
  BOTTOM w0.102: C384.2 89.09,58.97 91.2,58.97 92.78,57.39 99.25,57.39 100.07,58.21 147.66,58.21 152.26,53.62 159.35,53.62 159.64,53.33 161.09,53.33 v3(161.28,53.14)
PSATA_PTX_DRX_P0_C: length 183
  IN4 w0.089: v3(159.21,130.32) 159.24,130.32 159.57,129.99 159.57,128.86 159.11,128.4 157.84,128.4 156.97,127.53 156.97,126.72 156.96,126.71 156.96,126.64 156.94,126.63 156.94,126.62
  IN4 w0.114: v3(161.28,53.72) 161.63,53.37 161.77,53.37 161.86,53.46 161.86,54.54 163.34,56.02 163.34,58.81 168.14,63.6 168.14,75.28 171.05,78.19 175.37,78.19 180.37,83.2 180.37,91.26 180.13,91.5 180.13,100.04 173.28,106.89 170.1,106.89 169.37,107.63 164.01,107.63 160.56,111.08 160.56,111.84 157.08,115.32 157.08,116.05 154.71,118.42 154.71,123.63 156.94,125.86 156.94,126.62
  BOTTOM w0.089: UH1.AY8 159.21,131.07 v3(159.21,130.32)
  BOTTOM w0.102: C383.2 89.09,59.18 91.29,59.18 92.86,57.6 99.16,57.6 99.99,58.43 147.75,58.43 152.35,53.83 159.44,53.83 159.73,53.54 161.1,53.54 v3(161.28,53.72)
PSID_DISABLE#: length 141.4
  TOP w0.102: v3(179.06,69.01) 178.93,69.14 178.93,69.39 179.1,69.56 v1(179.33,69.56) U46.A37
  TOP w0.254: v3(221.81,119.69) 221.43,120.07 PR16.2
  IN1 w0.102: v3(243.18,127.12) 243.05,126.99 229.52,126.99 226.22,123.69 224.86,123.69 221.81,120.64 v3(221.81,119.69)
  IN3 w0.127: v3(179.06,69.01) 179.44,68.64 180.8,68.64 181.21,68.23 187.66,68.23 188.6,67.29 188.6,66.6 188.75,66.45 190.59,66.45 191.09,66.95 192.85,66.95 193.33,67.43 194.63,67.43 195,67.06 199.56,67.06 199.66,67.16 207.2,67.16 207.8,66.56 216.16,66.56 218.2,68.61 221.61,68.61 223.79,70.78 223.79,72.06 224.25,72.52 225.06,72.52 230.48,77.94 230.48,103.62 238.28,111.41 238.88,112.01 243.18,116.32 v3(243.18,127.12)
PWR_SRC_ON: length 5.9
  TOP w0.102: v1(213.93,162.23) 214.5,162.8 215.01,162.8 215.51,163.3 C297.2 R422.2 215.5,164.21 R423.1 214.3,164.21 213.89,164.62 213.89,165.14 214.09,165.33 Q21.3
PWRSHARE_EN#: length 11.7
  TOP w0.102: U48.4 283.61,191.38 283.4,191.16 R816.1 283.9,190.26 283.9,188.13 v1(283.24,187.47) 282.91,187.14 282.91,186.1 280.8,183.99 280.8,183.63 280.42,183.25 Q48.1
PX_EN: length 3.7
  TOP w0.089: RV48.2 72.89,140.21 72.71,140.39
  TOP w0.102: v1(72.46,140.64) 72.71,140.39
  TOP w0.254: v3(71.46,139.12) 72.7,139.12 RV48.2
  BOTTOM w0.254: UV1.AB16 70.98,138.64 v3(71.46,139.12)
RASA0#: length 33.6
  TOP w0.089: UV4.G3 v3(81,104.86)
  IN4 w0.127: v3(74.98,127.25) 74.49,126.75 74.49,126.1 74.61,125.98 74.61,124.66 75.38,123.88 75.38,122.69 75.64,122.43 76,122.43 76.48,121.95 76.48,120.3 76.8,119.98 76.8,116.84 76.93,116.72 77.41,116.72 77.53,116.59 77.53,115.17 78.34,114.36 78.34,114.18 77.7,113.54 77.7,113.36 77.9,113.17 78.08,113.17 78.72,113.8 78.9,113.8 79.09,113.6 79.09,113.42 78.46,112.79 78.46,112.61 78.66,112.41 78.84,112.41 79.47,113.05 79.65,113.05 79.84,112.86 79.84,112.68 79.29,112.14 79.29,111.96 82.21,109.05 82.21,105.5 81.97,105.26 81.4,105.26 81,104.86 v3(81,104.86)
  BOTTOM w0.089: UV4.G3 v3(81,104.86) ; UV1.G22 75.58,126.65 v3(74.98,127.25)
RASA1#: length 32.8
  TOP w0.089: UV3.L3 v3(68.26,104.06)
  IN4 w0.127: v3(68.26,104.06) 68.66,104.45 70.38,104.45 71.35,105.42 71.35,106.64 71.48,106.77 72.22,106.77 72.35,106.9 72.35,107.18 72.22,107.3 71.48,107.3 71.35,107.43 71.35,107.71 71.48,107.84 72.22,107.84 72.35,107.96 72.35,108.24 72.22,108.37 71.48,108.37 71.35,108.5 71.35,108.78 71.48,108.9 72.22,108.9 72.35,109.03 72.35,109.31 72.22,109.44 71.48,109.44 71.35,109.57 71.35,109.84 71.48,109.97 72.22,109.97 72.35,110.1 72.35,119.45 72.66,119.76 72.66,122.28 72.16,122.78 72.16,124.39 71.83,124.71 71.83,125.8 v3(71.43,126.2)
  BOTTOM w0.089: UV3.L3 v3(68.26,104.06)
  BOTTOM w0.13: UV1.G17 v3(71.43,126.2)
RED_CRT: length 153.3
  IN4 w0.102: v3(127.92,154.41) 126.98,153.47 115,153.47 114.37,152.84 109.22,152.84 102.46,146.09 98.17,146.09 97.54,146.72 84.59,146.72 84.23,146.36 81.73,146.36 80.52,145.15 79.11,145.15 78.45,144.49 72.54,144.49 71.1,145.94 62.58,145.94 59.45,149.06 57.93,149.06 57.15,149.84 51.7,149.84 48.58,152.96 48.24,152.96 38.21,162.99 35.61,162.99 34.6,162.99 33.05,164.54 29.37,164.54 17.78,176.13 7.81,176.13 6.53,177.41 v3(3.62,177.41)
  BOTTOM w0.102: U6.27 133.13,156.3 132.97,156.45 132.97,157.28 132.21,158.04 v1(131.07,158.04) 130.42,158.04 127.92,155.54 v3(127.92,154.41) ; JIO1.3 3.46,177.25 v3(3.62,177.41)
RED_DOCK: length 9.3
  TOP w0.102: v3(131.7,157.41) 131.7,159.25 131.45,159.5 v1(131.45,159.82) 131.45,160.2 131.84,160.59 v3(131.84,162.55)
  BOTTOM w0.102: v3(131.84,162.55) JDOCK1.53 ; U6.26 133.06,155.9 131.7,157.26 v3(131.7,157.41)
REGCTL_PNP10: length 8.8
  TOP w0.203: v3(244.43,163.81) 244.3,163.93 244.02,163.93 243.87,164.08 U31.7
  TOP w0.254: L29.1 247.72,168.46 v3(247.84,168.33)
  BOTTOM w0.254: v3(244.43,163.81) 245.23,163.81 245.87,164.46 v1(245.87,165.22) 245.87,166.61 247.59,168.33 v3(247.84,168.33)
REM_DIODE1_N: length 200
  TOP w0.254: v3(212.49,69.78) 213.06,69.78 C285.1 ; v3(211.77,74.92) 211.68,74.82 U51.B13
  IN1 w0.254: v3(93.55,54.84) 93.51,54.88 93.51,56.38 93.32,56.57 93.32,58.37 94.96,60.01 94.96,79.82 96.59,81.44 96.59,83.41 97.13,83.95 97.82,83.95 107.72,93.84 115.04,93.84 115.76,93.12 115.76,92.45 116.4,91.81 v3(116.65,91.81)
  BOTTOM w0.254: v3(93.55,54.84) 93.51,54.8 93.51,54.33 98.64,49.2 160.7,49.2 163.81,52.31 171.49,52.31 175.05,55.87 184.21,55.87 186.47,58.13 187.07,58.13 188.7,59.76 188.7,60.26 190.22,61.78 193.18,61.78 193.25,61.71 v1(203.33,61.71) 208.6,61.71 210.83,63.94 210.83,66.55 212.26,67.97 212.26,69.56 212.47,69.78 v3(212.49,69.78) 212.36,69.9 212.16,69.9 211.84,70.22 211.84,72.06 212.2,72.43 212.2,73.73 211.77,74.16 v3(211.77,74.92) ; Q1.3 117.79,91.8 C8.1 116.79,91.67 v3(116.65,91.81)
REM_DIODE1_P: length 201
  TOP w0.254: C285.2 213.17,71.3 212.66,71.81 v3(212.47,71.81) 211.84,72.44 211.84,72.8 211.93,72.89 U51.A13
  IN1 w0.254: v3(92.97,54.84) 93,54.88 93,56.17 92.81,56.36 92.81,58.58 94.45,60.22 94.45,80.03 96.08,81.66 96.08,83.62 96.92,84.46 97.61,84.46 107.51,94.35 115.25,94.35 116.27,93.34 116.27,92.7 v3(116.57,92.4)
  BOTTOM w0.254: v3(116.57,92.4) 116.77,92.59 C8.2 118.57,92.59 Q1.1 119.36,93.1 Q1.2 ; v3(92.97,54.84) 93,54.8 93,54.12 98.43,48.69 160.91,48.69 164.02,51.81 171.71,51.81 175.26,55.36 184.42,55.36 186.68,57.62 187.28,57.62 189.21,59.55 189.21,60.05 190.43,61.27 192.97,61.27 193.04,61.2 v1(207.27,61.2) 208.81,61.2 211.34,63.73 211.34,66.34 212.76,67.76 212.76,69.18 212.98,69.4 212.98,71.49 212.66,71.81 v3(212.47,71.81)
REM_DIODE2_N: length 279.8
  TOP w0.254: v3(31.52,140.54) 31.47,140.49 30.88,140.49 C9.2 30.41,140.53 30.02,140.53 Q2.3 ; v3(212.54,74.92) 212.18,74.56 U51.B14 ; C283.1 v3(213.81,69.89)
  IN4 w0.254: v3(31.52,140.54) 31.56,140.5 31.85,140.5 32.54,141.2 34.99,141.2 35.87,140.33 35.87,138.29 46.71,127.44 46.71,124.91 47.79,123.84 47.79,103.47 52.83,98.43 52.83,95.16 55.88,92.12 58.48,92.12 60.28,90.31 80.35,90.31 86.02,84.65 86.02,80.59 91.45,75.16 91.45,52.81 91.67,52.59 91.97,52.59 v3(92.03,52.65)
  BOTTOM w0.254: v3(92.03,52.65) 92.06,52.61 93.32,52.61 98,47.93 156.61,47.93 158.64,45.9 160.42,45.9 164.11,42.22 167.62,42.22 171.83,46.43 171.83,47.32 178.73,54.22 181.34,54.22 181.72,54.6 184.74,54.6 186.07,55.93 187.56,55.93 192.07,60.44 209.15,60.44 213.81,65.1 v3(213.81,69.89) 213.81,71.75 213.04,72.51 v1(213.04,73.23) 213.04,74.03 212.54,74.54 v3(212.54,74.92)
REM_DIODE2_P: length 281
  TOP w0.254: v3(31.52,139.96) 31.5,139.98 30.77,139.98 C9.1 30.41,140.05 30.02,140.05 Q2.2 29.18,139.64 28.53,140.29 Q2.1 ; C283.2 214.44,71.43 v3(214.31,71.55) 214.12,71.75 213.49,71.75 212.43,72.81 U51.A14
  IN4 w0.254: v3(31.52,139.96) 31.56,139.99 32.06,139.99 32.75,140.69 34.78,140.69 35.36,140.11 35.36,138.08 46.2,127.23 46.2,124.7 47.28,123.62 47.28,103.26 52.33,98.22 52.33,94.95 55.67,91.61 58.27,91.61 60.07,89.8 80.14,89.8 85.51,84.44 85.51,80.38 90.95,74.95 90.95,52.6 91.46,52.09 92.01,52.09 v3(92.03,52.07)
  BOTTOM w0.254: v3(214.31,71.55) v1(214.31,70.45) 214.31,64.89 209.36,59.93 192.28,59.93 187.77,55.43 186.28,55.43 184.95,54.09 181.93,54.09 181.55,53.71 178.94,53.71 172.34,47.11 172.34,46.22 167.83,41.71 163.9,41.71 160.21,45.39 158.43,45.39 156.4,47.42 97.79,47.42 93.11,52.1 92.06,52.1 v3(92.03,52.07)
REM_DIODE4_N: length 123.4
  TOP w0.254: v3(202.84,63.18) 202.92,63.26 202.92,63.46 203.36,63.9 210.75,63.9 v2(214.23,67.38) 216.52,69.68 C286.1 216.6,70.42 216.6,71.62 214.87,73.34 U51.A16
  IN4 w0.254: v3(197.39,88.88) 197.4,88.89 198.32,88.89 198.44,88.77 198.44,88.29 199.99,86.74 199.99,86.16 201.32,84.83 201.32,75.59 202.54,74.37 202.54,72.89 202.35,72.7 202.35,70.94 201.84,70.43 201.84,68.45 202.84,67.45 v3(202.84,63.18)
  BOTTOM w0.254: Q3.3 138.72,120.31 C16.1 140.47,120.31 140.67,120.51 143.44,120.51 146.68,117.27 148.16,117.27 155.28,110.15 165.25,110.15 186.25,89.14 194.61,89.14 194.8,88.95 197.31,88.95 v3(197.39,88.88)
REM_DIODE4_P: length 127.6
  TOP w0.254: U51.B17 213.68,73.97 213.8,73.85 215.09,73.85 217.11,71.83 217.11,70.68 C286.2 217.44,69.87 214.59,67.02 210.96,63.39 203.57,63.39 203.42,63.25 v3(203.42,63.18)
  IN4 w0.254: v3(203.42,63.18) 203.35,63.26 203.35,67.66 202.35,68.66 202.35,70.22 202.86,70.73 202.86,72.49 203.05,72.68 203.05,74.58 201.83,75.8 201.83,85.04 200.5,86.38 200.5,86.95 198.95,88.5 198.95,88.98 198.53,89.4 197.45,89.4 v3(197.39,89.46)
  BOTTOM w0.254: v3(197.39,89.46) 195.01,89.46 194.82,89.65 186.46,89.65 165.46,110.66 155.49,110.66 148.37,117.78 146.89,117.78 143.65,121.02 v1(141.8,121.02) 140.67,121.02 140.47,121.22 C16.2 139.51,121.67 Q3.2 138,121.67 137.35,121.02 Q3.1
RES_BIAS: length 4.4
  TOP w0.102: R562.1 244.49,166.66 243.91,166.08 U31.12 243.2,167.05 243.45,167.3 v1(243.45,168.34)
RESET_OUT#: length 134.8
  TOP w0.102: R843.2 211.77,88.39 212.1,88.72 v3(212.98,88.72) ; v3(186.3,104.49) 182.04,104.49 180.95,103.4 172.73,103.4 v1(166.87,109.26) 165.78,110.35 157.73,110.35 156.71,109.34 156.71,104.02 155.2,102.5 155.2,96.29 154.21,95.3 152.78,95.3 150.93,93.45 v3(149.8,93.45) ; U51.B39 211.68,82.64 v3(212.17,82.15) ; RH103.1 RH85.1 183.51,129.34 184.72,129.34 185.23,129.85 v3(185.23,129.91)
  IN4 w0.102: v3(212.17,82.15) 212.64,82.61 212.64,87.67 212.98,88.01 v3(212.98,88.72) 213.6,89.35 213.6,90.95 205.41,99.14 v3(201.74,99.14) ; v3(186.3,104.49) 186.3,108.19 185.75,108.74 185.75,122.43 187.07,123.75 187.07,127.5 185.23,129.34 v3(185.23,129.91)
  BOTTOM w0.102: RC69.1 149.8,90.49 v3(149.8,93.45) ; RH27.1 v3(201.74,99.14) 200.54,100.35 196.18,100.35 191.76,104.77 186.58,104.77 v3(186.3,104.49)
RESET_OUT#_R: length 3
  BOTTOM w0.102: JXDP2.46 v1(204.28,99.38) 203.98,99.38 203.74,99.14 RH27.2
RF_+1.05VSP: length 3.8
  TOP w0.102: v1(177.81,99.67) PR305.1
  TOP w0.254: PR305.1 178.37,97.73 178.37,96.83 178.23,96.68 PU300.5
RING2: length 4.6
  TOP w0.102: v1(284.98,157.2) 284.56,157.2 v3(284.14,157.62)
  IN3 w1.524: 281.5,156.87 280.32,155.69 278.36,155.69
  vias: v3(275.88,155.88) v3(276.47,155.88) v3(277.05,155.88) v3(282.96,157.62) v3(283.54,157.62)
RING2_L: length 11.9
  TOP w1.524: 299.02,164.9 298.13,164.01 292.94,164.01 289.1,160.18
  vias: v2(287.06,157.66)
RSMRST#: length 5.9
  TOP w0.102: v1(176.47,119.9) 176.68,119.69 R1630.1 177.47,118.66 176.85,118.04 U9.2 175.59,118.04 R1622.1 175.13,117.58 U8.3
RSMRST#_XDP: length 3.3
  BOTTOM w0.102: RH26.2 214.68,100.08 213.88,100.88 v1(213.68,100.88) JXDP2.39
RTN_VGA: length 32.6
  TOP w0.203: PU600.13 26.25,147.71 26.59,147.37 26.61,147.37
  TOP w0.254: v3(46.68,134.87) 46.68,135.55 PR657.2 ; PC630.2 27.24,145.66 v3(27.18,145.72) 26.95,145.95 26.95,146.86 26.84,146.97 26.84,147.14 26.61,147.37
  IN1 w0.254: v3(27.18,145.72) 27.08,145.62 26.91,145.62 26.91,145.62 26.63,145.62 26.06,145.05 26.06,143.72 27.01,142.76 30.7,142.76 32.5,140.96 34.57,140.96 38.32,137.21 41.82,137.21 44.4,134.64 46.45,134.64 v3(46.68,134.87)
  BOTTOM w0.102: v3(27.18,145.72) 27.78,145.72 v1(28.11,146.05)
RUN_ON: length 251.3
  TOP w0.102: v3(180.02,36.57) 178.18,38.41 175.74,38.41 175.19,38.97 175.19,40.48 175.15,40.51 U37.5 ; U146.5 221.49,128.07 221.86,128.44 222.85,128.44 224.12,127.17 v3(224.12,115.31) ; v3(188.55,58.21) 188.43,58.21 188.01,58.63 RP6.1 ; PR406.1 201.11,51.3 200.66,50.85 199.99,50.85 199.59,51.25 193.78,51.25 191.12,53.91 v2(189.1,53.91) v3(186.89,53.91) ; U46.A11 192.03,69.06 v3(192.65,69.68) ; Q52.2 156.15,113.07 v3(156.65,113.58) ; R717.1 v3(235.65,68.51)
  IN1 w0.102: v3(186.89,53.91) 186.89,51.94 185.74,50.79 182.84,50.79 180.66,48.61 180.66,37.2 v3(180.02,36.57) ; v3(192.65,69.68) 193.12,69.21 195.26,69.21 196.29,68.18 201.28,68.18 202.66,69.55 208.26,69.55 210.19,67.62 212.82,67.62 213.05,67.85 226.2,67.85 227.09,66.96 229.3,66.96 229.81,67.47 234.61,67.47 v3(235.65,68.51)
  IN2 w0.127: v3(199.91,105.86) 199.91,102.55 200.95,101.51 200.95,96.34 196.37,91.76 196.37,84.8 194.67,83.1 194.67,79.63 194.53,79.5 194.53,76.53 194.59,76.47 194.59,71.31 192.95,69.68 v3(192.65,69.68)
  IN3 w0.127: v3(224.12,115.31) 224.47,114.95 224.47,107.11 222.92,105.57 206.78,105.57 206.65,105.69 202.88,105.69 202.72,105.86 v3(199.91,105.86) 197.49,105.86 197.06,106.29 180.92,106.29 178.95,108.27 168.96,108.27 166.15,111.08 164.9,111.08 164.22,111.76 163.29,111.76 162.53,112.53 157.71,112.53 v3(156.65,113.58)
  IN4 w0.102: 188.53,58.21 188.22,57.89 188.22,55.23 v3(186.89,53.91) ; 188.53,58.21 v3(188.55,58.21) ; 188.53,58.21 188.53,59.15 189.76,60.38 189.76,60.85 190.64,61.73 190.64,62.98 190.92,63.27 190.92,63.94 191.41,64.43 191.41,68.54 191.94,69.08 192.18,69.08 192.65,69.55 v3(192.65,69.68)
RUN_ON_ENABLE#: length 266.1
  TOP w0.102: 156.67,41.19 157.86,42.38 v3(157.86,47.55) ; 156.67,41.19 Q71.2 ; 156.67,41.19 159.69,38.17 159.69,28.03 Q72.2 ; v3(218.73,91.3) 218.76,91.3 221.36,88.7 221.36,85.61 221.82,85.15 Q45.2 ; v3(102.16,52.67) 102.16,53.66 102.53,54.03 102.81,54.03 103.59,54.81 QC1.2 ; Q70.2 156.01,117.29 156.15,117.15 Q52.5 156.15,114.48 156.08,114.42 155.64,114.42 155.5,114.56 Q52.6 155.33,114.8 R909.2 154.34,113.8 v1(151.39,113.8) v3(149.82,113.8)
  IN2 w0.127: v3(157.86,47.55) 157.86,54.56 157.2,55.22 157.2,78.4 152.85,82.76 152.85,89.35 151.4,90.8 151.4,96.96 147.76,100.6 147.76,107.96 149.82,110.01 149.82,113.79 v3(149.82,113.8)
  IN3 w0.127: v3(102.16,52.67) 106.44,52.67 112.83,46.28 156.59,46.28 v3(157.86,47.55) ; v3(149.82,113.8) 153.96,113.8 156.5,111.26 162,111.26 163.45,109.81 165.63,109.81 168.44,107 178.42,107 180.4,105.02 196.53,105.02 197.97,103.58 203.94,103.58 209.2,98.32 212.57,98.32 215.62,95.26 215.62,93.35 217.67,91.3 v3(218.73,91.3)
RUNPWROK: length 192.8
  TOP w0.102: U51.B26 213.79,78.79 v3(213.45,78.45) ; v3(100.98,50.69) 100.98,50.51 RC7.2 ; RP17.8 214.39,89.82 214.57,89.64 216.85,89.64 217.93,90.72 v3(218.73,90.72) 218.76,90.72 220.79,88.69 v1(220.79,88) 220.79,85.93 219.93,85.07 219.93,81.95 Q45.1 221.17,79.13 221.98,78.33 v3(221.98,77.84) ; R3772.1 199.54,90.1 199.73,89.91 U50.2 200.52,89.91 v3(201.25,90.63)
  IN1 w0.102: v3(201.25,90.63) 202.69,90.63 203.14,91.07 205.71,91.07 206.04,90.74 209.57,90.74 210.09,90.22 213.21,90.22 213.7,90.72 v3(218.73,90.72) ; v3(221.98,77.84) 221.98,77.88 221.75,78.11 218.77,78.11 218.16,77.5 215.23,77.5 214.25,78.48 213.47,78.48 v3(213.45,78.45)
  BOTTOM w0.102: v3(221.98,77.84) 220.73,77.84 220.03,77.14 216.04,77.14 214.39,75.49 212.81,75.49 212.7,75.61 211.49,75.61 210.95,75.06 210.95,71.26 210.19,70.5 210.19,66.87 210.15,66.83 210.15,66.68 207.19,63.72 196.53,63.72 196.04,63.23 192.94,63.23 192.17,62.46 188.02,62.46 187.62,62.06 187.62,60.32 186.55,59.25 185.43,59.25 184.53,58.35 181.58,58.35 180.78,57.55 177.5,57.55 176.53,58.51 172.59,58.51 171.76,57.67 166.84,57.67 160.46,51.3 108.15,51.3 107.66,50.82 101.11,50.82 v3(100.98,50.69)
RUNPWROK_AND: length 10.1
  TOP w0.102: RC6.2 RC10.2 106.52,54.71 106.75,54.49 v2(106.75,54.24) 106.75,54.03 106.57,53.85 105.63,53.85 RC16.1 104.73,52.95 RC9.1 105.59,52.06 RC15.2 105.43,51.87 UC1.4 105.43,50.42 105.54,50.31 107.02,50.31 QC5.1
RUNPWROK_R: length 14.7
  TOP w0.102: RC103.1 v2(107.79,51.67) 108.04,51.41 108.04,50.48 107.38,49.82 107.38,48.76 107.32,48.7 QC5.2 ; QC5.2 106.67,47.64 RC104.1 CC138.1 ; QC5.2 106.23,48.7 105.91,49.02 105.91,49.65 105.74,49.82 104.27,49.82 104.13,49.68 UC1.1 104.13,48.3 104.02,48.19 103.75,48.19 103.57,48.38 103.57,48.83 RC7.1 103.06,49.41 RC5.2
S3_1.35V: length 2.8
  TOP w0.203: PR208.2 v1(179.45,85.96) 179.22,86.19 PU200.7
S5_1.35V: length 4.3
  TOP w0.203: PU200.8 179.76,86.59 179.83,86.67 PC215.1
  TOP w0.254: PR206.2 180.52,87.68 PC215.1 PR210.2
SATA_ACT#: length 87.2
  TOP w0.102: Q74.4 226.93,109.07 v3(226.68,109.31)
  IN1 w0.102: v3(225.74,118.32) 227.04,117.02 227.04,109.65 226.7,109.31 v3(226.68,109.31)
  IN3 w0.127: v3(160.27,124.79) 161.6,124.79 162.91,123.49 164.73,123.49 164.98,123.23 167.67,123.23 168.83,122.06 169.42,122.06 169.61,122.25 171.16,122.25 172.14,121.27 173.75,121.27 174.15,120.86 175.53,120.86 176.06,120.32 176.06,120.28 177.14,119.2 185.3,119.2 188.09,116.41 196.41,116.41 196.71,116.72 201.97,116.72 202.27,117.01 209.21,117.01 209.98,116.23 214.67,116.23 215.33,116.89 220.79,116.89 222.09,118.2 225.62,118.2 v3(225.74,118.32)
  BOTTOM w0.089: 161.2,126.62 161.2,127.37 161.72,127.89 161.72,128.18 162.03,128.49 162.03,128.93 UH1.AP3
  BOTTOM w0.102: v3(160.27,124.79) 160.27,125.22 161.2,126.14 161.2,126.62 ; v1(226.95,118.04) 226.67,118.32 v3(225.74,118.32)
SATA_COMP: length 4.9
  TOP w0.089: v3(159.16,129.51) 159.31,129.36 159.31,128.63 v1(158.9,128.22)
  TOP w0.254: RH57.1 157.63,128.9 157.63,129.14 157.98,129.48 159.13,129.48 v3(159.16,129.51)
  BOTTOM w0.254: UH1.AY5 159.43,129.78 v3(159.16,129.51)
SATA_IREF: length 2.8
  TOP w0.089: RH51.2 157.33,129.28 v3(157.99,129.94) 157.62,130.3 v1(157.09,130.3)
  BOTTOM w0.089: v3(157.99,129.94) 157.81,129.76 UH1.BD4
SATA_LED: length 58
  TOP w0.102: R934.2 v3(230.85,109.67) ; v2(255.08,152.2) 254.75,152.2 v3(254.44,152.5) 254.44,152.78 254.67,153 JLED1.4
  IN3 w0.127: v3(230.85,109.67) 230.85,114.07 233.17,116.4 235.34,116.4 241.72,122.78 241.72,132.34 245.67,136.29 245.67,137.57 248.95,140.85 248.95,143.69 251.22,145.95 251.22,149.74 253.98,152.5 v3(254.44,152.5)
SATA_ODD_PRX_DTX_N1: length 7.2
  TOP w0.102: JSATA2.5 164.52,35.4 164.66,35.4 165.42,34.64 166.01,34.64 167.16,35.78 168.38,35.78 168.72,35.44 169.51,35.44 C405.1
SATA_ODD_PRX_DTX_N1_C: length 137.8
  TOP w0.102: v3(171.57,35.26) 171.05,35.26 C405.2
  IN4 w0.114: v3(171.57,35.26) 169.74,35.26 168.59,36.41 168.59,38.02 167.19,39.42 162.5,39.42 159.58,42.35 159.58,55.18 161.19,56.8 161.19,60.5 165.66,64.97 165.66,75.21 170.62,80.17 174.94,80.17 178.46,83.68 178.46,88.34 178.67,88.56 178.67,89.79 178.43,90.03 178.43,99.18 173.61,104 170.59,104 168.78,105.81 163.29,105.81 153.88,115.22 153.88,116.11 153.01,116.98 153.01,124.42 154.26,125.67 154.26,127.84 154.61,128.2 154.61,129.35 153.54,130.42 153.54,130.92 v3(153.99,131.36)
  BOTTOM w0.089: 155.67,132.15 155.68,132.15 155.69,132.15 156.29,132.15 156.59,132.45 157.22,132.45 157.51,132.16 157.99,132.16 UH1.BC10
  BOTTOM w0.102: v3(153.99,131.36) 154.78,132.15 155.67,132.15
SATA_ODD_PRX_DTX_P1: length 7.2
  TOP w0.102: JSATA2.6 164.57,35.61 164.75,35.61 165.51,34.85 165.93,34.85 167.07,35.99 168.47,35.99 168.81,35.66 169.51,35.66 C404.1
SATA_ODD_PRX_DTX_P1_C: length 137.7
  TOP w0.102: v3(171.57,35.84) 171.23,35.5 170.68,35.5 170.56,35.61 170.56,35.79 C404.2
  IN4 w0.114: v3(154.4,130.95) 153.9,130.95 153.77,130.82 153.77,130.51 154.84,129.45 154.84,128.1 154.48,127.75 154.48,125.57 153.24,124.33 153.24,117.08 154.11,116.21 154.11,115.31 163.39,106.04 168.88,106.04 170.68,104.23 173.71,104.23 178.66,99.28 178.66,90.13 178.9,89.88 178.9,88.46 178.68,88.25 178.68,83.59 175.03,79.94 170.71,79.94 165.89,75.12 165.89,64.87 161.42,60.4 161.42,56.7 159.81,55.09 159.81,42.44 162.6,39.65 167.29,39.65 168.82,38.12 168.82,36.5 169.84,35.49 171.22,35.49 v3(171.57,35.84)
  BOTTOM w0.089: 155.67,131.94 155.68,131.94 155.69,131.95 156.37,131.95 156.67,132.25 156.82,132.25 156.88,132.2 156.88,131.98 156.94,131.92 157.1,131.92 157.18,131.99 UH1.BE10
  BOTTOM w0.102: 155.67,131.94 154.87,131.94 154.4,131.47 154.4,130.96 v3(154.4,130.95)
SATA_ODD_PTX_DRX_N1: length 7
  TOP w0.102: JSATA2.3 164.5,31.87 165.31,31.87 167.06,33.62 v4(168.91,33.62) 169.51,33.62 C406.1
SATA_ODD_PTX_DRX_N1_C: length 139.8
  TOP w0.102: v3(173.1,33.8) 172.78,33.47 171.38,33.47 C406.2
  IN4 w0.089: 158.26,130.4 158.27,130.4 158.28,130.41 158.35,130.41 158.36,130.42 158.73,130.42 159.11,130.8 159.22,130.8 159.65,131.23 159.65,131.43 v3(159.89,131.66)
  IN4 w0.114: v3(173.1,33.8) 172.79,33.49 172.56,33.49 172.47,33.59 172.47,36.15 171.61,37.01 171.2,37.01 167.71,40.5 162.95,40.5 160.66,42.79 160.66,54.21 162.72,56.28 162.72,59.06 166.96,63.3 166.96,74.98 171.06,79.09 175.38,79.09 179.75,83.45 179.75,91 179.51,91.25 179.51,99.79 173.03,106.27 169.85,106.27 169.19,106.92 163.77,106.92 159.94,110.75 159.94,111.58 154.09,117.43 154.09,123.92 155.89,125.72 155.89,126.26 156.44,126.81 156.44,130.01 156.82,130.4 158.26,130.4
  BOTTOM w0.089: v3(159.89,131.66) 159.89,131.74 UH1.AV10
SATA_ODD_PTX_DRX_P1: length 7
  TOP w0.102: C407.1 169.51,33.41 169.2,33.41 169.19,33.39 168.64,33.39 168.62,33.41 167.15,33.41 165.4,31.66 164.59,31.66 JSATA2.2
SATA_ODD_PTX_DRX_P1_C: length 139.8
  TOP w0.102: C407.2 171.08,33.26 173.05,33.26 v3(173.1,33.22)
  IN4 w0.089: v3(159.3,131.67) 159.45,131.51 159.45,131.32 159.14,131 159.03,131 158.64,130.62 158.27,130.62 158.26,130.63
  IN4 w0.114: v3(173.1,33.22) 173.05,33.26 172.47,33.26 172.24,33.49 172.24,36.06 171.51,36.78 171.11,36.78 167.62,40.27 162.85,40.27 160.43,42.7 160.43,54.31 162.49,56.37 162.49,59.16 166.73,63.39 166.73,75.07 170.97,79.31 175.29,79.31 179.52,83.55 179.52,90.91 179.28,91.15 179.28,99.69 172.93,106.04 169.75,106.04 169.1,106.7 163.67,106.7 159.71,110.66 159.71,111.49 153.86,117.34 153.86,124.01 155.67,125.81 155.67,126.36 156.21,126.9 156.21,130.11 156.73,130.63 158.26,130.63
  BOTTOM w0.089: UH1.AW10 159.3,131.75 v3(159.3,131.67)
SATA_PRX_DKTX_N2: length 3.8
  TOP w0.102: v3(132.33,167.63) 132.15,167.44 132.15,167.06 132.65,166.55 132.65,166.39 C698.2
  BOTTOM w0.102: v3(132.33,167.63) 132.17,167.79 132.17,168.16 132.34,168.33 JDOCK1.56
SATA_PRX_DKTX_N2_C: length 55.1
  TOP w0.102: v3(151.76,130.09) 151.68,130.09 151.67,130.08 150.45,130.08 148.86,131.68 148.86,143.65 147.59,144.92 147.59,150.22 146.57,151.23 146.57,156.93 145.89,157.62 143.3,157.62 141.99,158.93 140.91,158.93 138.34,161.51 135.59,161.51 132.84,164.25 132.84,164.95 C698.1
  BOTTOM w0.089: 155.67,131.31 155.68,131.33 155.69,131.33 155.73,131.37 155.73,131.37 155.85,131.48 156.45,131.48 156.71,131.74 157.33,131.74 157.51,131.92 157.77,131.92 158.03,131.66 UH1.BB9
  BOTTOM w0.102: v3(151.76,130.09) 152.95,130.09 153.17,130.31 154.67,130.31 155.67,131.31
SATA_PRX_DKTX_P2: length 3.8
  TOP w0.102: C697.2 132.44,166.35 132.44,166.46 131.94,166.97 131.94,167.44 v3(131.75,167.63)
  BOTTOM w0.102: JDOCK1.54 131.84,168.38 131.95,168.27 131.95,167.83 v3(131.75,167.63)
SATA_PRX_DKTX_P2_C: length 55
  TOP w0.102: C697.1 132.63,164.6 132.63,164.16 135.5,161.29 138.25,161.29 140.83,158.72 141.9,158.72 143.21,157.41 145.8,157.41 146.36,156.85 146.36,151.14 147.38,150.13 147.38,144.83 148.64,143.57 148.64,131.59 150.36,129.87 151.39,129.87 v3(151.76,129.51)
  BOTTOM w0.089: UH1.BD9 157.63,131.51 157.56,131.44 157.4,131.44 157.3,131.54 156.79,131.54 156.53,131.28 155.93,131.28 155.84,131.2 155.83,131.19 155.83,131.18 155.82,131.17
  BOTTOM w0.102: v3(151.76,129.51) 152.12,129.87 153.02,129.87 153.25,130.1 154.75,130.1 155.82,131.17
SATA_PRX_DTX_N0: length 7.1
  BOTTOM w0.102: JSATA1.5 82.98,56.72 83.51,56.19 v4(84.71,56.19) 85.75,56.19 86.26,56.7 86.26,56.73 86.65,57.11 86.67,57.11 86.95,57.39 87.49,57.39 C385.1
SATA_PRX_DTX_P0: length 7.1
  BOTTOM w0.102: C386.1 87.47,57.18 87.04,57.18 v4(86.62,56.76) 85.84,55.98 85.03,55.98 85.01,55.96 84.44,55.96 84.42,55.98 83.51,55.98 82.98,55.45 JSATA1.6
SATA_PTX_DKRX_N2: length 3.8
  TOP w0.102: C700.1 134.39,166.43 134.39,166.66 133.76,167.28 133.76,167.52 v3(133.93,167.68)
  BOTTOM w0.102: v3(133.93,167.68) 133.73,167.87 133.73,168.22 133.84,168.33 JDOCK1.62
SATA_PTX_DKRX_N2_C: length 56
  TOP w0.089: 157.9,131.77 157.91,131.78 157.92,131.78 157.96,131.82 158.05,131.82 158.63,131.82 159.05,132.24 159.47,132.24 159.53,132.3 159.53,132.51 159.4,132.64 v3(159.3,132.64)
  TOP w0.102: C700.2 134.46,165.12 134.35,165.01 134.35,164.79 134.11,164.54 134.11,164.01 v4(134.47,163.65) 135.92,162.2 139.03,162.2 139.05,162.22 139.61,162.22 139.63,162.2 139.99,162.2 143.83,158.36 146.31,158.36 147.27,157.4 147.27,151.52 148.28,150.5 148.28,145.21 149.55,143.94 149.55,132.62 151.05,131.12 152.15,131.12 152.85,130.42 154.52,130.42 155.65,131.55 157.68,131.55 157.9,131.77
  BOTTOM w0.089: v3(159.3,132.64) 159.3,132.95 UH1.AY13
SATA_PTX_DKRX_P2: length 3.8
  TOP w0.102: C699.1 134.18,166.31 134.18,166.57 133.55,167.19 133.55,167.47 v3(133.34,167.68)
  BOTTOM w0.102: JDOCK1.60 133.34,168.34 133.52,168.16 133.52,167.86 v3(133.34,167.68)
SATA_PTX_DKRX_P2_C: length 56.1
  TOP w0.089: v3(159.88,132.64) 159.73,132.49 159.73,132.22 159.55,132.04 159.13,132.04 158.71,131.62 158.13,131.62 158.05,131.62 158.05,131.62
  TOP w0.102: 158.05,131.62 157.77,131.34 155.74,131.34 154.61,130.21 152.76,130.21 152.06,130.91 150.96,130.91 149.34,132.53 149.34,143.85 148.07,145.12 148.07,150.42 147.06,151.43 147.06,157.31 146.22,158.15 143.74,158.15 139.9,161.99 v4(139.32,161.99) 135.83,161.99 134.53,163.29 134.5,163.29 134.11,163.68 134.11,163.71 133.9,163.92 C699.2
  BOTTOM w0.089: UH1.AW13 159.88,132.96 v3(159.88,132.64)
SATA_PTX_DRX_N0: length 6.9
  BOTTOM w0.102: C384.1 87.56,58.9 v4(86.74,58.9) 85.12,58.9 84.9,59.12 84.87,59.12 84.48,59.51 84.48,59.53 84.23,59.79 83.51,59.79 82.98,59.26 JSATA1.3
SATA_PTX_DRX_P0: length 7
  BOTTOM w0.102: C383.1 87.43,59.11 87.03,59.11 87.02,59.13 86.47,59.13 86.45,59.11 85.21,59.11 v4(84.84,59.48) 84.31,60 83.51,60 82.98,60.53 JSATA1.2
SB#: length 3.5
  TOP w0.102: U2.8 v1(275.07,181.47) 275.07,181.02 274.77,180.71 R153.2 R1626.2
SD_CD#: length 25.1
  TOP w0.102: v3(201.39,32.1) 201.39,31.32 v1(201.7,31.01) 201.73,30.98 C802.2 R3884.1 203.77,30.23 203.53,29.99 203.53,29.09 JSD1.17 ; U38.21 187.39,22.85 v3(187.2,22.66)
  BOTTOM w0.102: v3(187.2,22.66) 188.09,23.55 191.36,23.55 194.46,26.65 195.94,26.65 v3(201.39,32.1)
SD_CLK: length 27.2
  TOP w0.102: v3(183.86,30.71) 183.86,31.83 v1(184.34,32.31) 184.8,32.77 R676.2 ; JSD1.5 v3(205.03,27.37)
  IN2 w0.127: v3(205.03,27.37) 203.09,29.31 184.8,29.31 183.86,30.26 v3(183.86,30.71)
SD_CLK_R: length 2.4
  TOP w0.102: U38.43 186.19,30.34 v1(185.65,30.88) 185.61,30.91 R676.1
SD_CMD: length 32.1
  TOP w0.102: JSD1.2 v3(214.03,27.38) ; U38.45 185.39,30.38 v3(185.23,30.53)
  IN2 w0.127: v3(214.03,27.38) 213.14,28.27 207.47,28.27 206,29.75 186.02,29.75 v3(185.23,30.53)
SD_D0_RCLK_P_MMC_D0: length 7.1
  TOP w0.089: RE28.2 196.38,31.92 LE5.3 196.96,31.92 197.46,31.42 v4(199.39,31.42) 199.76,31.42 200.31,30.88 200.31,29.77 200.53,29.55 JSD1.7
SD_D0_RCLKR_P: length 24.8
  TOP w0.089: U38.30 189.91,26.46 190.15,26.22 190.76,26.22 v3(191.01,25.96) 191.16,25.81 191.65,25.81 192.06,26.22 193.96,26.22 194.18,26.44 194.18,29.49 194.02,29.65 193.48,29.65 193.17,29.97 193.17,31.3 193.49,31.61 194.12,31.61 194.43,31.92 LE5.4 195.16,31.92 RE28.1 ; U38.38 188.19,30.25 188.54,30.6 v3(188.54,30.67)
  IN1 w0.089: v3(191.01,25.96) 190.85,25.96 190.64,26.18 190.03,26.18 189.87,26.34 189.87,28.83 189.63,29.07 188.58,29.07 188.49,29.16 188.49,29.51 188.58,29.6 189.63,29.6 189.87,29.84 189.87,31.08 189.59,31.36 188.85,31.36 188.61,31.12 188.61,30.75 v3(188.54,30.67)
SD_D1_RCLK_N: length 7.1
  TOP w0.089: JSD1.8 199.03,29.56 199.18,29.71 199.84,29.71 200.01,29.89 200.01,30.76 199.64,31.13 v4(197.74,31.13) 197.18,31.13 197.12,31.07 LE5.2 196.37,31.07 RE27.2
SD_D1_RCLKR_N: length 24.9
  TOP w0.089: U38.37 188.59,30.14 v3(189.12,30.67) ; RE27.1 195.17,31.07 LE5.1 194.4,31.07 194.15,31.32 193.61,31.32 193.46,31.17 193.46,30.09 193.6,29.95 194.14,29.95 194.48,29.61 194.48,26.32 194.08,25.92 192.18,25.92 191.77,25.52 191.2,25.52 v3(191.01,25.33) 191.01,25.39 190.44,25.96 189.99,25.96 189.9,26.06 U38.29
  IN1 w0.089: v3(191.01,25.33) 190.76,25.58 190.76,25.64 190.48,25.92 189.93,25.92 189.61,26.24 189.61,28.73 189.52,28.82 188.47,28.82 188.23,29.05 188.23,29.62 188.47,29.86 189.52,29.86 189.61,29.95 189.61,30.98 189.49,31.11 188.96,31.11 188.86,31.01 188.86,30.93 v3(189.12,30.67)
