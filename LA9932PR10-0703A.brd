# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VSUM-_VGA: length 37
  TOP w0.254: v3(34.8,149.09) 35.05,149.34 PR624.2 ; PC632.1 29.97,146.17 PC626.2 ; PR655.2 PR659.2 29.59,146.55 PC626.2 ; v3(30.93,146.1) 30.86,146.17 PC627.2 30.49,146.36 PC626.2 ; v3(25.91,142.48) PC615.2 PC616.2 ; PR654.2 32.01,152.02 v3(31.93,151.95)
  IN1 w0.254: v3(25.91,142.48) 25.91,143.25 25.59,143.56 25.59,145.21 26.86,146.48 30.55,146.48 v3(30.93,146.1)
  IN2 w0.254: v3(34.8,149.09) 32.58,146.87 31.69,146.87 v3(30.93,146.1)
  BOTTOM w0.254: PH601.2 28.2,155.36 v1(28.2,153.34) 28.2,152.71 30.23,150.68 30.23,147.44 30.93,146.74 v3(30.93,146.1) ; v3(34.8,149.09) 34.79,149.09 31.93,151.95 v3(31.93,151.95)
VSYNC: length 5.3
  BOTTOM w0.089: v1(172.61,149.16) 171.56,148.12 171.56,147.72 171.37,147.53 171.08,147.24 170.64,146.8 170.64,146.32 UH1.N44
  BOTTOM w0.102: RH95.2 173.14,149.7 v1(172.61,149.16)
VSYNC_BUF: length 149.8
  IN4 w0.102: v3(132.13,152.57) 131.71,152.99 130.52,152.99 129.1,151.57 113.13,151.57 112.55,150.99 109.17,150.99 102.99,144.82 97.64,144.82 97.01,145.45 91.65,145.45 90.56,144.36 86.56,144.36 86.21,144.71 82.04,144.71 81.15,143.82 79.63,143.82 78.52,142.71 72.22,142.71 70.33,144.59 62.13,144.59 59.03,147.69 56.14,147.69 55.92,147.48 52.27,147.48 48.15,151.59 47.81,151.59 37.68,161.72 36.14,161.72 34.08,161.72 32.53,163.27 28.84,163.27 20.75,171.36 10.78,171.36 7.28,174.87 6.99,174.87 6.48,175.38 v3(6.48,175.5)
  BOTTOM w0.102: v3(132.13,152.57) 132.25,152.7 U6.18 ; v3(6.48,175.5) 6.67,175.5 6.9,175.73 7.34,175.73 7.6,175.99 7.6,176.58 6.93,177.25 JIO1.4
VSYNC_DOCK: length 12.1
  TOP w0.102: v3(135.38,159.88) 135.12,159.62 135.07,159.62 134.48,159.03 133.85,159.03 133.29,158.47 133.29,156.5 v1(133.08,156.29) 131.89,155.1 131.89,153.85 132.77,152.98 v3(132.77,152.21)
  BOTTOM w0.102: v3(132.77,152.21) 132.85,152.3 U6.17 ; v3(135.38,159.88) 135.34,159.93 JDOCK1.67
VW_VGA: length 3.3
  TOP w0.203: PU600.6 23.38,145.52 23.62,145.28 v1(23.62,145.1) 23.62,144.85 24.13,144.34 PC611.1
  TOP w0.254: PR638.1 PC611.1
WCKA0_0: length 21.4
  TOP w0.089: UV4.D4 v3(81.8,106.46)
  BOTTOM w0.089: UV4.D4 v3(81.8,106.46) ; UV1.E32 82.32,125 83.31,124.01 83.31,123.28 83.33,123.26 83.33,123.24
  BOTTOM w0.127: v3(81.8,106.46) 82.48,106.46 82.68,106.66 82.98,106.66 83.34,107.01 v4(83.34,111.81) 83.34,122.9 83.33,122.91 83.33,123.24
WCKA0_1: length 30.7
  TOP w0.089: UV4.P4 v3(81.8,99.26)
  IN1 w0.114: v3(75.71,121.68) 76.05,121.34 76.27,121.34 77.92,119.69 77.92,101.72 78.49,101.15 78.93,101.15 79.31,100.76 79.31,99.75 79.7,99.37 80.97,99.37 81.49,98.85 81.76,98.85 81.89,98.97 81.89,99.17 v3(81.8,99.26)
  BOTTOM w0.089: UV4.P4 v3(81.8,99.26) ; UV1.A21 74.98,122.28 75.33,121.92 75.33,121.63 75.48,121.49 75.53,121.49 v3(75.71,121.68)
WCKA0B_0: length 21.6
  TOP w0.089: UV4.D5 v3(81.8,107.26)
  BOTTOM w0.089: UV4.D5 v3(81.8,107.26) ; 83.07,123.24 83.07,123.26 83.09,123.28 83.09,123.91 82.3,124.7 81.88,124.7 81.58,125 UV1.E30
  BOTTOM w0.127: 83.07,123.24 83.07,122.8 83.07,122.79 v4(83.07,113.78) 83.07,107.12 82.87,106.93 82.68,106.93 82.34,107.26 v3(81.8,107.26)
WCKA0B_1: length 31.5
  TOP w0.089: UV4.P5 v3(81.8,98.46)
  IN1 w0.114: v3(75.71,121.12) 76.2,121.12 77.71,119.6 77.71,101.63 78.4,100.94 78.85,100.94 79.11,100.68 79.11,99.67 79.61,99.17 80.88,99.17 81.4,98.64 81.62,98.64 v3(81.8,98.46)
  BOTTOM w0.089: v3(75.71,121.12) 75.57,121.26 75.38,121.26 75.11,121.54 75.11,121.83 74.75,122.18 74.75,123.18 74.68,123.26 74.68,123.75 74.98,124.06 UV1.C21 ; UV4.P5 v3(81.8,98.46)
WCKA1_0: length 24.1
  TOP w0.089: UV3.P4 v3(66.66,107.26)
  BOTTOM w0.089: v3(66.66,107.26) UV3.P4 ; 68.64,120.58 68.62,120.6 68.62,121.74 68.18,122.18 68.18,123 68.08,123.1 68.08,124.5 UV1.E13
  BOTTOM w0.127: v3(66.66,107.26) 66.19,107.26 65.86,106.94 64.63,106.94 64.26,107.31 v4(64.26,111.62) 64.26,116.23 67.46,119.42 68,119.42 68.64,120.07 68.64,120.58
WCKA1_1: length 41.9
  TOP w0.089: UV3.D4 v3(66.66,98.46)
  IN1 w0.114: v3(60.98,124.64) 61.05,124.71 61.56,124.71 62.4,123.87 63.35,123.87 63.68,123.54 63.68,116.56 59.07,111.95 57.64,111.95 56.48,110.79 56.48,102.04 57.65,100.87 60.95,100.87 61.64,100.18 64.12,100.18 65.63,98.67 66.45,98.67 v3(66.66,98.46)
  BOTTOM w0.089: UV3.D4 v3(66.66,98.46) ; v3(60.98,124.64) 61.34,125 UV1.E3
WCKA1B_0: length 24.2
  TOP w0.089: UV3.P5 v3(66.66,106.46)
  BOTTOM w0.089: 68.37,120.58 68.37,120.6 68.39,120.61 68.39,121.64 67.95,122.08 67.95,122.1 67.38,122.67 67.38,123.05 67.48,123.15 67.48,124.3 UV1.D12 ; UV3.P5 v3(66.66,106.46)
  BOTTOM w0.127: v3(66.66,106.46) 66.05,106.46 65.84,106.67 64.52,106.67 64,107.2 v4(64,115.27) 64,116.34 67.35,119.69 67.89,119.69 68.37,120.18 68.37,120.58
WCKA1B_1: length 41.8
  TOP w0.089: UV3.D5 v3(66.66,99.26)
  IN1 w0.114: v3(66.66,99.26) 66.66,99.01 66.52,98.87 65.71,98.87 64.2,100.39 61.72,100.39 61.04,101.07 57.73,101.07 56.68,102.12 56.68,110.71 57.72,111.75 59.15,111.75 63.88,116.48 63.88,123.63 63.44,124.07 62.49,124.07 61.66,124.9 61.66,125.16 v3(61.78,125.28)
  BOTTOM w0.089: UV3.D5 v3(66.66,99.26)
  BOTTOM w0.1: UV1.F4 v3(61.78,125.28)
WEA0#: length 34.8
  TOP w0.089: UV4.L12 v3(87.4,101.66)
  IN4 w0.127: v3(78.53,126.2) 78.23,126.49 78.23,127.14 78.52,127.42 79.66,127.42 80.86,126.22 80.86,123.05 82.06,121.85 82.09,121.85 83.12,120.82 83.12,117.36 86.95,113.53 86.95,112.88 87.81,112.02 87.81,108.46 88.78,107.5 88.78,102.42 88.33,101.97 87.71,101.97 v3(87.4,101.66)
  BOTTOM w0.089: UV4.L12 v3(87.4,101.66)
  BOTTOM w0.13: UV1.G25 v3(78.53,126.2)
WEA1#: length 32.4
  TOP w0.089: UV3.G12 v3(61.06,101.66)
  IN4 w0.127: v3(61.06,101.66) 60.67,102.05 60.67,102.71 60.52,102.86 59.95,102.86 59.57,103.24 59.57,104.2 60.66,105.29 60.66,110.09 60.52,110.23 60.52,112.26 64.42,116.16 64.42,118.81 65.18,119.56 65.18,123.67 64.57,124.27 64.57,127.25 64.71,127.39 65.51,127.39 v3(65.91,127)
  BOTTOM w0.089: UV3.G12 v3(61.06,101.66)
  BOTTOM w0.13: UV1.H10 66.18,127.27 v3(65.91,127)
WIGIG60GHZ_DIS#: length 111
  TOP w0.102: U46.A1 191.71,64.06 191.77,64 191.77,63.45 v3(191.94,63.28) ; R694.1 210.86,150.21 D35.1 210.46,150.91 210.28,151.09 207.88,151.09 206.27,149.48 197.69,149.48 193.08,144.87 v1(193.08,144.39) 193.08,143.28 v3(193.55,142.81)
  IN4 w0.102: v3(191.94,63.28) 191.77,63.45 191.77,65.08 192.15,65.46 193.27,65.46 193.74,65.93 193.74,67.23 194.86,68.35 194.86,70.46 194.16,71.16 194.16,73.87 192.05,75.97 192.05,78.6 193.04,79.59 193.04,86.99 192.72,87.3 192.72,89.94 192.98,90.19 192.98,94.64 194.47,96.13 194.47,101.36 194.81,101.7 194.95,101.83 195.08,101.97 195.08,112.97 194.27,113.78 194.27,119.33 195.2,120.26 195.2,121.72 194.85,122.07 194.85,131.28 194.41,131.73 194.41,132.71 193.77,133.35 193.77,142.59 v3(193.55,142.81)
WIGIG60GHZ_DIS#_R: length 8.6
  TOP w0.102: v3(207.86,148.34) 208.32,148.8 208.6,148.8 R725.1 R694.2 208.61,150.61 D35.2
  BOTTOM w0.102: v1(207.14,146.29) 207.86,147.02 v3(207.86,148.34) 208.17,149.73 JMINI2.32
WIGIG_LED#: length 29.9
  TOP w0.102: Q124.4 210.95,146.94 211.58,146.31 v3(211.58,145.09) 211.33,144.84 RP13.3
  IN3 w0.127: v3(211.58,145.09) 208.51,142.01 206.93,142.01 206.06,141.15 197.76,141.15 v3(197.59,140.98)
  BOTTOM w0.102: v3(197.59,140.98) 197.59,143.69 196.8,144.48 R706.1 ; JMINI2.42 211.81,147.47 211.01,146.68 v1(211.01,146.17) 211.01,145.66 v3(211.58,145.09)
WIRELESS_LED#: length 251.6
  TOP w0.102: Q100.3 231.19,106.86 R937.2 233.28,104.78 v3(235.02,104.78) ; Q124.6 210.05,145.64 209.91,145.79 209.91,147.11 210.2,147.4 211.27,147.4 211.72,146.94 Q124.3 214.05,146.94 214.44,146.55 Q89.1 214.44,143.69 214.59,143.55 214.59,142.33 213.91,141.66 v1(213.62,141.66) 212.22,141.66 208.63,138.07 v3(208.35,138.07) ; v3(179.07,63.93) 179.07,64.13 179.5,64.56 U46.A47 ; v3(277.56,178.86) Q77.1
  IN3 w0.127: v3(179.07,63.93) 179.37,63.64 180.57,63.64 181.4,62.81 192.09,62.81 192.74,63.47 195.43,63.47 196.19,64.22 203.33,64.22 204.82,62.73 207.61,62.73 208.4,63.52 217.63,63.52 217.87,63.76 222.43,63.76 233.33,74.66 233.33,103.1 v3(235.02,104.78) ; v3(208.35,138.07) 209.19,137.22 227.85,137.22 228.11,137.48 229.92,137.48 v3(230.19,137.21)
  IN4 w0.102: v3(277.56,178.86) 277.18,178.48 277.18,176.61 272.54,171.97 265.18,171.97 262.64,169.43 262.64,168.13 260.38,165.88 257.14,165.88 254.29,163.03 254.29,158.96 255.18,158.07 255.18,156.87 254.26,155.95 251.85,155.95 249.44,153.54 249.44,151.23 248.82,150.6 247.97,150.6 247.75,150.39 244.63,150.39 234.37,140.14 231.97,140.14 230.19,138.36 v3(230.19,137.21) 230.19,136.39 228.37,134.57 228.37,110.53 234.13,104.78 v3(235.02,104.78)
WIRELESS_ON#/OFF: length 87.6
  TOP w0.102: U46.B13 190.46,69.8 189.87,69.8 v3(189.8,69.74) ; v2(193.16,72.29) 193.08,72.21 v3(193.08,71.44) 193.23,71.29 194.04,71.29 194.24,71.48 RP3.5 ; v3(233.57,114.18) 233.55,114.2 JSF1.4
  IN3 w0.127: v3(193.08,71.44) 193.67,71.44 195.65,69.46 198.08,69.46 199.1,68.43 207.73,68.43 208.33,67.83 214.17,67.83 216.21,69.88 219.01,69.88 219.27,70.14 219.27,71.36 220.73,72.82 220.73,73.59 223.97,76.83 224.64,76.83 227.67,79.86 227.67,88.68 229.21,90.22 229.21,104.99 233.57,109.35 v3(233.57,114.18)
  BOTTOM w0.102: v3(193.08,71.44) 193.08,71.31 192.75,70.98 191.05,70.98 v3(189.8,69.74)
WLAN_LAN_DISB#: length 164.1
  TOP w0.102: v3(259.68,152.23) 259.74,152.29 259.74,155.28 260.1,155.63 260.1,156.49 260.1,163.03 260.73,163.66 260.73,172.9 260.3,173.33 U15.4 ; U46.A64 190.85,62.36 191.35,62.86 v3(191.35,63.28)
  IN3 w0.127: v3(191.35,63.28) 191.35,63.38 191.81,63.85 195.33,63.85 196.01,64.53 203.39,64.53 204.93,62.99 207.51,62.99 208.29,63.77 217.53,63.77 217.77,64.01 222.09,64.01 233.08,74.99 233.08,104.06 244.87,115.85 244.87,131.78 247.95,134.86 249.41,134.86 253.25,138.7 253.25,149.28 254.26,150.29 257.07,150.29 259.01,152.23 v3(259.68,152.23)
WLAN_LED: length 72.6
  TOP w0.102: R3671.2 v3(226.25,106.62) 226.25,105.16 v2(225.6,104.51)
  TOP w0.305: JLED1.5 254.17,154.77 253.7,155.23 v3(253.7,156.85)
  IN3 w0.127: v3(253.7,156.85) 253.7,155.53 252.94,154.76 251.49,154.76 250.9,154.18 250.9,153.39 251.18,153.11 251.18,150.78 250.45,150.06 250.45,146.27 248.19,144 248.19,141.17 244.29,137.26 244.29,136.39 240.7,132.81 240.7,123.2 235.03,117.53 229.93,117.53 227.47,115.07 227.47,107.83 226.25,106.61 v3(226.25,106.62)
WLAN_LED#: length 6.9
  TOP w0.102: Q124.1 212.22,145.52 v3(212.22,145.02) 211.83,144.64 RP13.2
  BOTTOM w0.102: v1(212.35,144.14) 212.22,144.26 v3(212.22,145.02) 212.22,147.18 212.73,147.69 JMINI2.44
WLAN_RADIO_DIS#: length 108.1
  TOP w0.102: U46.A48 v3(179.64,64.06)
  IN4 w0.102: v3(187.18,135.5) 186.35,134.66 185.52,134.66 183.69,132.84 183.69,128.38 181.12,125.81 181.12,122.89 183.45,120.56 183.45,113.46 185.29,111.62 185.29,108.55 185.52,108.33 185.52,103.47 186.37,102.62 186.37,100.5 186.97,99.9 187.41,99.9 188,99.31 188,96.01 187.49,95.5 187.49,89.06 186.92,88.49 186.92,88.15 187.49,87.58 187.49,80.94 186.02,79.46 185.29,79.46 184.87,79.04 184.29,79.04 183.65,78.4 178.04,72.8 178.04,66.36 179.64,64.76 v3(179.64,64.06)
  BOTTOM w0.102: v3(187.18,135.5) 187.5,135.18 v1(191.64,135.18) 196,135.18 200.03,139.21 200.03,144.01 199.95,144.08 D31.1 201.49,145.21 202.12,145.84 R693.1
WLAN_RADIO_DIS#_R: length 7.1
  TOP w0.102: v1(202.3,148.3) v3(202.91,148.3)
  BOTTOM w0.102: D31.2 200.86,146.5 R3885.1 202.12,147.39 R693.2 202.91,148.2 v3(202.91,148.3) 202.91,148.89 203.06,149.05 JMINI2.20
WWAN_RADIO_DIS#: length 199
  TOP w0.102: v3(184.04,61.64) 184.04,61.64 184.12,61.72 U46.A53 ; RP3.7 194.37,70.48 v3(193.99,70.11)
  IN2 w0.127: v3(193.99,70.11) 194.87,70.98 194.87,76.45 195.42,76.99 195.42,79.25 194.92,79.75 194.92,82.99 196.62,84.69 196.62,91.65 201.21,96.24 201.21,101.62 200.8,102.02 200.8,116.12 201.9,117.23 201.9,119.8 201.64,120.06 201.64,121.71 202.89,122.96 202.89,141.5 200.93,143.46 200.93,143.93 v3(200.52,144.34)
  IN3 w0.127: v3(200.52,144.34) 202.77,144.34 206.55,148.12 206.55,148.86 207.16,149.47 216.27,149.47 223.96,157.15 229.66,157.15 235.52,163.02 235.52,165.86 236.44,166.78 241.6,166.78 243.33,168.51 247,168.51 247.74,167.78 251.73,167.78 255.62,171.67 260.37,171.67 262.6,173.9 262.6,191.12 263.15,191.66 265.17,191.66 266.06,192.56 v3(268.48,192.56)
  BOTTOM w0.102: JMINI1.20 268.76,192.84 v3(268.48,192.56) ; v3(193.99,70.11) 193.99,68.71 v1(193.55,68.27) 193.11,67.82 191.7,67.82 191.17,67.3 188.85,67.3 188.28,66.73 188.28,66.41 187.45,65.59 186.95,65.59 186.25,64.89 186.25,63.83 184.06,61.64 v3(184.04,61.64)
XDP_DBRESET#: length 250.1
  TOP w0.102: RC52.2 RC35.1 105.69,111.92 105.69,110.4 C1553.1 105.69,110 105.23,109.54 104.05,109.54 103.4,110.19 v3(99.57,110.19)
  IN1 w0.102: v3(99.57,110.19) 98.12,108.74 98.12,104.4 99.23,103.29 99.23,99.09 98.12,97.98 98.12,86.96 93.25,82.08 93.25,80.89 v3(93.41,80.73) 93.25,80.57 93.25,78.25 92.72,77.72 92.72,73.67 93.6,72.78 v3(93.6,67.73)
  IN4 w0.102: v3(164.82,118.96) 164.31,118.46 164.31,113.47 166.91,110.88 169.16,110.88 v3(169.32,110.71) 169.32,110.14 170.88,108.58 173.98,108.58 181.81,100.74 181.81,96.5 182.17,96.15 182.17,90.62 182.47,90.33 182.47,86.51 182.35,86.39 182.35,85.58 182.61,85.31 182.61,83.8 182.06,83.25 182.06,81.79 180.99,80.72 180.28,80.72 175.53,75.97 174.76,75.97 174.6,75.81 v3(173.39,75.81)
  BOTTOM w0.102: v3(169.32,110.71) 169.85,111.24 176.75,111.24 184.53,103.47 191.57,103.47 196.75,98.29 203.84,98.29 204.43,98.88 JXDP2.48 ; JXDP1.18 v3(93.41,80.73) ; UC3.1 160.94,116.94 161.3,117.31 161.43,117.31 161.76,117.64 163.39,117.64 RH66.1 164.57,118.42 164.82,118.67 v3(164.82,118.96) ; v3(99.57,110.19) 99.57,110.04 v1(98.93,109.4) ; v3(173.39,75.81) 172.54,75.81 164.29,67.57 93.76,67.57 v3(93.6,67.73)
XDP_DBRESET#_R: length 7.8
  TOP w0.089: v3(111.47,108.2) 110.96,108.71 110.96,109.36 110.67,109.65 109.26,109.65 109.15,109.54
  TOP w0.102: RC35.2 106.66,111 106.85,111 108.31,109.54 v2(108.87,109.54) 109.15,109.54
  BOTTOM w0.089: v3(111.47,108.2) JCPU1.AP33
XDP_FN0: length 2.9
  BOTTOM w0.102: JXDP2.9 v1(213.74,108.38) 214.33,108.38 RH3.2
XDP_FN1: length 5.5
  BOTTOM w0.102: JXDP2.11 213.81,107.88 RH4.2 215.18,106.52 216.18,106.52 v1(216.61,106.95)
XDP_FN2: length 6
  BOTTOM w0.102: v1(216.68,105.49) 215.19,105.49 RH6.2 214.34,105.65 213.81,105.65 213.43,106.04 213.43,106.61 213.15,106.88 JXDP2.15
XDP_FN3: length 3.7
  BOTTOM w0.102: RH7.2 213.97,104.98 v1(213.68,105.27) 213.2,105.76 213.2,106.29 213.1,106.38 JXDP2.17
XDP_FN4: length 5.8
  BOTTOM w0.102: JXDP2.27 213.41,103.88 213.68,103.61 214.33,103.61 RH8.2 215.18,103.47 215.98,103.47 216.12,103.33 216.66,103.33 v1(217.04,103.71)
XDP_FN5: length 5.2
  BOTTOM w0.102: v1(216.65,102.45) 215.18,102.45 RH9.2 214.25,103.38 JXDP2.29
XDP_FN6: length 3
  BOTTOM w0.102: RH17.2 214.23,102.38 v1(213.68,102.38) JXDP2.33
XDP_FN7: length 6.1
  BOTTOM w0.102: JXDP2.35 213.72,101.88 RH10.2 215.2,101.44 217.16,101.44 v1(217.34,101.26)
XDP_FN8: length 5.1
  BOTTOM w0.102: v1(201.36,108.17) 202.78,108.17 RH11.2 203.56,108.38 JXDP2.10
XDP_FN9: length 3
  BOTTOM w0.102: JXDP2.12 v1(204.24,107.88) 203.51,107.88 RH13.2
XDP_FN10: length 5.1
  BOTTOM w0.102: JXDP2.16 203.53,106.88 RH12.2 202.79,106.15 v1(201.35,106.15)
XDP_FN11: length 3.2
  BOTTOM w0.102: RH14.2 204.04,106.38 v1(204.28,106.38) JXDP2.18
XDP_FN12: length 3.2
  BOTTOM w0.102: JXDP2.28 v1(204.28,103.88) 203.99,103.88 RH16.2
XDP_FN13: length 5
  BOTTOM w0.102: JXDP2.30 203.48,103.38 RH19.2 202.77,104.09 v1(201.4,104.09)
XDP_FN14: length 3
  BOTTOM w0.102: RH20.2 203.46,102.38 v1(204.28,102.38) JXDP2.34
XDP_FN15: length 5.1
  BOTTOM w0.102: JXDP2.36 203.61,101.88 RH22.2 202.67,100.94 v1(201.4,100.94)
XDP_FN16: length 5.2
  BOTTOM w0.102: JXDP2.4 204.11,109.88 203.8,110.2 202.86,110.2 RH24.2 201.97,110.7 v1(201.47,110.2)
XDP_FN17: length 3
  BOTTOM w0.102: RH25.2 203.57,109.38 v1(204.28,109.38) JXDP2.6
XDP_OBS0: length 2.5
  TOP w0.089: T173.1 109.77,105.9 v3(110.47,105.2)
  BOTTOM w0.102: v3(110.47,105.2) JCPU1.AR30
XDP_OBS1: length 2.3
  TOP w0.089: T174.1 112.98,105.69 v3(112.47,106.2)
  BOTTOM w0.102: v3(112.47,106.2) JCPU1.AN31
XDP_OBS2: length 2
  TOP w0.089: v3(113.47,104.2) 113.96,103.71 T88.1
  BOTTOM w0.089: v3(113.47,104.2) 113,103.73 JCPU1.AN29
XDP_OBS3: length 1.2
  TOP w0.089: v3(111.47,106.2) 111.48,106.19 T89.1
  BOTTOM w0.102: v3(111.47,106.2) JCPU1.AP31
XDP_OBS4: length 1.5
  TOP w0.089: v3(112.47,104.2) 111.98,103.7 T90.1
  BOTTOM w0.102: v3(112.47,104.2) JCPU1.AP30
XDP_OBS5: length 6.3
  TOP w0.102: v3(112.47,103.2) 111.97,102.69 108.8,102.69 T116.1
  BOTTOM w0.102: v3(112.47,103.2) JCPU1.AN28
XDP_OBS6: length 2.4
  TOP w0.089: T117.1 111.08,104.59 v3(111.47,104.2)
  BOTTOM w0.102: v3(111.47,104.2) JCPU1.AP29
XDP_OBS7: length 6
  TOP w0.089: v3(111.47,103.2) 111.07,103.6 109.21,103.6 108.74,104.07
  TOP w0.102: T118.1 107.33,105.48 108.74,104.07
  BOTTOM w0.102: v3(111.47,103.2) JCPU1.AP28
XDP_PRDY#: length 52.2
  IN4 w0.102: v3(110.47,104.2) 109.98,104.69 107.85,104.69 104.48,101.32 96.36,101.32 v3(95.07,102.61)
  BOTTOM w0.102: JXDP1.2 93.65,72.73 91.39,74.99 91.39,84.44 90.87,84.95 90.87,89.9 95.51,94.54 v1(95.51,96.46) 95.51,102.17 v3(95.07,102.61) ; v3(110.47,104.2) JCPU1.AR29
XDP_PREQ#: length 52
  IN4 w0.102: v3(106.65,101.46) 106.1,100.92 96.01,100.92 v3(95.08,101.84)
  BOTTOM w0.089: JCPU1.AT29 108.92,103.73 108.74,103.55
  BOTTOM w0.102: v3(95.08,101.84) 95.11,101.82 v1(95.11,99.1) 95.11,94.71 90.47,90.07 90.47,84.78 90.98,84.27 90.98,74.82 93.58,72.23 JXDP1.1 ; RC55.2 105.83,100.64 v3(106.65,101.46) 108.74,103.55
XDP_RST#_R: length 3.5
  BOTTOM w0.102: v1(96.45,82.3) 96.45,81.07 RC23.2 95.61,80.23 JXDP1.17
XDP_TCLK: length 54.5
  TOP w0.102: v2(96.51,103.41) 96.51,102.81 v3(96.5,102.79)
  IN4 w0.102: v3(113.47,109.2) 112.95,109.72 109.42,109.72 106.3,106.59 106.3,104.97 103.96,102.63 96.66,102.63 v3(96.5,102.79)
  BOTTOM w0.089: 112.64,111.73 113.47,110.91 v3(113.47,109.2)
  BOTTOM w0.102: RC59.2 105.22,111.69 107.28,113.74 111.27,113.74 112.13,112.88 112.13,112.25 112.64,111.73 ; v3(96.5,102.79) 96.5,102.78 96.01,102.3 96.01,85.52 95.22,84.73 JXDP1.26 ; v3(113.47,109.2) JCPU1.AM34
XDP_TDI: length 44.5
  TOP w0.102: RC54.2 110.62,113.19 v3(110.46,113.03) 110.62,112.86 RC32.2
  BOTTOM w0.102: JXDP1.22 95.06,82.73 97.16,84.83 v1(97.16,87.87) 97.16,109.76 98.45,111.05 105.27,111.05 106.35,112.13 109.57,112.13 v3(110.46,113.03)
XDP_TDI_R: length 9
  TOP w0.089: v3(113.47,106.2) 113.92,106.2 114.15,106.43 v2(114.15,106.66) 113.95,106.87 113.95,109.43 113.73,109.64 113.73,110.14 112.78,111.08 111.02,111.08 RC32.1
  BOTTOM w0.102: v3(113.47,106.2) JCPU1.AM31
XDP_TDO: length 45.9
  TOP w0.102: RC34.2 111.51,112.82 v3(111.31,113.02) 111.31,113.45 RC57.2
  BOTTOM w0.102: JXDP1.20 95.21,81.73 97.98,84.49 v1(97.98,98.54) 97.98,101.5 98.08,101.6 98.08,109.69 99.04,110.65 105.44,110.65 106.52,111.73 110.02,111.73 v3(111.31,113.02)
XDP_TDO_R: length 6.7
  TOP w0.089: RC34.1 v2(112.7,111.48) 113.47,111.48 114.89,110.07 114.89,108.61 v3(114.47,108.2)
  BOTTOM w0.102: v3(114.47,108.2) JCPU1.AL33
XDP_TMS: length 48.6
  TOP w0.089: 108.74,110.7 109.1,110.34 111.24,110.34 112.1,109.48 112.1,108.56 112.46,108.2 v3(112.47,108.2)
  TOP w0.102: RC53.2 108.74,110.7 ; v3(96.5,102.11) v2(96.5,100.35)
  IN4 w0.102: v3(96.5,102.11) 96.88,101.73 104.32,101.73 107.19,104.6 107.19,106.23 108.71,107.75 112.02,107.75 v3(112.47,108.2)
  BOTTOM w0.089: v3(112.47,108.2) JCPU1.AN33
  BOTTOM w0.102: JXDP1.23 94.99,83.23 96.5,84.74 v3(96.5,102.11)
XDP_TRST#: length 48.5
  TOP w0.089: v3(113.47,108.2) 113.1,108.57 113.1,110.19 112.43,110.85 110.37,110.85 RC62.2
  TOP w0.102: v3(97.66,102.15) v2(97.66,101.56)
  IN4 w0.102: v3(113.47,108.2) 113.03,108.64 109.03,108.64 106.78,106.39 106.78,104.77 104.16,102.15 v3(97.66,102.15)
  BOTTOM w0.102: JXDP1.21 95.14,82.23 97.57,84.66 97.57,102.05 v3(97.66,102.15) ; v3(113.47,108.2) JCPU1.AM33
XFR_ID#: length 210.9
  TOP w0.089: v3(173.74,134.61) 173.8,134.55 v1(174.4,134.55) 175.19,134.55 175.69,134.04 177.17,134.04 177.6,134.47 179.3,134.47 179.38,134.54
  TOP w0.102: 179.38,134.54 179.96,135.12 RPH6.3
  IN3 w0.089: 155.67,132.39 157.74,132.39 158.05,132.07 162.02,132.07 162.31,132.37 162.31,132.92 162.53,133.14 163.36,133.14 163.54,133.32 170.45,133.32 170.54,133.23 171.85,133.23 172.02,133.4 172.02,133.85 172.37,134.2 173.32,134.2 v3(173.74,134.61)
  IN3 w0.127: 155.67,132.39 150.88,132.39 144.37,138.9 144.37,146.98 138.63,152.72 136.24,152.72 135.95,153.01 133.83,153.01 132.96,153.88 127.21,153.88 125.68,155.41 108.89,155.41 102.76,149.27 86.29,149.27 85.79,148.77 81.5,148.77 79.15,146.42 71.1,146.42 67.52,150 58.27,150 57.6,150.68 50.11,150.68 44.8,155.98 44.8,156.88 39.58,162.11 33.09,162.11 24.32,170.87 24.32,173.98 21.46,176.84 7.05,176.84 v3(6.35,176.14)
  BOTTOM w0.089: v3(173.74,134.61) 173.87,134.74 UH1.F17
  BOTTOM w0.102: v3(6.35,176.14) 6.35,176.5 JIO1.2
XTAL25_IN: length 8.3
  BOTTOM w0.089: UH1.AM43 162.84,145.76 162.84,146.23 163.14,146.53 163.14,146.96 163.17,146.99 163.17,147.43 162.62,147.97 162.36,148.23
  BOTTOM w0.102: RH152.2 160.72,152.53 v1(160.72,151.76) 160.72,149.87 162.36,148.23
XTAL25_IN_R: length 5.6
  BOTTOM w0.102: RH152.1 RH153.2 159.56,154.57 CH14.2 159.77,154.85 159.77,157.09 159.41,157.44 YH2.1
XTAL25_OUT: length 11.2
  BOTTOM w0.089: 162.88,148 163.38,147.5 163.38,146.92 163.33,146.87 163.33,146.45 163.24,146.37 UH1.AL44
  BOTTOM w0.102: 162.88,148 162.75,148.13 162.75,148.64 161.23,150.16 v1(161.23,150.42) 161.23,152.9 RH153.1 160.39,153.75 CH13.2 160.39,155.3 YH2.3
XTALI: length 4.8
  TOP w0.102: Y3.3 247.15,166.19 246.18,165.22 245.59,165.22 C471.2 244.54,165.28 U31.10
XTALIN: length 7.9
  BOTTOM w0.102: UV1.AM28 80.58,146.38 81.12,146.92 v1(81.12,148.29) 81.12,148.86 80.81,149.16 CV95.1 79.8,149.16 79.64,149.01 RV100.1 78.98,148.81 YV1.1
XTALO: length 1.9
  TOP w0.102: R1144.2 244.94,164.8 243.97,164.8 243.89,164.88 U31.9
XTALOUT: length 6.2
  BOTTOM w0.102: YV1.3 76.2,149.66 78.92,149.66 RV100.2 CV94.1 79.99,150.79 RV125.1
XTALOUT_R: length 7.4
  BOTTOM w0.102: RV125.2 81.11,150.03 v1(81.28,149.85) 81.6,149.53 81.6,146.61 80.96,145.98 80.96,144.58 UV1.AK28
Z2805: length 2.3
  TOP w0.508: v3(248.54,190.2) 248.77,189.97 T156.22
  BOTTOM w0.508: v3(248.54,190.2) R574.1
Z2806: length 2.3
  TOP w0.508: v3(248.52,197.82) 248.74,197.59 T156.16
  BOTTOM w0.508: v3(248.52,197.82) R573.1
Z2807: length 2.5
  TOP w0.508: T156.21 248.85,191.24 v3(248.49,190.88)
  BOTTOM w0.508: R572.1 248.69,191.09 v3(248.49,190.88)
Z2808: length 2.4
  TOP w0.508: v3(248.5,198.54) 248.82,198.86 T156.15
  BOTTOM w0.508: R571.1 248.67,198.71 v3(248.5,198.54)
Z4012: length 2.4
  TOP w0.102: PD3.2 v1(241.06,155.84)
  TOP w0.508: PD3.2 241.1,154.56 PR1.2
Z4304: length 8.8
  TOP w0.102: PRP2.6 73.91,163.74 73.78,163.87 73.78,164.24 74.02,164.48 74.02,165.69 73.79,165.92 73.58,165.92 PD2.2 72.77,165.9 72.66,165.9 72.56,166 72.56,167.06 71.9,167.71 v4(71.9,168.18) 71.9,168.86 PBATT1.7
Z4305: length 8.7
  TOP w0.102: PBATT1.6 71.68,168.86 71.68,167.62 72.33,166.96 v4(72.33,166.61) 72.33,165.91 72.56,165.67 72.82,165.67 PD2.3 73.55,165.69 73.69,165.69 73.79,165.59 73.79,164.58 73.55,164.33 73.55,163.86 73.41,163.72 PRP2.7
Z4306: length 8.4
  TOP w0.102: PRP2.8 72.91,164.47 72.16,165.22 71.57,165.22 PD4.2 70.47,166.82 v1(69.28,168.01) 68.79,168.5 PBATT1.5
ZODD_WAKE#: length 29.9
  TOP w0.102: U46.A59 187.12,61.76 v3(186.98,61.63) ; RP18.8 167.2,57.76 167.06,57.62 167.06,57.1 168.52,55.64 v1(168.52,55.39) v3(168.52,54.69) 168.52,54.04 168.76,53.8 169.46,53.8 169.6,53.94 Q76.3
  IN3 w0.127: v3(186.98,61.63) 186.81,61.63 186.25,61.06 186.25,60.85 185.84,60.44 185.42,60.44 184.98,60 184.98,57.52 182.92,55.46 169.29,55.46 v3(168.52,54.69)
N115227: length 8.9
  TOP w0.102: v2(5.91,177.47) 6.03,177.35 PQ6.4
  TOP w0.254: PQ6.4 8.19,177.35 8.71,176.82 PR25.1 ; PR25.1 8.7,176.06 PR18.2 PR23.1 ; PR25.1 8.82,175.97 PC8.1 11.42,175.97 PQ4.4
N115634: length 4.5
  TOP w0.102: PQ6.1 10.64,179.25 v1(11.56,180.16)
  TOP w0.254: PQ6.1 9.33,179.25 9.02,178.93 9.02,178.55 9.27,178.3 PQ6.2
N392231: length 11.5
  TOP w0.508: v3(46.92,169.4) 46.16,168.64 PD701.1
  BOTTOM w0.508: v3(46.92,169.4) 47.94,170.42 v1(48.01,170.42) 51.06,170.42 51.53,169.95 54.07,169.95 PR742.1
N513876: length 4.5
  TOP w0.102: v1(53.47,158.74) 53.33,158.88 51.82,158.88 PR718.1
  TOP w0.254: PR718.1 51.5,159.2 PU700.13
N514008: length 2.6
  TOP w0.254: PR719.1 51,159.33 v1(51,160.26) PU700.12
N743839: length 2.9
  TOP w0.203: PR631.2 21.78,144.44 PU600.2
  TOP w0.254: PR691.1 PR631.2
N992434: length 10.1
  TOP w0.254: PD7.2 168.84,164.32 168.66,164.51 167.97,164.51 166.6,165.88 165.18,165.88 164.7,166.36 v2(164.7,167.45) 164.7,171
N992510: length 6
  TOP w0.102: v1(170.31,168.81) 169.19,168.81 PR26.2
  TOP w0.254: PR26.2 PC17.1 166.49,167.97 PQ7.2
N995059: length 4.1
  TOP w0.254: PU704.1 235.6,139.36 235.7,139.26 235.7,138.88 235.54,138.71 PR748.2 v1(236.54,138.1) 237.05,138.1 237.36,138.42 PQ710.1
N995231: length 6.7
  TOP w0.254: PQ707.5 236.86,143.5 237.05,143.31 237.05,141.99 236.82,141.76 v1(236.67,141.76) 235.53,141.76 234.43,140.66 PU704.4
N995271: length 9.6
  TOP w0.102: PQ707.3 234.22,141.74 PR724.1 234.06,141.72 233.87,141.91 233.87,142.1 233.62,142.36 v3(233.24,142.36) ; v3(237.55,142.74) 237.55,143.51 v1(237.4,143.66) 236.91,144.15 PQ707.6
  IN2 w0.127: v3(237.55,142.74) 233.62,142.74 v3(233.24,142.36)
N1002908: length 6.7
  TOP w0.102: PR807.2 229.73,78.81 229.55,78.98 228.79,78.98 v1(228.16,79.62)
  TOP w0.254: PQ805.6 229.59,78.43 PR807.2 229.22,77.78 PQ805.5
N1002948: length 3.7
  TOP w0.254: PD811.2 109.86,158.54 109.73,158.42 v1(109.73,157.85) 109.73,157.34 109.92,157.15 PR815.2
N1002952: length 5.7
  TOP w0.102: v1(113.22,157.53) 113.03,157.34 111.76,157.34 111.44,157.03 PD811.1
  TOP w0.254: PD811.1 111.44,155.37 112.13,154.69 PQ812.6
N1002956: length 5.5
  TOP w0.102: PR816.1 115.13,151.93 v1(115.61,152.42)
  TOP w0.254: 113.43,150.87 PQ812.3 ; 113.43,150.87 113.91,150.87 114.62,151.58 PR816.1 ; 113.43,150.87 113.02,150.87 112.78,151.11 PQ812.2
N1002964: length 2.4
  TOP w0.254: PR863.1 41.85,146.72 42.32,146.25 PU800.19
N1003044: length 40
  TOP w0.254: v3(108.59,151.63) 109.92,152.96 v1(109.92,153.53) PR815.1 PR813.1 ; v3(82.13,150.92) 83.89,152.67 83.89,154.93 84.27,155.31 PQ809.4
  IN2 w0.127: v3(108.59,151.63) 106.81,149.85 90.87,149.85 90.02,150.7 85.92,150.7 85.31,151.31 82.53,151.31 v3(82.13,150.92)
N1003284: length 92.2
  TOP w0.254: v3(99.95,172.33) 99.51,171.88 PC807.2 ; PR811.1 43.32,151.06 40.2,151.06 v3(39.94,150.8)
  IN4 w0.254: v3(99.95,172.33) 98.49,172.33 94.24,168.07 94.24,165.53 93.41,164.71 87.77,164.71 85.3,167.19 77.77,167.19 77.09,167.87 66.33,167.87 65.96,167.5 57.09,167.5 54.74,169.85 52.01,169.85 50.95,168.8 v3(43.25,168.8)
  BOTTOM w0.254: v3(99.95,172.33) 100.01,172.39 PQ810.4 ; v3(39.94,150.8) 39.94,151.06 40.9,152.01 42.32,152.01 44.01,153.69 44.01,161.85 42.58,163.27 v1(42.58,167.26) 42.58,168.14 v3(43.25,168.8)
N1003374: length 17.6
  TOP w0.102: PQ806.3 230.97,79.67 231.66,78.97 232.91,78.97 233.15,78.73 v1(233.87,78.73)
  TOP w0.254: PQ806.3 229.48,79.67 v3(229.3,79.49) ; PR810.2 228.54,88.64 v3(228.79,88.38) ; PU804.2 229,83.11 PR812.2 v3(228.79,82.29)
  IN4 w0.254: v3(228.79,88.38) 228.94,88.23 228.99,88.23 229.27,87.95 229.27,85.18 228.79,84.7 v3(228.79,82.29) 229.3,81.78 v3(229.3,79.49)
N1003454: length 7.7
  TOP w0.102: PR819.1 193.85,49.6 v1(194.31,49.14)
  TOP w0.254: PQ817.1 190.72,51.78 191.14,51.36 PU805.2 191.14,50 191.54,49.6 PR819.1
N1003474: length 1.8
  TOP w0.102: PQ807.3 171.69,71.86 v1(171.26,71.43)
N1003522:
  vias: v1(168.72,71.36)
N1003526: length 15.9
  TOP w0.254: PR802.1 166.99,72.8 167.57,73.37 PQ801.2 167.57,76.65 v1(169.47,78.55) 170.19,79.27 171.95,79.27 172.15,79.07 172.15,78.34 174.16,76.33 PR804.1
N1003966: length 193
  TOP w0.254: v3(169.23,49.14) 170.05,49.14 170.69,49.77 174.3,49.77 176.24,51.72 185.76,51.72 186.25,51.23 PD819.1 186.06,50.11 186.06,48 PD810.1 ; PQ816.2 99.84,164.9 v3(99.13,164.19)
  IN2 w0.254: v3(169.23,49.14) 169.23,49.42 168.82,49.84 163.39,49.84 157.82,55.4 157.82,78.73 153.42,83.14 153.42,89.58 151.97,91.03 151.97,97.2 148.33,100.84 148.33,107.61 150.6,109.88 150.6,115.7 148.78,117.52 148.78,135.67 143.58,140.87 143.58,143.99 138,149.56 132.08,149.56 131.38,150.26 128.48,150.26 127.46,149.23 121.81,149.23 120.18,147.6 118.96,147.6 118.78,147.42 v3(118.78,147.11)
  BOTTOM w0.254: v3(99.13,164.19) 99.13,163.82 99.7,163.25 102.49,163.25 v1(105.48,160.26) 106.52,159.22 112.94,159.22 115.72,156.44 115.72,153.57 118.56,150.74 118.56,147.33 v3(118.78,147.11)
N1004028: length 11.7
  TOP w0.254: PR824.1 180.94,48.06 180.21,47.34 PQ818.2 179.53,47.47 PR882.2 ; PR882.2 179.53,48.94 179.2,49.27 v1(179.2,50.35) 179.2,50.85 179.4,51.06 181.84,51.06 182.41,50.49 PQ819.3 ; PR882.2 179.95,48.69 180.44,49.19 PQ819.6
N1004036: length 6.7
  TOP w0.102: v1(179.01,44.54) PQ818.1
  TOP w0.254: PQ818.1 180.05,45.74 180.6,46.28 PU807.2 183.25,46.28 PR823.1
N1004086: length 29.1
  TOP w0.254: PQ805.2 224.73,77.78 224.35,78.16 v1(224.35,80.51) 224.35,81.78 225.07,82.5 PQ802.1 226.25,82.48 v3(226.89,81.84) ; PQ806.6 233.11,80.97 PR801.2 234.08,81.6 v3(234.7,82.22) ; PD818.1 224.47,75.49 v3(224.09,75.87)
  IN1 w0.254: v3(234.7,82.22) 230.95,82.22 230.42,81.69 227.04,81.69 v3(226.89,81.84)
  IN4 w0.254: v3(224.09,75.87) 224.09,79.3 226.64,81.84 v3(226.89,81.84)
N1004090: length 2.8
  TOP w0.102: PU801.4 228.21,85.38 v1(228.35,85.52)
  TOP w0.254: PQ802.2 226.95,84.15 PU801.4
N1004112: length 3.3
  TOP w0.102: v1(114.61,155.23) PR890.1
  TOP w0.254: PR890.1 112.78,154.98 PQ812.5
N1004194: length 3.4
  TOP w0.102: v1(189.3,48.69) 189.93,49.33 190.31,49.33 190.49,49.15 PU805.4
  TOP w0.254: PU805.4 190.49,48.34 190.96,47.87 PU806.1
N1004236: length 3.2
  TOP w0.102: v1(35.32,145.61) 35.56,145.37 35.56,144.53 PR838.1
  TOP w0.254: PU800.28 35.86,144.23 PR838.1
N1004240: length 6
  TOP w0.254: PQ806.2 229.17,80.32 228.88,80.61 v1(228.88,81.08) 228.88,81.23 229.17,81.52 230.76,81.52 231.7,82.46 PU804.4
N1004350: length 9.8
  TOP w0.102: PR821.1 70.95,152.29 v1(70.09,151.43)
  TOP w0.254: PQ811.4 74.16,155.59 73.51,154.94 73.51,153.15 PC811.1 PR821.1
N1004812: length 3.2
  TOP w0.102: v1(184.34,48.44) 184.77,48.87 184.77,49.39 184.42,49.75 PR881.1
  TOP w0.254: PR881.1 184.41,49.84 PQ819.2
N1005192: length 2.9
  TOP w0.102: v1(219.78,96.83) 220.35,96.83 220.66,96.51 PR883.2
  TOP w0.254: PQ824.5 221.17,96.37 PR883.2
N1005388: length 4
  TOP w0.102: PR886.1 191.15,37.34 v1(190.92,37.11)
  TOP w0.254: PR886.1 PR884.1 189.7,38.84 189.7,38.9 189.5,39.11 PQ813.5
N1005532: length 11
  TOP w0.254: PQ813.2 186.23,39.11 186.12,38.99 186.12,38.46 ; PQ813.3 186.12,38.46 ; 186.12,38.46 186.12,37.73 187.22,36.63 v1(189.04,36.63) 191.52,36.63 192.05,37.16 PR829.2
N1005544: length 12.2
  TOP w0.254: PQ821.5 186.18,41.77 185.68,42.28 185.68,43.44 186.15,43.91 v1(186.82,43.91) 190.79,43.91 v3(191.17,44.29) ; v3(191.17,42.29) PR887.1 PR885.1
  IN2 w0.254: v3(191.17,44.29) v3(191.17,42.29)
N1005606: length 9.6
  TOP w0.254: PR826.2 184.98,34.71 185.68,35.41 v1(185.68,38.47) 185.68,40.31 185.94,40.58 187.42,40.58 188.24,39.76 PQ813.6
N1006752: length 4.6
  TOP w0.102: v1(182.75,33.58) 183.16,33.99 PQ814.2
  TOP w0.254: PR827.1 PR826.1 184.51,35.22 PQ814.2
N1007864: length 5.9
  TOP w0.254: PQ821.2 189.43,41.77 189.82,42.15 189.82,42.42 ; 189.82,42.42 189.82,42.55 190.17,42.9 v1(190.69,42.9) 191.67,42.9 192.06,42.51 PR849.2 ; 189.82,42.42 PQ821.3
N1007980: length 2.9
  TOP w0.102: PR840.1 185.1,42.84
  TOP w0.254: 185.1,42.84 PR839.1 185.1,41.98 184.82,41.7 v3(184.43,41.7) PQ822.2
N1008596: length 5
  TOP w0.102: PR850.1 39.04,147.3 39.37,147.63 39.37,149.15 v1(39.75,149.53)
  TOP w0.254: PU800.26 38.82,147.21 PR850.1
N1009306: length 4.9
  TOP w0.102: PU806.4 189.66,44.93 v1(189.17,44.44)
  TOP w0.254: PU806.4 189.66,46.27 188.85,47.08 188.85,47.75 PD810.3
N1009636: length 5.2
  TOP w0.102: PQ822.1 179.48,42.66 v1(179.02,42.2)
  TOP w0.254: PD813.3 181.8,40.91 181.21,41.51 PQ822.1
N1009712: length 6.2
  TOP w0.102: v1(101.09,167.95) 101.16,167.88 PQ826.1
  TOP w0.254: PR818.2 100.89,162.61 PC809.1 101.79,164.53 102.26,165
N1009720: length 256.6
  TOP w0.102: v2(118.7,153.56) v3(118.7,152.9)
  TOP w0.254: v3(224.47,96.64) 223.67,97.44 219.05,97.44 218.44,96.83 PR869.1 218.12,95.25 216.73,95.25 ; PR863.2 41.85,148.53 v3(41.54,148.83)
  IN1 w0.254: v3(118.7,152.9) 118.7,153.11 118.29,153.52 118.29,157.25 119.43,158.39 v3(119.43,158.61)
  IN2 w0.254: v3(118.7,152.9) 118.7,153.32 118.05,153.98 104.54,153.98 102.13,151.56 92.24,151.56 89.45,154.36 76.04,154.36 73.69,152.01 66.99,152.01 66.24,152.76 48.34,152.76 47.72,152.14 47.44,152.14 44.77,149.47 43.37,149.47 42.55,148.64 41.73,148.64 v3(41.54,148.83) ; v3(224.47,96.64) 224.47,108.49 222.12,110.84 222.12,116.64 220.54,118.23 220.54,121.6 215.97,126.17 215.97,127.88 212.17,131.67 212.17,136.35 201.79,146.73 200.77,146.73 199.92,147.57 199.92,148.78 196.34,152.36 196.34,153.57 194.98,154.93 191.25,154.93 187.41,158.76 184.09,158.76 174.77,168.08 155.99,168.08 154.7,166.79 150.93,166.79 149.2,165.06 146.79,165.06 144.74,163.01 141.63,163.01 139.9,161.28 134.75,161.28 132.85,159.38 130.47,159.38 129.89,158.8 119.62,158.8 v3(119.43,158.61)
N1009724: length 4.7
  TOP w0.102: PR870.1 219.39,93.72 v1(219.2,93.53)
  TOP w0.254: 216.73,93.32 217.57,93.32 218.44,94.2 PR869.2 PR870.1
N1009740: length 302
  TOP w0.254: v3(180.21,40.11) 179.9,39.79 PD813.1 ; v3(113.41,149.49) 114.16,149.49 116.79,152.12 116.79,153.36 117.32,153.89 117.32,157.02 v1(116.51,157.84) 114.21,160.14 108.4,160.14 107.95,160.58 103.38,160.58 103.06,160.9 PQ815.4 ; PD821.1 v3(180.94,16.87)
  IN2 w0.254: v3(88.14,41.07) 88.39,41.07 89.03,41.71 89.03,46.64 90.62,48.23 90.62,56.89 95.38,61.65 95.38,67.43 90.62,72.19 90.62,90.86 95.71,95.95 95.71,115.63 87.99,123.35 87.99,125.7 87.29,126.4 87.29,126.74 83.63,130.39 83.63,140.89 84.08,141.34 84.08,144.65 85.03,145.6 85.03,146.74 85.47,147.18 89.07,147.18 89.38,147.5 111.42,147.5 v3(113.41,149.49) ; v3(180.21,40.11) 179.38,40.11 175.15,35.88 175.15,20.12 178.4,16.87 v3(180.94,16.87)
  IN3 w0.254: v3(88.14,41.07) 91.51,41.07 92.94,42.51 155.44,42.51 158.6,39.36 169.2,39.36 171.1,37.46 175.96,37.46 178.61,40.11 v3(180.21,40.11)
N1009748: length 5.3
  TOP w0.102: PQ824.6 220.52,94.54 219.94,93.96 v1(219.94,92.14)
  TOP w0.254: PR870.2 219.83,96 220.28,96 220.52,95.76 PQ824.6
N1009764: length 5.2
  TOP w0.102: PR875.2 221.16,90.86 221.67,90.35 v1(222,90.35)
  TOP w0.254: 221.17,91.95 221.82,92.6 PQ824.3 ; 221.17,91.95 PR875.2 ; 221.17,91.95 PQ824.2
N1009998: length 7.5
  TOP w0.254: PU807.4 182.88,45.12 183.06,44.94 185.8,44.94 186.43,45.56 v1(186.43,45.9) 186.43,46.83 186.82,47.22 PD810.2
N1010104: length 4.7
  TOP w0.102: 98.87,162.68 v1(98.87,161.09)
  TOP w0.254: PR822.2 100.71,160.84 98.87,162.68 PQ816.1
N1208920: length 8.4
  TOP w0.102: v1(166.4,21.2) 167.36,22.16 PQ828.1
  TOP w0.254: PQ828.1 168.73,22.16 170.02,20.88 173.22,20.88 PD815.2
N16790095: length 3.8
  BOTTOM w0.089: UH1.C26 175.36,138.57 175.67,138.88 175.91,138.88
  BOTTOM w0.102: 175.91,138.88 176.15,139.12 176.15,139.43 176.32,139.61 177.72,139.61 T59.1
N16807572: length 5
  TOP w0.102: T58.1 154.92,127.88 157.38,127.88 158.17,128.67 v3(158.17,129.02)
  BOTTOM w0.089: v3(158.17,129.02) 158.49,128.7 UH1.BB2
N16834717: length 7.5
  TOP w0.102: R1607.2 R1620.2 230.19,68.7 231.08,69.59 v1(231.08,69.97) 231.08,70.67 230.3,71.45 U36.5
N16837387: length 2.5
  TOP w0.102: v1(61.11,149.37) 61.11,147.98 RV78.2 60.57,147.88 60.46,147.99 QV8.2
N16843836: length 3.1
  BOTTOM w0.089: UV1.AL13 68.58,145.09 67.5,146.17
  BOTTOM w0.102: T151.1 67.25,146.93 67.25,146.42 67.5,146.17
N16843839: length 5.5
  BOTTOM w0.089: UV1.AJ13 68.58,143.94 68.2,144.33 68.2,145.15 67.44,145.91 66.87,145.91 66.61,146.17
  BOTTOM w0.102: 66.61,146.17 66.11,146.67 66.11,147.63 T152.1
N16845401: length 2.8
  TOP w0.089: T65.1 161.05,133.26 161.05,133.76 160.78,134.03 160.52,134.03 v3(159.95,134.6)
  BOTTOM w0.089: UH1.AW17 159.95,134.85 v3(159.95,134.6)
N16845569: length 2.3
  TOP w0.089: v3(160.6,134.6) 161.11,134.09 T67.1
  BOTTOM w0.089: v3(160.6,134.6) 160.6,134.8 UH1.AV17
N16850101: length 2.1
  TOP w0.089: CV86.2 61.58,135.56 RV45.1 62.24,135.58 v1(62.61,135.94)
N16850105: length 2.4
  TOP w0.089: 58.11,135.3 CV85.2
  TOP w0.102: v1(56.2,135.5) 56.4,135.3 RV46.1 58.11,135.3
N16856615: length 1.9
  TOP w0.089: v3(64.99,130.61) 65.79,131.41 T108.1
  BOTTOM w0.089: v3(64.99,130.61) 64.99,130.62 64.58,131.02 UV1.N8
N16856618: length 2.6
  TOP w0.089: v3(65.6,131.87) 65.81,132.09 T105.1
  BOTTOM w0.089: v3(65.6,131.87) 66.12,132.4 UV1.P10
N16856621: length 1.4
  TOP w0.089: v3(62.54,132.63) 62.04,132.63 T106.1
  BOTTOM w0.089: UV1.P4 62.11,132.2 v3(62.54,132.63)
N16857314: length 3.8
  TOP w0.102: T57.1 157.3,127.29 158.82,128.81 v3(158.82,129.02)
  BOTTOM w0.089: UH1.BA2 158.82,128.9 v3(158.82,129.02)
N16858942: length 2.1
  TOP w0.089: T75.1 167.77,132.53 v3(167.32,132.09)
  BOTTOM w0.089: UH1.AB10 167.12,132.09 v3(167.32,132.09)
N16878549: length 10.5
  BOTTOM w0.089: 155.02,147.79 155.8,147.79 156.33,148.33 157.93,148.33 158.46,147.79 159.15,147.79 160.08,146.87 160.08,146.54 160.38,146.24 160.38,145.77 UH1.AV43
  BOTTOM w0.102: 155.02,147.79 154.35,147.79 152.61,149.53 T62.1
N16878550: length 6.9
  BOTTOM w0.089: UH1.AY45 159.56,146.82 158.94,147.44 158.31,147.44 157.79,147.96 156.49,147.96
  BOTTOM w0.102: T63.1 153.94,147.3 155.83,147.3 156.49,147.96
N16878551: length 11.7
  BOTTOM w0.102: T60.1 151.51,150.95 154.45,148.02 155.65,148.02 156.14,148.51 158,148.51 158.53,147.98 159.59,147.98 160.39,147.18 UH1.AV45
N16878552: length 11.2
  BOTTOM w0.089: 156.41,148.14 157.86,148.14 158.39,147.62 159.08,147.62 159.9,146.79 159.9,146.27 UH1.AW44
  BOTTOM w0.102: T61.1 151.66,149.63 152.1,149.2 152.62,149.2 154.26,147.56 155.83,147.56 156.41,148.14
N16878560: length 2
  TOP w0.089: v3(160.16,145.33) 160.55,145.72 T64.1
  BOTTOM w0.089: UH1.AU42 160.76,145.28 160.21,145.28 v3(160.16,145.33)
N16878561: length 11.6
  BOTTOM w0.102: T66.1 152.52,150.28 154.54,148.25 155.57,148.25 156.02,148.7 158.08,148.7 158.61,148.17 159.67,148.17 160.75,147.09 160.75,146.24 UH1.AU44
N16976351: length 1.3
  TOP w0.089: T71.1 165.58,131.28 v3(165.7,131.39)
  BOTTOM w0.089: UH1.AD10 165.82,131.39 v3(165.7,131.39)
N17068457: length 1.2
  TOP w0.089: v3(165.76,144.48) 165.73,144.51 T76.1
  BOTTOM w0.089: UH1.AD39 166.12,144.13 165.77,144.48 v3(165.76,144.48)
N17068936: length 1.8
  TOP w0.089: T77.1 166.06,144.13 v3(165.76,143.83)
  BOTTOM w0.089: v3(165.76,143.83) 165.89,143.83 UH1.AD38
N17103565: length 2.1
  TOP w0.102: U146.10 218,128.07 217.84,128.22 v3(217.55,128.22) 217.41,128.08 C454.1
N17103571: length 2.1
  TOP w0.102: U146.12 218.2,127.27 218.17,127.25 v1(217.56,127.25) 217.5,127.19 C451.1
N17103600: length 7.1
  BOTTOM w0.089: 156.79,147.58 157.64,147.58 158.16,147.06 158.49,147.06 UH1.BA45
  BOTTOM w0.102: 156.79,147.58 156.04,146.84 153.27,146.84 T78.1
N17104124: length 5.7
  BOTTOM w0.089: 157.88,147.08 UH1.BC45 ; 156.83,147.35 157.6,147.35
  BOTTOM w0.102: T79.1 153.67,146.61 156.08,146.61 156.83,147.35 ; 157.6,147.35 157.88,147.08
N17104491: length 6
  TOP w0.102: v1(189.74,172.27) 190.09,172.62 D7.1 193.51,172.62 R3737.1 193.98,173.09 194.5,173.09 194.76,172.83 U148.3
N17104650: length 3.5
  BOTTOM w0.089: 155.13,146.11 156.61,146.11 UH1.BE43
  BOTTOM w0.102: 155.13,146.11 154.5,146.11 T80.1
N17105178: length 4.1
  BOTTOM w0.102: UH1.BE44 156.97,146.35 154.11,146.35 T81.1
N17139830: length 1.4
  TOP w0.089: v3(171.18,142.04) 170.76,142.46 T82.1
  BOTTOM w0.089: v3(171.18,142.04) 171.18,141.91 UH1.M33
N17139840: length 1.5
  TOP w0.089: T83.1 172.35,142.62 v3(171.8,142.08)
  BOTTOM w0.089: UH1.L33 171.48,141.76 v3(171.8,142.08)
N17164952: length 5.4
  BOTTOM w0.089: 155.67,140.65 155.83,140.48 157.33,140.48 157.61,140.19 UH1.BC30
  BOTTOM w0.102: T84.1 153.42,140.9 154.95,140.9 155.14,140.7 155.61,140.7 155.67,140.65
N17164953: length 1.6
  TOP w0.089: T85.1 158.92,139.94 v3(159.07,140.1)
  BOTTOM w0.089: UH1.BB29 158.76,139.79 v3(159.07,140.1)
N17190484: length 3.9
  TOP w0.254: PQ827.1 184.75,40.8 PR839.2 185.97,41.15 v3(185.99,41.12) PQ821.6
N17195971: length 7.5
  TOP w0.254: PQ707.2 233.61,143.5 233.07,142.97 v3(232.87,142.97) 232.65,142.97 232.31,143.31 PR725.2 PR727.1 231.99,141.75 PR723.1 PC736.1 230.4,141.56 229.92,142.04 PU701.1
N17205976: length 3.6
  TOP w0.254: R864.2 237.11,70.86 v1(238.06,71.81) 238.92,72.67 JDEG2.1
N17220570: length 5.9
  TOP w0.089: RH195.1 160.15,127.64 160.15,130.74 v3(160.85,131.44) 161.23,131.44 v1(161.37,131.3)
  BOTTOM w0.089: UH1.AT8 161.12,131.17 v3(160.85,131.44)
N17513991: length 27
  TOP w0.102: v3(264.1,154.8) 264.16,154.87 R39.2 ; v1(280.87,150.99) 281.52,150.99 282.12,151.59 v3(282.12,152.77)
  TOP w0.254: R40.2 282.12,153.85 v3(282.12,152.77) 282.49,152.77 282.61,152.9 Q330.2
  IN3 w0.127: v3(282.12,152.77) 281.19,151.84 276.95,151.84 275.5,153.29 275.5,153.91 274.99,154.42 264.48,154.42 v3(264.1,154.8)
N17681337: length 2.1
  TOP w0.102: CD46.2 RC108.1 89.46,26.23 v1(89.16,26.53)
N17682009: length 1.9
  TOP w0.102: v1(95.38,25.06) 95.38,25.85 RC109.1 CD47.2
N17682019: length 0.9
  TOP w0.102: CD48.2 RC110.1
N17682043: length 4.9
  TOP w0.102: v2(103.05,27.36) 102.72,27.69 RD25.1 RD2.2 RD4.1 99.24,27.69 99.16,27.61 QD9.1
N17734625: length 3.3
  TOP w0.102: v1(262.99,150.21) 263.54,150.75 R1119.1 R1142.1 264.4,152.87 C1105.1
N17734631: length 4
  TOP w0.102: R1120.1 C1106.1 ; R1120.1 R1141.1 ; R1120.1 263.54,153.92 262.95,154.51 261.98,154.51 v1(261.76,154.3)
N17860472: length 7.1
  TOP w0.102: v2(91.75,108.03) RV108.2 90.36,105.35 90.36,103.5 90.11,103.24 88.98,103.24 UV4.J13
N18000518: length 4.8
  BOTTOM w0.102: JMINI2.22 203.9,149.05 203.44,148.59 203.44,147.85 R703.2 203.04,147.41 v1(204.03,146.42)
N18000576: length 4.7
  BOTTOM w0.102: v1(217.58,160.11) 217.1,159.63 216.61,159.63 R707.1 215.84,159.39 215.84,158.41 216.14,158.11 JMINI2.49
N18107028: length 2.1
  BOTTOM w0.102: v1(152.87,156.89) R3761.2 C1551.1
N18289631: length 25.8
  TOP w0.102: JHP1.5 291.82,159.4 292.39,158.83 292.39,157.46 289.64,154.7 v2(287.02,154.7) 286.92,154.8 v3(286.92,155.39)
  BOTTOM w0.102: R1100.2 276.24,157.66 277.14,157.66 279.15,155.65 281.2,155.65 282.98,153.88 284.49,153.88 284.84,153.53 R1676.1 286.92,154.52 v3(286.92,155.39)
N18386761: length 5.8
  TOP w0.089: 58.22,102.46 58.4,102.65 58.76,102.65 58.87,102.54 59.19,102.54 59.51,102.86 UV3.J13
  TOP w0.102: RV118.2 56.14,100.89 56.39,100.64 v1(56.96,100.64) 57.22,100.64 57.98,101.4 57.98,102.23 58.22,102.46
N18505964: length 1.3
  TOP w0.089: T2.1 122.7,80.97 v3(122.47,81.2)
  BOTTOM w0.089: JCPU1.AC7 122.94,81.67 v3(122.47,81.2)
N18614557: length 4.3
  TOP w0.102: v3(48.83,164.46) v1(47.96,164.46)
  TOP w0.254: PU700.6 49.21,164.31 49.07,164.46 v3(48.83,164.46)
  BOTTOM w0.254: PC708.2 PR714.1 49.09,164.71 v3(48.83,164.46) 48.58,164.71 PR713.1
N18623445: length 4.8
  TOP w0.102: PD820.2 175.2,26.23 v1(175.31,26.34)
  TOP w0.254: PD820.2 174.75,24.21 PR828.2 173.25,24.21 173.06,24.02 PQ829.2
N18623534: length 5.5
  TOP w0.254: PR830.2 167.78,26.25 168.94,26.25 v1(169.09,26.1) 169.11,26.08 PQ828.2 169.77,24.25 170.19,24.67 PQ829.1
N18623732: length 6
  TOP w0.102: PR894.2 v1(164.2,23.21)
  TOP w0.254: PR894.2 PR895.2 165.57,24.25 PQ828.3 167.18,25.15 166.59,25.75 PR830.1
N18643940: length 5.2
  TOP w0.102: Q75.1 230.14,109.16 229.94,108.96 R934.1 229.94,107.9 230.38,107.46 231.83,107.46 v1(232.67,106.62)
N18690134: length 2.8
  TOP w0.089: RH330.2 177.22,146.93 177.22,146.93
  TOP w0.102: v1(178.31,148.11) 178.31,147.5 177.66,146.85 CH76.1 177.22,146.93
N18703943: length 1.4
  TOP w0.089: v3(118.47,82.2) 118.87,81.8 T3.1
  BOTTOM w0.089: JCPU1.AG8 118.94,82.67 v3(118.47,82.2)
N18790484: length 5.4
  TOP w0.102: PD821.2 177.55,16.87 v1(179,18.32)
  TOP w0.254: PQ830.1 176.15,16.16 176.86,16.87 PD821.2
N18790539: length 2.5
  TOP w0.254: PQ830.2 174.07,16.82 PR833.1 PR834.2
N18790579: length 3.8
  TOP w0.102: PQ831.1 v1(171.96,18.89)
  TOP w0.254: PR834.1 174.55,18.44 PQ831.1
N18790685: length 5.3
  TOP w0.102: v1(170.98,19.98) 171.42,19.54 PQ831.2
  TOP w0.254: PQ831.2 173.64,19.54 174.27,20.17 PU808.4
N18793722: length 4.2
  TOP w0.254: PR804.2 175.93,74.37 v1(176.6,73.71) 176.6,73.46 176.29,73.16 PQ807.6
N18834972: length 8.7
  TOP w0.102: v1(225.93,139.5) 226.84,140.4 PR726.2
  TOP w0.254: PU701.2 227.78,143.31 226.95,142.48 PR726.2 PR730.1 PR731.1 PC726.1
N18878176: length 8.1
  TOP w0.102: PBATT1.3 66.21,168.33 v1(66.55,168.33) 68.44,168.33 70,166.77 70,165.78 PD4.3
N18894554: length 3.2
  BOTTOM w0.102: v1(128.35,136.98) 127.99,136.98 PR550.1
  BOTTOM w0.508: PC542.1 PR550.1
N18894698:
  vias: v3(128.68,140.17)
N18894707: length 2.4
  BOTTOM w0.203: PU500.28 122.2,143.49 122.07,143.62 v3(121.95,143.62) 120.99,143.62 PR507.2
N18894708: length 2.6
  BOTTOM w0.203: PR512.2 121.03,145.58 v1(121.97,144.65) 122.16,144.65 122.52,144.29 PU500.30
N18894710: length 2.4
  BOTTOM w0.203: PU500.29 122.4,143.89 122.16,144.14 121.6,144.14 PR509.2
N18894766: length 2.4
  TOP w0.102: v1(130.88,146.61) 130.67,146.81 PC520.2
  TOP w0.254: PR533.1 128.92,147.69 129.8,146.82 PC520.2
N18894780: length 1.2
  TOP w0.254: PC527.2 127.98,145.86 PR543.1
N18894784: length 2.1
  TOP w0.102: PR539.1 125.08,147.13 v1(124.53,147.69)
  TOP w0.254: PR539.1 125.08,145.87 PC526.2
N18894855: length 5.1
  BOTTOM w0.203: PR535.2 130.44,143.06 128.78,143.06 128.76,143.03 v1(128.27,143.03) 127.76,143.03 127.7,143.09 PU500.14
  BOTTOM w0.254: PC521.1 PR535.2
N18894856: length 0.9
  BOTTOM w0.254: PC521.2 131.9,144.58 PR545.2
N18894871: length 24.7
  BOTTOM w0.254: PR551.1 130.35,139.56 133.42,139.56 134.09,140.24 136.23,140.24 v1(136.81,139.66) 137.62,138.85 137.62,123.94 PH501.2
N18894872: length 4.5
  BOTTOM w0.102: v1(133.67,142.1) 133.22,142.55 PR548.2
  BOTTOM w0.254: PC538.1 PC529.1 131.84,142.03 PR548.2
N18894895: length 5
  TOP w0.102: PR530.1 129.8,140.82 v1(130.38,140.82)
  TOP w0.254: PC518.1 127.61,141.43 v3(128.03,141.85) PR530.1
  BOTTOM w0.203: PU500.16 127.59,142.29 v3(128.03,141.85)
N18898957: length 6.2
  TOP w0.102: v1(50.95,169.05) 50.95,168.81 52.02,167.74 PR704.1
  TOP w0.254: PU700.2 52,165.95 51.66,166.29 v3(51.66,166.65) 51.84,166.83 52.27,166.83 PC704.1 52.33,166.88 PR704.1
  BOTTOM w0.254: v3(51.66,166.65) 51.88,166.42 PC703.2
N18899027: length 5.2
  TOP w0.254: PR705.1 53.23,167.73 PC704.2 53.23,166.5 v3(52.9,166.17) 52.5,165.77 PU700.1
  BOTTOM w0.102: v1(54.04,164.65) 53.74,164.65 PC705.1
  BOTTOM w0.254: v3(52.9,166.17) 52.96,166.11 PC705.1
N18990088: length 1.4
  TOP w0.254: T4.1 130.01,102.66 130.47,102.2 v3(130.47,102.2)
  BOTTOM w0.254: JCPU1.R27 v3(130.47,102.2)
N19270300: length 1.4
  TOP w0.089: v3(134.47,102.2) 133.97,101.7 T40.1
  BOTTOM w0.089: v3(134.47,102.2) JCPU1.L27
N19270310: length 1.4
  TOP w0.089: T39.1 134.99,102.68 v3(135.47,102.2)
  BOTTOM w0.089: v3(135.47,102.2) JCPU1.K27
N19270320: length 1.4
  TOP w0.254: T41.1 128.98,101.7 v3(129.47,102.2)
  BOTTOM w0.254: JCPU1.T27 v3(129.47,102.2)
N19293545: length 1.4
  TOP w0.089: v3(127.47,102.2) 127.9,102.63 T42.1
  BOTTOM w0.305: v3(127.47,102.2) JCPU1.V27
N19348815: length 1.3
  TOP w0.254: v3(132.47,101.2) 132.02,101.65 T43.1
  BOTTOM w0.305: JCPU1.N26 v3(132.47,101.2)
N19355782: length 2.3
  TOP w0.089: T44.1 114.03,101.76 v3(114.47,102.2)
  BOTTOM w0.254: v3(114.47,102.2) JCPU1.AL27
N19359234: length 1.3
  TOP w0.089: v3(115.47,102.2) 115.26,101.98 T45.1
  BOTTOM w0.254: v3(115.47,102.2) JCPU1.AK27
N19359738: length 4
  TOP w0.203: v3(195.39,36.11) 195.85,36.57 195.85,37.35 196.19,37.69 PU100.4
  TOP w0.254: PR102.2 PR100.2 v3(195.39,36.11)
N19359776: length 3.3
  TOP w0.203: PU100.7 197.85,36.04 v1(197.27,35.46)
  TOP w0.254: PR118.2 PR119.1 197.26,35.45 v1(197.27,35.46)
N19359778: length 4.3
  TOP w0.203: PR105.1 195.09,34.28 v3(195.39,34.58) 196.22,35.41 196.22,37.16 196.34,37.29 PU100.5
N19359887: length 3.2
  TOP w0.203: PR104.2 PR101.2 v3(195.35,39.23) 196.1,38.49 PU100.2
N19359966: length 2
  TOP w0.102: PC111.1 197.69,43.73 v1(196.52,43.73)
N19360011: length 3.7
  TOP w0.203: PR106.1 195.67,41.01 v3(195.8,40.88) 196.1,40.58 196.1,39.1 196.32,38.89 PU100.1
N19360218: length 2
  TOP w0.102: 199.39,33.01 PR108.1 200.97,33.01 v1(201.27,32.71)
N19438915: length 2.3
  TOP w0.089: v3(140.47,92.2) 140.96,91.71 T46.1
  BOTTOM w0.089: v3(140.47,92.2) JCPU1.E17
N19581764: length 1.2
  TOP w0.089: v3(126.47,107.2) 126.48,107.21 T48.1
  BOTTOM w0.089: v3(126.47,107.2) JCPU1.W32
N19581774: length 1.3
  TOP w0.089: T49.1 114.04,91.63 v3(114.47,91.2)
  BOTTOM w0.089: JCPU1.AL16 v3(114.47,91.2)
N19592461: length 2.1
  TOP w0.089: T51.1 116.09,88.03 v3(116.1,88.01)
  BOTTOM w0.089: JCPU1.AL13 115.82,87.73 v3(116.1,88.01)
N21489543: length 4.8
  TOP w0.089: v3(115.48,108.25) 115.86,108.63 115.86,110.38 T56.1
  BOTTOM w0.089: v3(115.48,108.25) 115.94,107.79 JCPU1.AK33
N23050350: length 6.7
  BOTTOM w0.089: JCPU1.AR1 110.94,75.67 108.91,73.63
  BOTTOM w0.102: T34.1 107.4,72.97 108.25,72.97 108.91,73.63
N23050352: length 6.5
  BOTTOM w0.089: JCPU1.A2 145.06,76.73 146.33,75.46
  BOTTOM w0.102: T33.1 146.33,75.46
N23050370: length 1.8
  TOP w0.089: T29.1 136.97,81.7 v3(136.47,81.2)
  BOTTOM w0.089: v3(136.47,81.2) 136,80.73 JCPU1.K6
N23050372: length 1.4
  TOP w0.089: T25.1 138.96,80.71 v3(139.47,80.2)
  BOTTOM w0.089: v3(139.47,80.2) JCPU1.F5
N23050374: length 8.7
  TOP w0.089: 112.97,73.63 112.97,75.7 v3(113.47,76.2)
  TOP w0.102: T27.1 113.29,69.14 113.29,70.68 112.97,70.99 112.97,73.63
  BOTTOM w0.089: JCPU1.AM2 113.94,76.67 v3(113.47,76.2)
N23050426: length 5.6
  BOTTOM w0.102: T18.1 142.94,112.6 JCPU1.C35
N23050428: length 5.1
  BOTTOM w0.102: JCPU1.B35 143.94,113.61 T20.1
N23050430: length 6.3
  BOTTOM w0.102: JCPU1.A34 144.42,109.25 144.42,113.73 T8.1
N23050432: length 5.7
  BOTTOM w0.102: JCPU1.A35 144.94,112.42 T9.1
N23050450: length 4.4
  BOTTOM w0.089: JCPU1.AT2 109.93,76.72 108.74,76.72
  BOTTOM w0.102: T5.1 106.58,78.21 108.07,76.72 108.74,76.72
