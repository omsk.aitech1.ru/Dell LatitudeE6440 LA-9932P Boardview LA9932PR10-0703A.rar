# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.05V_MP: length 23
  TOP w0.254: PR306.1 180.23,99.99 178.01,102.21 172.24,102.21 167.55,106.9 165.01,106.9 164.48,106.37 163.79,106.37 163.6,106.17 PC310.1
  vias: v1(155.34,101.06) v3(160.91,103.24) v4(157.29,101.72) v4(157.93,101.72) v4(158.56,101.72) v4(158.69,104.19) v4(159.2,101.72) v4(159.32,104.19) v4(159.83,101.72) v4(159.96,104.19) v4(160.59,104.19) v4(161.23,104.19)
+1.5V_RUN: length 171.4
  TOP w0.508: v3(152.34,140.18) 152.95,140.18 152.97,140.2 155.5,140.2 RH192.1 ; RH57.2 RH51.1 155.82,129.28 v3(155.54,129)
  TOP w2.54: 199.96,62.86 200.6,62.86 202.24,61.22 211.48,61.22 215.78,65.52 218.32,65.52
  IN1 w1.016: 222.19,65.14 231.4,65.14 233.05,63.49 233.05,60.44 233.36,60.12
  IN2 w2.54: 221.05,106.23 221.05,100.28 220.09,99.33 220.09,94.48
  IN3 w0.254: v3(164.78,141.44) 164.3,140.96 163.7,140.96 163.34,140.6 v3(163.34,138.84)
  IN3 w2.54: 26.67,194.62 26.67,171.88 33.97,164.58 40.43,164.58 51.35,153.66 58.88,153.66 59.55,152.99 68.76,152.99 69.24,152.5 75.64,152.5 76.76,153.62 79.52,153.62 ; 107.25,157.47 101.54,151.76 91.31,151.76 89.73,153.34 85.66,153.34
  BOTTOM w0.254: UH1.AN11 162.01,132.62 v3(161.78,132.62) ; v3(164.78,141.44) 164.92,141.44 165.21,141.73 UH1.AF34 ; UH1.AK26 163.67,138.51 v3(163.34,138.84) 163.34,138.91 UH1.AK28 ; v3(156.57,137.07) 157.05,137.07 UH1.BE22 ; UH1.AW40 159.5,145.16 v3(159.01,145.66) 158.64,146.03 UH1.BB44
  BOTTOM w0.508: v3(159.52,151.62) 159.83,151.32 RH165.2 ; RH188.1 v3(152.34,140.18)
  vias: v2(153.48,150.88) v3(26.23,202.3) v3(26.23,201.69) v3(26.23,201.08) v3(26.84,201.69) v3(26.84,201.08) v3(152.75,133.38) v3(152.86,151.95) v3(153.13,152.47) v3(153.35,133.38) v3(153.47,151.95) v3(153.74,152.47) v3(154.08,151.95) v3(155.51,119.75) v3(156.1,119.75) v3(156.1,119.17) v3(156.68,119.75) v3(156.68,119.17) v3(220.01,65.31) v3(220.27,64.76) v3(220.51,108.97) v3(220.51,108.38) v3(220.51,107.8) v3(220.6,65.31) v3(220.85,64.76) v3(221.06,108.64) v3(221.06,108.05) v3(221.18,65.31) v3(234.19,59.5) v3(234.19,58.92)
+1.05V_RUN: length 309.5
  TOP w0.254: v3(168.28,142.59) 168.73,143.04 168.73,145.84 CH50.1
  TOP w0.508: v3(200.99,86.81) 200.52,86.34 R866.2 ; R1179.1 203.65,87.95 v3(203.04,88.56) ; CH37.1 161.22,142.91 161.64,143.33 v3(161.78,143.33) ; v3(168.63,140.46) 168.63,140.06 168.68,140.01 CH47.1 ; RH244.1 166.53,149.63 v3(165.93,150.23) ; v3(100.28,112.96) 100.28,113.79 101.22,114.73 104.33,114.73 104.65,114.42 104.65,113.91 104.97,113.59 RC99.2 ; RC53.1 107.95,112.83 v3(108.21,113.08) 108.21,113.1 v2(109.16,114.05) 109.66,114.56 RC54.1 RC57.1
  IN1 w0.508: v3(207.79,101.11) 207.37,101.11 206.12,102.35 206.12,103.51 201.44,108.19 188.55,108.19 187.77,107.42 180.29,107.42 179.26,108.45 170.59,108.45 165.15,113.88 163.08,113.88 v3(162.32,114.64) ; v3(100.28,112.96) 100.28,109.48 98.93,108.13 98.93,104.33 101.61,101.65 102.42,101.65 v3(103.57,100.5) 103.57,99.18 v3(105.92,96.83)
  IN2 w0.254: v3(161.78,143.33) 162.31,142.8 162.31,140.58 164,138.88 v3(164,137.21) ; 166.06,140.65 166.06,140.7 166.32,140.96 166.93,140.96 167.01,140.89 167.87,140.89 168.73,141.75 168.73,142.13 v3(168.28,142.59)
  IN2 w0.508: v3(200.99,86.81) 202.26,86.81 203.04,87.58 v3(203.04,88.56) 203.04,89.11 202.63,89.51 202.63,92.94 205.74,96.05 205.74,99.06 v3(207.79,101.11) ; 166.06,140.65 166.05,140.64 166.05,138.93 v3(165.97,138.84)
  IN2 w1.016: 153.86,97.97 153.86,101.68 156.33,104.15 156.33,107.59 157.99,109.25 157.99,114.35 158.31,114.67
  IN3 w0.508: 155.79,151.22 156.78,150.23 v3(165.93,150.23) ; v3(153.67,96.22) 151,93.55 151,90.41 148.4,87.81 148.4,62.16 145.04,58.79 114.18,58.79 107.52,65.46 101.47,65.46 94.83,72.1 94.83,81.36 105.32,91.85 105.32,96.23 v3(105.92,96.83)
  IN3 w1.016: 154.5,141.6 153.8,142.29 153.8,149.95 154.89,151.04
  IN4 w0.508: v3(100.28,112.96) 102.94,112.96 103.06,113.08 v3(108.21,113.08)
  BOTTOM w0.254: v3(161.78,143.33) 161.78,142.84 UH1.AN35 UH1.AN34 ; v3(169.24,141.94) 169.15,141.94 UH1.U35 168.53,142.34 v3(168.28,142.59) 168.62,142.94 UH1.U36
  BOTTOM w0.279: JXDP2.40 207.56,100.88 v3(207.79,101.11)
  BOTTOM w0.508: RC27.1 101.91,112.83 100.41,112.83 v3(100.28,112.96) ; v3(155.35,123.08) 156.24,123.08 156.58,123.42 RH206.1 ; RC60.1 v3(105.92,96.83) ; v3(103.57,100.5) 103.71,100.64 RC55.1
  vias: v3(153.67,96.83) v3(154.98,152.24) v3(155.45,151.76) v3(155.58,141.6) v3(156.28,141.28) v3(158.61,135.56) v3(158.87,116.4) v3(159.35,114.64) v3(159.45,116.4) v3(159.96,114.64) v3(160.06,116.4) v3(160.59,135.56) v3(160.54,114.64) v3(160.67,116.4) v3(161.13,114.64) v3(161.24,136.57) v3(161.28,116.4) v3(161.71,114.64) v3(161.9,136.58) v3(162.54,136.57) v3(162.55,135.55) v3(163.34,135.58) v3(164.02,133.98) v3(164.65,133.98) v3(165.32,137.21) v3(165.29,136.39) v3(165.32,135.58) v3(165.98,137.21) v3(165.96,135.58) v3(167.97,140.44)
+1.05V_RUN_CHG: length 4.7
  TOP w0.102: v1(155.65,118.51) 155.98,118.18 156.3,118.18 157,117.48 157.09,117.48 157.42,117.15 Q70.1
  TOP w0.508: R925.2 157.82,115.73 157.42,116.13 Q70.1
+1.5V_RUN_HDMI: length 6.5
  TOP w0.203: U19.31 15.41,201.69 15.24,201.86 14.49,201.86 C355.1 ; U19.12 21.56,198.49 21.84,198.22 v3(21.84,198.04) ; U19.40 15.47,198.09 v3(14.8,197.41)
  TOP w0.508: v3(14.8,197.41) C354.1 ; v3(14.8,202.37) C355.1
  vias: v1(22.86,200.78) v3(21.97,201.73)
+1.5V_RUNP: length 15.7
  TOP w0.254: v4(206.06,55.11) PC402.1 PR402.1
  IN1 w0.254: v4(195.96,59.43) 205.61,59.43 206.06,58.98 v4(206.06,55.11)
  vias: v1(196.15,58.79)
+1.05VSP_5V: length 1.4
  TOP w0.102: PC308.1 v1(173.93,99.88)
+1.05VSP_B+: length 1.3
  TOP w0.102: v2(171.01,97.15) 170.8,96.94 PC302.1
+1.8V_MPLL_PVDD: length 9.5
  TOP w0.508: v3(64.96,129.53) 64.33,130.17 v1(64.33,130.33) 64.33,130.69 63.82,131.19 61.66,131.19 CV215.1 CV219.1 58.54,131.26 CV216.1 58.13,130.85 LV17.1
  BOTTOM w0.254: v3(64.96,129.53) 64.58,129.91 UV1.L8
+1.8V_RUN_CARD: length 28.1
  TOP w0.203: 189.3,23.1 188.75,23.1 188.59,23.27 U38.24
  TOP w0.508: v3(192.41,18.79) 191.9,18.28 v2(191.4,18.28) 190.76,18.28 190.3,18.74 C580.1 190.06,19.79 C560.2 190.06,22.34 189.3,23.1 ; JSD1.14 v3(206.98,9.84)
  IN1 w0.508: v3(206.98,9.84) 202.62,9.84 193.68,18.79 v3(192.41,18.79)
+1.8V_RUN_FB: length 4.1
  BOTTOM w0.102: PR689.1 96.98,122.43 v1(96.59,122.04)
  BOTTOM w0.508: PU603.2 98.38,124.2 PR687.1 97.55,122.48 PR689.1
+1.8V_RUN_GFX: length 51
  TOP w0.102: v4(95.12,125.34) v2(95.12,124.44)
  TOP w0.508: v3(55.5,129.78) 55.74,130.03 LV17.2 LV18.2 ; LV19.1 78.49,142.47 78.49,144.2 79.45,145.17 CV67.1 CV68.1 80.84,145.98 CV66.1 81.55,146.11 v3(81.81,145.85)
  IN2 w0.508: v3(69.03,142.1) 64.39,142.1 63.76,141.47 62.99,141.47 61.34,139.82 61.34,134.29 60.9,133.85 59.06,133.85 57.53,132.32 57.53,130.93 56.39,129.78 v3(55.5,129.78)
  IN3 w2.032: 90.62,128.2 89.21,128.2 84.49,132.91 84.49,140.12
  BOTTOM w0.254: UV1.AM30 81.38,145.42 v3(81.81,145.85)
  BOTTOM w0.305: UV1.AF14 69.58,142.09 v3(69.79,142.29)
  vias: v3(68.9,143.12) v3(72.26,150.1) v3(72.26,149.47) v3(72.9,150.1) v3(72.9,149.47) v4(94.49,126.61) v4(94.49,125.97) v4(95.12,125.97)
+1.8V_RUN_VIN: length 0.9
  BOTTOM w0.102: v1(109.67,123.37) 109.3,123.74 108.97,123.74
+1.8V_RUNP:
  vias: v1(97.41,128.96)
+1.8V_SPLL_PVDD: length 2.3
  TOP w0.102: v2(55.96,129.42) 57.13,128.25 LV18.1
  BOTTOM w0.3: UV1.H7 v3(63.38,127.8)
+1.35V_MEM: length 53.4
  TOP w0.508: 95.38,62.09 94.89,61.61 94.89,57.58 95.28,57.2 103.89,57.2 104.71,56.38 RC6.1 ; v3(101.04,25.77) 100.9,25.91 RD2.1 ; v3(96.71,25.45) 95.99,26.17 95.99,27.44 95.63,27.8 RD19.1 ; RD15.1 96.47,23.47 v3(96.14,23.8) ; RD22.1 v3(103.71,24.55)
  IN4 w0.508: v3(116.29,24.64) 116.05,24.88 112.4,24.88 112.07,24.55 v3(103.71,24.55) 102.49,25.77 v3(101.04,25.77) 97.03,25.77 v3(96.71,25.45) 96.14,24.88 v3(96.14,23.8)
  BOTTOM w0.305: v3(130.47,82.2) JCPU1.T8 ; v3(120.47,83.2) JCPU1.AE8 ; JCPU1.W2 127,76.73 v3(127.47,77.2) ; JCPU1.AB2 123.94,76.69 v3(123.47,76.22) ; JCPU1.W8 127,82.73 v3(127.47,83.2) ; v3(123.47,80.2) JCPU1.AB5 ; v3(133.47,82.2) JCPU1.N8 ; v3(120.47,77.2) JCPU1.AE2 ; v3(123.47,83.2) JCPU1.AB8 ; v3(127.47,80.2) 127,79.73 JCPU1.W5 ; JCPU1.T2 129.94,76.67 v3(129.47,76.2) ; v3(120.47,80.2) JCPU1.AE5 ; v3(130.47,79.2) JCPU1.T5
  vias: v2(96.8,86.74) v3(113.72,32.42) v3(113.72,30.89) v3(113.72,29.37) v3(113.69,18.69) v3(113.69,17.17) v3(113.69,15.64) v3(115.98,18.69) v3(115.98,17.17) v3(115.98,15.64) v3(116.26,40.62) v3(116.26,39.09) v3(116.26,37.57) v3(116.26,33.94) v3(116.26,32.42) v3(116.26,30.89) v3(116.26,29.37) v3(116.3,23.76) v3(117.22,87.3) v3(117.45,86.17) v3(117.84,20.21) v3(117.84,18.69) v3(117.84,17.17) v3(117.84,15.64) v3(118.47,86.2) v3(118.75,40.62) v3(118.75,39.09) v3(118.75,37.57) v3(118.75,32.42) v3(118.75,30.89) v3(118.75,29.37) v3(118.75,25.03) v3(118.75,23.51) v3(118.96,88.87) v3(119.37,18.69) v3(119.37,17.17) v3(119.37,15.64) v3(119.47,86.2) v3(119.48,81.23) v3(119.94,12.45) v3(120.47,86.2) v3(120.74,88.94) v3(120.89,20.21) v3(120.89,18.69) v3(120.89,17.17) v3(120.89,15.64) v3(121.39,82.3) v3(121.44,33.93) v3(121.47,86.2) v3(121.52,40.62) v3(121.52,39.09) v3(121.52,37.57) v3(121.52,32.42) v3(121.52,30.89) v3(121.52,29.37) v3(121.52,25.53) v3(121.52,24.01) v3(121.74,12.51) v3(122.52,88.94) v3(122.48,86.13) v3(122.85,20.21) v3(122.85,18.69) v3(122.85,17.93) v3(122.85,16.4) v3(123.21,32.42) v3(123.21,30.89) v3(123.21,29.37) v3(123.24,33.76) v3(123.32,25.71) v3(123.41,86.14) v3(123.47,85.2) v3(123.54,12.47) v3(123.57,23.93) v3(123.83,17.17) v3(124.29,88.94) v3(124.28,30.13) v3(124.36,20.59) v3(124.36,18.31) v3(124.36,16.02) v3(124.47,86.2) v3(124.44,39.47) v3(124.44,37.19) v3(124.91,38.33) v3(124.84,19.45) v3(125.05,31.27) v3(125.05,28.99) v3(125.34,12.55) v3(125.47,86.2) v3(125.47,75.2) v3(125.93,25.07) v3(125.93,23.55) v3(126.14,88.94) v3(126.06,20.21) v3(126.06,18.69) v3(126.06,17.93) v3(126.06,16.4) v3(126.22,40.62) v3(126.22,39.09) v3(126.22,37.57) v3(126.3,33.77) v3(126.3,33.08) v3(126.32,32.42) v3(126.32,30.89) v3(126.32,29.37) v3(126.47,86.2) v3(126.47,85.2) v3(126.49,82.22) v3(126.47,81.25) v3(126.47,78.21) v3(126.49,77.24) v3(127.14,12.51) v3(127.46,86.17) v3(127.83,62.61) v3(127.83,62.01) v3(127.83,61.4) v3(127.83,60.79) v3(127.98,88.94) v3(128.47,86.2) v3(128.68,20.21) v3(128.68,18.69) v3(128.68,17.17) v3(128.68,15.64) v3(128.94,40.62) v3(128.94,39.09) v3(128.94,37.57) v3(128.91,33.2) v3(128.94,32.42) v3(128.94,30.89) v3(128.94,29.37) v3(128.89,25.04) v3(128.89,23.51) v3(128.94,12.41) v3(129.48,86.17) v3(129.63,88.94) v3(129.92,12.5) v3(130.21,30.89) v3(130.21,29.37) v3(130.15,25.16) v3(130.15,23.64) v3(130.47,86.2) v3(130.47,85.2) v3(130.59,40.62) v3(130.59,39.09) v3(130.59,37.57) v3(130.81,20.21) v3(130.81,18.69) v3(130.81,17.17) v3(131.47,86.18) v3(131.66,88.94) v3(132.47,86.2) v3(133.49,86.17) v3(133.69,88.94) v3(134.24,62.78) v3(134.24,62.17) v3(134.24,61.56) v3(134.24,60.95) v3(134.47,86.2) v3(135.47,86.17) v3(135.79,88.94) v3(136.47,86.2) v3(137.69,88.94)
+1.35V_MEM_CHG: length 3
  TOP w0.102: R926.2 142.57,42.28 v1(142.57,41.32)
  TOP w0.508: R926.2 143.78,41.84 Q71.1
+1.35V_MEM_GFX: length 211.8
  TOP w0.254: UV3.D1 v3(69.86,99.26) ; UV4.P3 v3(80.2,98.46) UV4.P2 ; UV3.G2 v3(68.26,101.66) UV3.H3 ; UV4.T3 v3(81,97.66) ; UV4.F12 v3(87.4,105.66) ; UV3.F14 58.49,100.46 v3(58.47,100.48) ; UV3.T14 v3(58.66,108.86) ; UV4.F3 v3(80.2,104.86) ; UV4.C10 v3(86.6,107.26) UV4.D11 ; UV3.B14 v3(58.49,97.26) ; v3(58.37,104.46) UV3.L14 UV3.L13 ; v3(78.5,97) 78.77,97.26 UV4.T1 ; v3(58.49,98.86) UV3.D14 UV3.D13 ; UV3.T3 v3(67.46,108.06) ; v3(88.2,100.86) UV4.L13 UV4.K12 ; UV3.R5 v3(65.73,107.66) ; UV3.M14 v3(58.5,105.26) ; UV3.P1 v3(69.99,106.86) ; UV4.C5 v3(81.8,108.06) ; UV4.G14 v3(89.94,104.46) ; UV3.H12 v3(60.26,101.66) UV3.G13 UV3.G14 58.69,101.26 v3(58.49,101.46) ; UV4.P1 v3(78.46,98.86) ; UV4.M3 v3(80.2,100.06) ; UV3.P2 v3(68.26,107.26) UV3.P3 ; UV3.N10 v3(62.66,106.46) ; UV3.C10 v3(61.86,98.46) UV3.D11 ; UV4.B3 v3(80.2,108.06) ; UV4.G4 v3(81.8,104.86) ; UV3.G4 v3(66.66,100.86) ; UV4.M12 v3(87.4,100.06) ; UV3.E5 v3(65.86,100.06) ; UV4.D1 v3(78.6,107.26) ; UV3.G1 v3(69.06,101.66) ; UV4.L1 v3(79.4,101.66) UV4.L2 ; UV3.M3 v3(68.26,105.66) ; UV3.M1 v3(70.01,105.26) ; UV3.B12 v3(60.26,96.86) ; UV3.C5 v3(65.86,97.66) ; UV4.B12 v3(87.4,108.86) ; v3(61.06,98.46) UV3.D12 ; UV4.P12 v3(87.4,98.46) UV4.P11 ; UV3.F1 v3(69.06,100.86) ; UV4.T14 v3(89,96.86) ; UV4.E10 v3(85.63,106.06) ; UV4.G13 v3(88.2,104.86) ; UV3.K12 v3(60.26,103.26) ; UV4.L14 v3(89,100.86) ; UV3.E10 v3(62.66,99.26) ; UV4.B14 v3(89.98,108.46) ; UV4.L11 v3(86.6,100.86) ; UV4.M1 v3(78.46,100.46) ; UV3.T1 69.46,108.55 v3(69.8,108.89) ; UV4.T12 v3(87.4,96.86) ; UV4.B1 v3(78.6,108.86) ; UV4.H12 v3(88.2,103.26) ; UV3.P11 v3(61.86,107.26) ; UV3.G11 v3(61.86,100.86) ; UV3.P12 v3(60.26,107.26) ; UV3.B1 v3(69.86,97.66) ; UV4.D13 v3(88.2,106.46) ; UV3.R10 v3(62.66,108.06) ; UV4.L4 v3(81.8,100.86) ; UV4.D3 v3(80.2,107.26) ; UV3.F3 v3(68.26,100.86) ; UV4.R10 v3(85.8,97.66) ; UV4.M14 v3(89,100.06) ; UV3.B3 v3(67.46,96.86) ; UV4.D12 v3(87.4,107.26) ; UV4.G1 v3(78.6,104.86) ; UV4.G11 v3(86.6,104.86) ; UV3.K3 v3(68.26,103.26) ; UV4.F1 v3(78.6,105.66) ; UV4.N5 v3(82.6,100.06) ; UV3.L2 v3(69.06,104.06) UV3.L1 ; UV4.F14 v3(89.94,105.26) ; UV3.J1 v3(69.86,103.26) ; UV4.E5 v3(82.6,105.66) ; UV3.N5 v3(65.86,105.66) ; UV4.N10 v3(85.8,99.26) ; UV4.K3 v3(80.2,101.66) ; UV4.H3 v3(80.2,104.06) UV4.G2 ; UV4.R5 v3(81.8,97.66) ; UV3.D3 v3(68.26,99.26) ; UV4.P14 v3(89,98.46) ; UV3.T12 v3(60.26,108.86) ; UV3.P14 v3(58.49,106.86) ; UV3.L4 v3(67.46,104.06) ; UV3.M12 v3(60.26,105.66) ; UV3.F12 v3(61.06,100.06) ; UV3.L11 v3(61.86,104.86) ; v3(89.94,106.86) UV4.D14
  TOP w0.508: CV180.1 v3(66.36,94.99) ; CV21.1 CV18.1 v3(82.6,118.18) ; CV209.1 RV119.1 v3(64.21,94.99) ; v3(67.57,95) 67.25,94.68 CV189.1 CV145.1 ; CV43.1 56.83,97.27 v3(57.09,97.02) ; v3(70.23,95.11) 69.92,94.8 CV144.1 CV146.1 ; CV41.1 91.19,96.83 v3(91.06,96.96) ; RV187.2 v3(94.11,102.3) ; RV145.1 84.42,129.39 RV148.1 85.08,127.55 85.08,126.91 84.6,126.44 v3(84.45,126.44) ; CV191.1 56.01,98.23 v3(56.45,98.67) 56.01,99.12 CV192.1 ; v3(81.71,110.73) CV322.1 RV109.1 ; v3(91.12,99.62) CV152.1 ; CV44.1 v3(65.28,94.99) ; CV25.1 67.43,127.45 v3(67.81,127.07) ; CV165.1 CV164.1 v3(74.55,118.18) ; v3(76.11,129.21) 75.62,129.7 CV23.1 ; CV177.1 v3(91.12,98.73) ; CV167.1 CV166.1 v3(77.28,118.18) ; CV141.1 CV188.1 CV178.1 80.77,94.67 v3(81.15,95.05) ; v3(71.06,95.05) 70.81,94.8 CV156.1 ; CV208.1 RV139.1 93.44,103.17 v3(93.96,103.69) ; v3(66.63,113.9) CV333.1 RV191.1 ; CV157.1 v3(56.33,100) ; CV330.1 RV185.1 v3(87.96,113.15) ; v3(73.92,117.91) 73.65,118.18 CV163.1 CV19.1 ; RV189.2 RV190.2 53.93,102.16 CV350.1 v3(53.28,102.15) ; CV24.1 67.97,128.91 v3(67.78,129.1) 67.4,129.48 CV22.1 ; CV42.1 v3(81.85,95.05) ; v3(82.8,95.05) 82.92,94.92 CV323.1 RV129.1 ; v3(86.74,95.11) 87.06,94.79 CV151.1 CV143.1 ; CV153.1 v3(91.11,100.51) ; v3(80.14,118.18) CV26.1 CV13.1 ; CV176.1 v3(91.12,97.85) ; CV142.1 v3(88.84,94.99) ; RV193.1 v3(53.28,104.84) ; RV188.2 v3(94.11,101.41) ; v3(58.5,105.26) 58.45,105.21 57.85,105.21 57.34,105.72 CV158.1 ; CV20.1 v3(85.23,118.18)
  BOTTOM w0.254: UV4.D12 v3(87.4,107.26) UV4.D11 ; UV3.G13 v3(60.26,101.66) UV3.H12 ; UV4.L11 v3(86.6,100.86) ; UV3.F12 v3(61.06,100.06) ; UV3.D14 v3(58.49,98.86) ; UV4.E10 v3(85.63,106.06) ; v3(70.21,127.27) 70.66,127.27 UV1.H16 ; UV4.N10 v3(85.8,99.26) ; UV3.T3 v3(67.46,108.06) ; UV3.G2 v3(68.26,101.66) UV3.H3 ; v3(58.47,100.48) 59.04,100.48 UV3.F14 ; UV4.M12 v3(87.4,100.06) ; UV3.M1 v3(70.01,105.26) ; UV3.L4 v3(67.46,104.06) ; UV6.P2 v3(68.26,99.26) UV3.D3 ; UV4.N5 v3(82.6,100.06) ; UV5.J1 v3(79.4,102.46) ; UV4.C5 v3(81.8,108.06) ; v3(73.79,127.94) 73.24,127.4 UV1.H19 ; UV4.B14 v3(89.98,108.46) ; UV3.P12 v3(60.26,107.26) UV6.D13 ; v3(78.5,97) 78.65,97 78.91,97.26 UV4.T1 ; UV4.H12 v3(88.2,103.26) ; UV4.G14 v3(89.94,104.46) ; UV4.G1 v3(78.6,104.86) ; UV4.M3 v3(80.2,100.06) ; UV4.G2 v3(80.2,104.06) UV4.H3 ; UV3.L11 v3(61.86,104.86) ; UV4.G4 v3(81.8,104.86) ; UV4.L14 v3(89,100.86) UV4.L13 ; UV3.C5 v3(65.86,97.66) ; v3(58.49,101.46) 58.69,101.26 UV3.G14 ; UV1.J23 76.65,128.2 v3(77.04,127.8) 77.38,128.14 UV1.J24 ; UV4.T3 v3(81,97.66) ; UV4.L13 v3(88.2,100.86) ; UV4.L13 UV4.K12 ; UV3.G4 v3(66.66,100.86) ; UV4.P3 v3(80.2,98.46) ; UV4.D3 v3(80.2,107.26) UV5.P2 ; UV3.B12 v3(60.26,96.86) ; UV4.T14 v3(89,96.86) ; UV4.L1 v3(79.4,101.66) UV4.L2 ; UV5.D13 v3(89,98.46) UV4.P14 ; UV3.G11 v3(61.86,100.86) ; UV3.B3 v3(67.46,96.86) ; UV4.T12 v3(87.4,96.86) ; UV4.E5 v3(82.6,105.66) ; UV3.P1 v3(69.99,106.86) ; UV3.L2 v3(69.06,104.06) UV3.L1 ; UV4.K3 v3(80.2,101.66) ; UV3.D1 v3(69.86,99.26) ; UV3.L13 UV3.L14 v3(58.37,104.46) ; UV4.L4 v3(81.8,100.86) ; UV4.B3 v3(80.2,108.06) ; UV3.T14 v3(58.66,108.86) ; UV4.D14 v3(89.94,106.86) ; UV3.P14 v3(58.49,106.86) ; UV4.D1 v3(78.6,107.26) ; UV4.F12 v3(87.4,105.66) ; UV4.R5 v3(81.8,97.66) ; UV3.M3 v3(68.26,105.66) ; UV3.N10 v3(62.66,106.46) ; UV1.H13 68.13,127.4 v3(67.81,127.07) ; UV4.B12 v3(87.4,108.86) ; UV3.M12 v3(60.26,105.66) ; UV3.F3 v3(68.26,100.86) ; UV4.M14 v3(89,100.06) ; UV4.M1 v3(78.46,100.46) ; UV4.P1 v3(78.46,98.86) ; UV4.G13 v3(88.2,104.86) ; UV1.K10 66.18,129.05 v3(65.78,129.45) 65.38,129.05 UV1.K9 ; UV4.B1 v3(78.6,108.86) ; UV3.R10 v3(62.66,108.06) ; UV3.C10 v3(61.86,98.46) ; UV4.F3 v3(80.2,104.86) ; UV3.R5 v3(65.73,107.66) ; UV4.G11 v3(86.6,104.86) ; UV1.K23 76.96,128.62 v3(77.02,128.62) 77.38,128.98 UV1.K24 ; UV3.N5 v3(65.86,105.66) ; UV4.F1 v3(78.6,105.66) ; UV1.J9 65.38,128.22 v3(65.76,128.6) 66.16,128.2 UV1.J10 ; UV4.P11 v3(87.4,98.46) UV4.P12 ; UV4.C10 v3(86.6,107.26) ; UV3.B14 v3(58.49,97.26) ; UV3.F1 v3(69.06,100.86) ; UV3.K3 v3(68.26,103.26) ; UV3.P11 v3(61.86,107.26) ; UV3.D12 v3(61.06,98.46) UV3.D11 ; UV3.K12 v3(60.26,103.26) ; UV3.T1 69.46,108.55 v3(69.8,108.89) ; UV3.M14 v3(58.5,105.26) ; UV3.E5 v3(65.86,100.06) ; UV4.R10 v3(85.8,97.66) ; UV3.E10 v3(62.66,99.26) ; UV3.B1 v3(69.86,97.66) ; UV3.G1 v3(69.06,101.66) ; UV3.T12 v3(60.26,108.86) ; UV4.F14 v3(89.94,105.26) ; UV3.P3 v3(68.26,107.26)
  BOTTOM w0.3: v3(67.78,129.1) 67.08,129.8 UV1.L11
  BOTTOM w0.305: UV1.L12 68.02,129.8 v3(68.52,130.29) 68.98,129.83 UV1.L13 ; UV1.L20 UV1.L21 UV1.L22 75.78,129.54 v3(76.11,129.21)
  BOTTOM w0.508: CV156.1 70.81,94.8 v3(71.06,95.05) ; v3(57.52,110.75) 57.52,110.48 CV354.1 RV197.1 ; RV195.1 CV352.1 v3(59.55,110.66) ; CV139.1 CV138.1 91.13,104.96 v3(91.13,104.96) ; CV209.1 RV119.1 v3(64.21,94.99) ; v3(66.36,94.99) CV180.1 CV189.1 CV145.1 ; CV179.1 v3(91.06,96.07) ; CV176.1 v3(91.12,97.85) ; CV185.1 CV181.1 v3(58.55,110.73) ; CV143.1 CV142.1 v3(88.84,94.99) ; CV150.1 CV147.1 v3(71.69,94.99) ; v3(86.74,95.11) 87.06,94.79 CV151.1 ; RV129.1 CV323.1 82.92,94.92 v3(82.8,95.05) ; CV130.1 v3(91.06,96.96) ; CV177.1 v3(91.12,98.73) ; v3(70.23,95.11) 69.92,94.8 CV144.1 CV146.1 ; CV152.1 v3(91.12,99.62) ; CV328.1 RV183.1 93.44,103.17 v3(93.96,103.69)
  vias: v2(85.29,119.9) v3(64.93,128.6) v3(82.2,91.9) v3(82.2,91.32) v3(82.7,90.73) v3(82.78,91.9) v3(82.78,91.32) v3(83.56,91.9) v3(83.56,91.32) v3(83.61,90.16) v3(84.18,91.93) v3(84.18,91.34) v3(84.19,90.16) v3(84.5,90.76) v3(84.76,91.93) v3(84.76,91.34) v3(85.08,90.76) v3(86.15,119.82) v3(86.15,119.23)
+1.35V_MEM_GFX_CHG: length 5.1
  TOP w0.102: v1(84.39,87.05) 83.49,87.95 RV182.2
  TOP w0.508: QV11.1 81.79,89.15 82.55,88.38 83.24,88.38 RV182.2
+1.35V_MEN_P: length 47.1
  TOP w0.203: PU200.5 177.52,84.05 v3(177.88,83.69)
  TOP w0.254: PC211.2 PR204.2 PC214.1 175.94,79.65 169.48,79.65 165.28,75.44 160.96,75.44 v3(159.83,76.57)
  IN3 w1.016: 171.9,84.32 171.9,81.54 165.53,75.17 164.53,75.17 163.39,74.03
  BOTTOM w0.254: v3(177.88,83.69) 177.13,84.45 176.02,84.45 175.86,84.28 172.62,84.28 v3(171.32,85.58)
  vias: v1(157.61,71.81) v3(171.32,86.16) v4(159.13,73.97) v4(159.13,73.33) v4(159.13,72.7) v4(159.13,71.43) v4(159.13,70.79) v4(159.13,70.16) v4(159.13,69.52) v4(159.77,73.97) v4(159.77,73.33) v4(159.77,72.7) v4(159.77,71.43) v4(159.77,70.79) v4(159.77,70.16) v4(159.77,69.52) v4(161.04,73.97) v4(161.04,73.33) v4(161.04,72.7) v4(161.04,71.43) v4(161.04,70.79) v4(161.04,70.16) v4(161.67,73.97) v4(161.67,73.33) v4(161.67,72.7) v4(161.67,71.43) v4(161.67,70.79) v4(161.67,70.16) v4(162.31,73.97) v4(162.31,73.33) v4(162.31,72.7) v4(162.31,71.43) v4(162.31,70.79) v4(162.31,70.16)
+3.3V_ALW: length 460.4
  TOP w0.102: v4(105.54,128.51) v2(105.54,129.21)
  TOP w0.254: RP19.8 167.02,63.02 166.63,62.63 ; RP18.3 168.98,58.76 169.32,59.1 169.32,60.25 v3(169.56,60.49)
  TOP w0.305: 230.73,96.51 230.96,96.29 231.46,96.29 231.57,96.4 JAPS1.7
  TOP w0.381: C720.1 198.76,88.27 198.76,89.02 198.52,89.26 U50.5 ; CV87.1 83.81,149.98 UV14.5 ; PC801.2 233.43,83.76 PU804.5
  TOP w0.508: PR895.1 v3(166.26,25.15) ; QV12.3 v3(96.34,115.7) ; v3(214.38,88.57) 213.63,87.82 R1171.1 ; PR720.1 46.99,161.47 v3(46.55,161.91) ; R515.1 163.22,54.14 v3(162.8,54.56) ; R817.1 v3(219.33,73.4) ; v3(162.79,166.98) 163.34,166.98 163.87,166.45 163.87,163.15 163.31,162.59 PR6.1 163.34,161.69 163.34,159.81 162.24,158.71 157.77,158.71 157.38,158.32 157.38,157.41 156.74,156.77 v3(156.74,156.29) ; R800.1 v3(182.83,57.09) ; PR868.2 42.74,148.49 v3(42.03,149.2) ; v3(166.24,60.72) 166.24,62.25 166.63,62.63 ; v3(197.87,88.13) C720.1 ; R932.1 222.68,106.49 v3(222.94,106.75) ; v3(199.85,80.47) 199.94,80.38 R839.1 ; 230.73,96.51 v3(228.41,96.51) ; R1162.1 189.92,98.3 190.18,98.57 v3(190.18,99.05) ; PR209.1 v3(181.98,89.53) ; R796.1 177.01,64.07 v3(177.48,63.6) ; v3(230.65,76.19) PR807.1 230.9,78.54 232.73,78.54 233.36,77.9 R850.1 ; PR300.2 177.7,92.18 177.46,92.41 v3(177.1,92.41) ; v3(169.56,60.49) 173.23,60.49 174.54,61.8 v3(177.48,61.8) ; PU801.5 227.06,86.8 PC805.2 PR810.1 v3(226.19,88.64) ; R937.1 231.48,103.89 v3(231.15,103.56) ; PR119.2 v3(197.26,32.78) ; R51.1 v3(219.33,84.7) ; v3(219.39,75.56) 218.71,76.24 R834.1 ; v3(83.68,150.88) CV87.1 ; v3(234.44,80.69) PR801.1 ; v3(234.88,83.82) PC801.2
  TOP w1.016: 189.65,167.95 v2(189.65,162.99) 189.65,160.01 190.06,159.6 190.06,141.25 191.77,139.54 191.77,133.28 ; 181.42,119.94 185.17,119.94 188.85,123.62 188.85,125.34
  IN1 w1.524: 201.14,98.08 202.12,97.11 205,97.11 205.01,97.12 216.94,97.12 219.52,94.54 220.47,94.54
  IN2 w0.508: v3(42.03,149.2) 46.16,153.33 v3(46.16,156.52) ; v3(166.26,25.15) 169.24,25.15 169.94,25.85 169.94,40.97 170.73,41.76 170.73,54.35 169.39,55.68 163.92,55.68 v3(162.8,54.56)
  IN3 w0.508: v3(83,150.88) 83,150.61 82.69,150.31 81.15,150.31 78.68,147.83 71.93,147.83 71.1,148.67 71.1,149.32 69.74,150.68 68.73,150.68 68.07,151.34 58.87,151.34 58.19,152.01 50.66,152.01 v3(46.16,156.52) ; v3(96.34,115.7) 96.34,118.11 97.98,119.75 97.98,123.82 101.28,127.12 ; v3(182.83,57.09) 181.4,57.09 180.67,57.81 180.67,58.93 v3(180.41,59.2) 178.53,59.2 175.93,56.61 167.24,56.61 165.33,54.7 162.94,54.7 v3(162.8,54.56) ; v3(179.9,134.17) 180.58,134.85 183.05,134.85 184.34,136.15 190.88,136.15 v3(192.97,134.05) ; v3(165.48,166.61) 165.11,166.98 v3(162.79,166.98) ; v3(190.18,99.05) 194.41,99.05 196.06,100.7 198.4,100.7 v3(199.75,99.36) ; v3(166.24,60.72) 166.75,60.21 169.28,60.21 v3(169.56,60.49)
  IN3 w3.048: 172.37,101.59 176.43,101.59 179.2,98.82 179.2,92.57 ; 130.56,150.32 133.85,147.03 136.07,147.03 140.15,142.95 140.15,122.52 145.86,116.8 145.86,111.7 146.73,110.84 ; 107.04,148.9 106.53,148.39 106.49,148.39 102.11,144.01 102.11,130.04
  BOTTOM w0.508: v3(156.74,156.29) 156.74,154.66 R755.2 ; v3(179.9,134.17) 180.06,134.17 180.43,134.54 RH238.1 ; v3(46.16,156.52) 46.04,156.63 46.04,161.4 v3(46.55,161.91) ; v3(165.48,166.61) 167.39,168.52 175.13,168.52 181.23,162.42 185.8,162.42 190.06,166.68 190.06,167.88
  BOTTOM w1.016: 102.31,128.54 101.16,129.7 101.16,132.58 100.14,133.59 100.14,134.23 99.51,134.86 98.62,134.86 97.28,136.2 97.28,140.33 98.62,141.66 98.62,144.64 93.96,149.3 83.8,149.3 83.25,149.85
  vias: v2(187.87,83.18) v3(186.12,83.69) v3(186.12,83.08) v3(186.12,82.5) v3(189.6,168.84) v3(190.18,168.84) v3(191.77,56.63) v3(191.77,56.02) v3(192.91,129.28) v3(192.91,128.67) v3(193.52,129.28) v3(193.52,128.67) v3(195.45,170.17) v3(196.04,170.17) v3(196.61,70.22) v3(197,74.21) v3(200.34,99.61) v3(200.34,98.92) v3(206.66,69.08) v3(207.27,69.08) v3(208.28,92.65) v3(208.28,92.07) v3(208.35,68.76) v3(208.87,92.65) v3(208.87,92.07) v3(209.45,92.65) v3(209.45,92.07) v3(210.03,92.65) v3(220.24,130.56) v3(220.24,129.97) v3(220.24,129.38) v3(220.44,70.32) v3(220.44,69.71) v3(220.85,130.56) v3(220.85,129.97) v3(220.85,129.38) v3(221.05,70.32) v3(221.05,69.71) v3(221.43,130.3) v3(221.43,129.72) v3(221.45,126.29) v3(221.45,125.66) v3(222.06,126.29) v3(222.06,125.66) v3(222.63,94.95) v3(222.63,94.36) v3(222.63,93.78) v3(226.49,114.32) v3(226.51,113.69) v3(227.65,72.76) v3(228.16,73.14) v3(228.16,68.89) v3(228.41,72.57) v3(228.64,69.33) v3(229.05,69.78) v3(233.29,138.79) v3(233.49,74.09) v3(233.49,73.48) v3(233.87,138.79) v3(234.04,74.48) v3(234.04,73.87) v3(234.19,139.31) v3(234.46,138.79) v3(235.04,138.79) v3(244.51,148.64) v3(244.51,148.03) v3(245.1,148.03) v3(247.49,148.14) v3(248.1,148.14) v3(263.06,174.74) v3(263.06,174.16) v3(263.64,174.74) v3(263.64,174.16) v3(264.23,174.74) v3(264.23,174.16) v3(266.23,174.74) v3(266.54,174.23) v3(266.84,174.74) v4(104.27,128.51) v4(104.27,127.88) v4(104.9,128.51) v4(104.9,127.88) v4(105.54,127.88) v4(206.63,57.71) v4(206.63,57.01) v4(207.2,57.39) v4(216.54,52.3) v4(217.2,52.94) v4(217.2,52.3) v4(217.87,53.58) v4(217.87,52.95) v4(217.87,52.31) v4(218.51,53.58) v4(218.51,52.95) v4(218.51,52.31) v4(219.14,53.58) v4(219.14,52.95) v4(219.14,52.31) v4(219.78,53.58) v4(219.78,52.95) v4(219.78,52.31) v4(220.41,53.58) v4(220.41,52.95) v4(220.41,52.31)
+3.3V_ALW2: length 632.3
  TOP w0.203: PU100.3 195.71,38.09
  TOP w0.356: PC814.2 175.82,18.05 PU808.5
  TOP w0.406: PU806.5 190.96,45.24 191.15,45.05 191.7,45.05 PC810.2 ; PR824.2 182.13,47.81 182.13,47.2 182.4,46.93 PU807.5 ; PU805.5 191.79,48.43 192.06,48.15 192.38,48.15 PR819.2
  TOP w0.508: v3(221.81,91.11) 222.07,91.38 PR875.1 ; PR747.1 47.36,160.22 47.66,159.92 v3(47.69,159.92) ; v3(151.75,117.4) 151.75,116.56 153.44,114.87 R909.1 ; R874.2 197.36,77.33 v3(197.25,77.45) ; PC808.2 193.44,45.44 193.85,45.86 193.85,48.26 193.44,48.68 PR819.2 ; PC808.2 PC810.2 ; PC808.2 193.11,44.74 v3(192.6,44.24) ; PR849.1 192.05,40.76 v3(192.05,40.12) PR829.1 ; v3(224.33,138.59) 226.05,138.59 PR726.1 ; PR894.1 165.85,22.29 v3(166.23,22.67) ; v3(173.25,74.73) 172.02,74.73 171.59,74.3 PR808.1 ; PR862.1 v3(42.75,135.23) 42.56,135.04 42.09,135.04 41.28,134.23 PR846.1 ; v3(95.44,93.08) 96,93.08 RV81.2 ; v3(185.51,46.48) PC812.2 PR823.2 183.96,47.64 183.54,48.06 PR824.2 ; R517.1 172.02,51.96 172.35,51.63 v3(172.87,51.63) ; PR864.1 195.78,82.79 v3(195.78,81.64) ; v3(176.65,17.87) PC814.2 ; PR733.1 v3(219.9,143.94) ; PR816.2 114.62,154.43 v3(114.57,154.49) ; v4(195.37,37.33) 195.04,37 PR103.1 194.71,38.08 PC114.2 195.71,38.09
  IN1 w0.508: v3(195.78,81.64) 195.08,81.64 193.83,80.39 193.83,79.45 v3(193.27,78.89)
  IN2 w0.508: v3(172.87,51.63) 172.02,50.79 172.02,39.46 170.75,38.19 170.75,24.87 168.56,22.67 v3(166.23,22.67) ; v3(151.75,117.4) 149.93,119.22 149.93,136.5 149.51,136.92 149.51,148.54 147.39,150.65 140.85,150.65 138.7,152.81 137.13,152.81 136.25,153.69 131.31,153.69 129.95,152.33 122.05,152.33 119.25,155.12 115.89,155.12 115.25,154.49 v3(114.57,154.49) 114.57,154.61 113.93,155.25 105.09,155.25 101.92,152.07 92.45,152.07 89.62,154.9 75.87,154.9 73.48,152.52 67.2,152.52 66.45,153.26 52.03,153.26 47.38,157.91 47.38,159.61 v3(47.69,159.92) ; v3(183.48,105.84) 183.48,111.23 182.67,112.04 182.67,112.99 183.41,113.74 183.41,120.23 179.71,123.94 v3(179.71,124.53) ; v4(195.37,37.33) 193.79,37.33 192.05,39.07 v3(192.05,40.12) 192.05,43.69 v3(192.6,44.24) 190.86,45.98 186.02,45.98 v3(185.51,46.48)
  IN3 w0.508: v3(195.78,81.64) 195.92,81.78 200.62,81.78 201.47,82.63 201.47,83.45 202.85,84.83 203.41,84.83 203.51,84.92 203.51,84.92 206.1,87.52 216,87.52 216.35,87.18 220.79,87.18 221.81,88.19 v3(221.81,91.11) ; v3(166.23,22.67) 167.84,21.06 173.46,21.06 v3(176.65,17.87) ; v3(185.51,46.48) 184.4,46.48 182.32,48.57 180.15,48.57 177.67,51.04 175.2,51.04 174.61,51.63 v3(172.87,51.63) ; v3(151.75,117.4) 151.75,117.4 157.07,112.08 162.34,112.08 163.79,110.63 165.97,110.63 168.78,107.82 178.76,107.82 180.74,105.84 v3(183.48,105.84) 196.88,105.84 197.47,105.25 206.47,105.25 206.59,105.12 223.37,105.12 v3(223.39,105.15) ; v3(193.27,78.89) 190.28,78.89 190.06,78.67 183.7,78.67 181.31,76.28 179.8,76.28 178.25,74.73 v3(173.25,74.73)
  IN4 w0.508: v3(42.75,135.23) 42.75,133.67 44.9,131.52 46.37,131.52 48.73,129.16 48.73,103.83 53.72,98.83 53.72,95.56 56.07,93.21 66.66,93.21 68.61,91.26 80.94,91.26 83.12,89.08 86.74,89.08 91.12,93.46 95.06,93.46 v3(95.44,93.08) ; v3(221.81,91.11) 221.81,96.6 222.68,97.47 222.68,104.43 v3(223.39,105.15) 223.84,105.59 223.84,110.23 222.67,111.39 222.67,123.05 223.27,123.64 223.27,134.04 224.33,135.11 v3(224.33,138.59) 224.33,139.51 v3(219.9,143.94) ; v3(173.25,74.73) 173.09,74.73 172.24,73.88 172.24,52.26 v3(172.87,51.63)
  BOTTOM w0.381: CH11.1 179.01,124.86 179.27,125.12 UH2.5
  BOTTOM w0.508: v3(179.71,124.53) CH11.1 ; v3(42.75,135.23) 43.83,136.31 43.83,147.84 46.42,150.43 46.42,151.06 v1(47.21,151.85) 47.89,152.53 47.89,158.61 47.69,158.82 v3(47.69,159.92) ; v3(193.27,78.89) 193.6,78.89 195.05,77.45 v3(197.25,77.45)
+3.3V_ALW_5048: length 68.8
  TOP w0.279: C707.1 184.62,59.61 U46.A54 ; U46.A43 179.98,66.56 179.83,66.41 179.07,66.41 178.82,66.16 C710.1 ; C709.1 190.32,74.67 190.32,73.97 U46.A17
  TOP w0.305: v3(189.74,66.02) 189.96,65.81 U46.B5 ; v3(184.11,71.74) 183.87,71.99 U46.B30
  TOP w0.508: v3(191.52,75.1) C709.1 ; v3(178.06,65.46) 177.94,65.57 C710.1 ; v3(194.18,66.75) 194.02,66.75 193.54,66.27 C708.1 ; v3(185.8,59.88) 185.29,59.38 C707.1
  IN2 w0.508: v3(184.11,71.74) 184.11,72.27 185.1,73.26 185.1,76.6 184.74,76.97 v3(184.74,77.95) ; v3(185.8,59.88) 182.51,59.88 180.65,61.74 180.65,62.53 180.03,63.15 178.97,63.15 178.4,63.72 178.4,65.12 v3(178.06,65.46)
  IN3 w0.508: v3(191.52,75.1) 189.84,73.42 186.27,73.42 184.59,71.74 v3(184.11,71.74) 184.11,71.97 183.64,72.44 181.74,72.44 180.98,71.68 180.98,70.48 180.43,69.93 178.72,69.93 178.09,69.31 178.09,65.5 v3(178.06,65.46)
  BOTTOM w0.508: v3(191.52,75.1) 191.52,73.19 191.97,72.74 192.85,72.74 v1(194.04,71.54) 194.74,70.84 194.74,68.19 194.39,67.83 194.39,66.96 v3(194.18,66.75) 191.22,66.75 190.5,66.02 v3(189.74,66.02)
+3.3V_ALW_PCH: length 384.9
  TOP w0.254: 169.23,58.13 169.61,58.13 170,58.52 v3(170,58.94) ; 169.23,58.13 169.23,57.89 169.1,57.76 RP18.1 ; 169.23,58.13 169.1,58.26 RP18.2 ; RPH12.5 173.12,122.84 v3(173.34,122.61) ; v3(173.34,122.61) 173.12,122.38 RPH15.8 ; v3(173.34,122.61) 173.62,122.34 RPH15.7 ; v3(173.34,122.61) 173.62,122.88 RPH12.6 ; RPH15.6 174.12,122.34 v3(174.44,122.66) ; RPH18.5 205.68,118.16 ; CH45.1 168.61,136.46 169.29,137.13 v3(169.29,137.21) ; v3(174.44,122.66) 174.12,122.98 RPH12.7 ; v3(174.44,122.66) 174.62,122.84 RPH12.8 ; v3(166.17,63.69) 166.34,63.52 RP19.7
  TOP w0.305: JAPS1.1 230.69,93.4
  TOP w0.381: v3(169.23,122.48) 169.74,122.99 169.74,125.17 169.19,125.72 169.19,127.56 169.17,127.58 169.17,128.13
  TOP w0.457: CH43.1 168.58,137.98 v3(168.63,138.03)
  TOP w0.508: 230.69,93.4 227.77,93.4 v3(225.15,96.01) ; v3(179.51,116.39) 179.51,116.83 R1624.2 ; 205.68,118.16 206.53,119.01 206.53,125.52 v3(205.22,126.82) ; RH46.1 166.19,118.89 v3(166.12,118.96) ; CH51.1 163.83,146.21 163.83,147.68 v3(163.49,148.02) ; RH73.1 RH222.2 RH170.1 173.48,116.67 v3(173.8,116.67) 173.98,116.67 174.36,117.05 R1622.2
  IN1 w0.508: v3(173.37,78.66) 173.37,77 171.29,74.91 171.29,61.25 170,59.97 v3(170,58.94) 170,55.9 169.17,55.08 v3(169.17,52.89) ; v3(169.23,122.48) 169.93,122.48 170.5,123.05 172.9,123.05 v3(173.34,122.61) ; v3(179.71,105.12) 179.83,105.23 199.89,105.23 203.71,101.41 v3(203.71,100.89) 204.72,99.88 v3(210.31,99.88) 219.39,99.88 223.25,96.01 v3(225.15,96.01)
  IN2 w0.508: v3(174.44,122.66) 175.2,123.42 v3(175.2,124.89) ; v3(173.8,116.67) 174.07,116.67 175.6,115.14 175.6,113.26 176.06,112.79 176.06,107.81 178.16,105.72 179.1,105.72 v3(179.71,105.12) 179.71,104.35 179.31,103.95 179.31,94.67 179.25,94.6 179.25,91.96 178.06,90.77 178.06,89.63 178.25,89.44 178.25,87.27 178.68,86.84 178.68,82.81 175.49,79.62 173.86,79.62 173.37,79.12 v3(173.37,78.66) ; v3(169.17,52.89) 168.72,52.44 164.72,52.44 163.7,51.43 v3(163.7,50.79) ; 181.48,139.97 181.48,144.83 180.91,145.41 177.99,145.41 176.98,146.42 172.98,146.42 172.72,146.17 170.94,146.17 169.67,147.44 164.07,147.44 v3(163.49,148.02) ; v3(166.17,63.69) 166.17,62.81 170,58.98 v3(170,58.94)
  IN3 w0.254: v3(169.29,137.21) 169.11,137.39 168.49,137.39 168.1,137.79 165.23,137.79 164.65,138.36 v3(164.65,140.47)
  IN3 w0.508: v3(166.12,118.96) 166.3,118.96 168.16,117.1 169.16,117.1 169.31,117.25 172.06,117.25 172.65,116.67 v3(173.8,116.67) 174.7,116.67 175.07,116.3 177.38,116.3 177.92,115.75 179.26,115.75 179.51,116 v3(179.51,116.39) ; v3(163.7,50.79) 162.04,49.12 157.71,49.12 155.83,47.23 113.22,47.23 105.48,54.98 102.11,54.98 100.92,53.79 92.95,53.79 92.36,54.38 v3(92.36,55.45)
  IN4 w0.508: v3(92.36,55.45) 92.36,59.13 94.81,61.59 94.81,78.92 v3(97.73,81.84)
  BOTTOM w0.254: UH1.AJ30 164.65,140.37 v3(164.65,140.47) 164.65,140.55 UH1.AJ32 ; UH1.A26 176.17,138.57 v3(176.28,138.67)
  BOTTOM w0.279: JXDP2.44 203.42,99.88 CH2.1 ; JXDP2.43 v3(210.31,99.88)
  BOTTOM w0.457: 174.42,122.66 174.42,122.66 v3(174.44,122.66)
  BOTTOM w0.508: 174.42,122.66 174.37,122.61 v3(173.34,122.61) 173.34,123.03 RH78.1 ; v3(185.31,135.46) 185.02,135.46 184.33,136.15 184.33,136.18 ; v3(175.2,124.89) 175.39,124.7 RH75.1 ; RH237.1 183.9,135.76 184.33,136.18 ; RC11.1 97.27,79.8 97.73,80.25 v3(97.73,81.84) ; v3(203.71,100.89) 203.28,100.46 CH2.1 ; 184.33,136.18 RH35.1
  BOTTOM w1.016: 205.87,126.23 206.25,125.85 216.09,125.85 ; 188.85,130.17 201.88,130.17 204.55,127.5
  vias: v2(187.54,128.31) v3(166.12,122.43) v3(169.26,138.85) v3(185.15,127.31) v3(185.74,127.31) v3(187.96,130.3) v3(187.96,129.71) v3(217.62,125.91) v3(218.2,125.91)
+3.3V_ALW_PCH_JTAG: length 7.5
  TOP w0.102: RH50.1 167.47,120.88 v2(167.67,121.08)
  TOP w0.508: v3(164.81,122.52) 164.72,122.61 RH52.1 ; RH46.2 165.66,119.66 v3(165.14,120.18) 165.55,120.59 RH48.1 RH50.1
  IN2 w0.508: v3(165.14,120.18) 165.14,121.2 164.81,121.53 v3(164.81,122.52)
+3.3V_ALW_VTR: length 72.8
  TOP w0.279: U51.A11 210.93,72.8 210.76,72.63 210.76,71.82 C774.1 ; U51.A41 v1(209.43,85.65) 209.43,86.6 C776.1 ; C777.1 217.74,79.54 U51.A26 ; v3(202.36,82.65) 202.31,82.6 202.31,81.59 202.67,81.23 203.58,81.23 203.76,81.04 U51.A52
  TOP w0.305: v3(206.56,74.92) 206.68,74.8 U51.B3 ; U51.B35 213.68,83.68 214.36,84.37 v3(214.36,85.08) C780.1
  TOP w0.508: C777.1 217.79,79.29 217.3,78.79 v3(217.11,78.79) ; v3(210.19,86.29) 210.19,86.35 209.74,86.79 C776.1 ; v3(202.36,82.65) 202.01,82.65 201.44,83.23 C781.1
  IN2 w0.508: v3(206.56,74.92) 206.56,74.53 206.31,74.29 205.69,74.29 205.3,74.67 205.3,75.53 205.12,75.71 205.12,76.81 204.15,77.78 202.15,77.78 201.93,77.99 201.93,82.22 v3(202.36,82.65)
  IN3 w0.508: 210.54,72.89 211.05,73.4 215.46,73.4 217.68,75.62 217.68,78.22 v3(217.11,78.79) ; 210.54,72.89 210.54,71.84 211.82,70.55 v3(212.47,70.55) ; 210.54,72.89 209.84,73.59 207.33,73.59 206.56,74.35 v3(206.56,74.92) ; v3(214.36,85.08) 214.36,85.51 213.59,86.29 v3(210.19,86.29) 209.6,86.87 206.36,86.87 203.68,84.19 203.28,84.19 202.36,83.28 v3(202.36,82.65)
  IN4 w0.508: v3(218.82,70.32) 218.59,70.55 v3(212.47,70.55)
+3.3V_CARD: length 34.5
  TOP w0.102: 232.16,65.69 232.11,65.64 231.56,65.64 v2(231.42,65.5)
  TOP w0.279: U41.3 234.63,65.95 234.3,66.28 233.68,66.28
  IN2 w1.524: 231.33,65.46 229.11,65.46 227.2,63.55 227.2,57.77 223.27,53.83 223.27,38.47
  vias: v3(223.9,36.13) v3(223.9,35.55) v3(223.9,34.92) v3(232.54,65.97) v3(232.54,65.36) v3(233.05,65.65)
+3.3V_CARDAUX: length 43.5
  TOP w0.102: v2(220.5,34.36) 220.93,34.79 v3(220.98,34.79)
  TOP w0.254: C642.1 235.63,59.39 U41.15 ; JEXP1.16 224.28,33.65 224.1,33.84 223.47,33.84 C646.1
  TOP w0.508: v3(236.98,59.74) C643.1 235.98,59.05 C642.1 ; C646.1 223.28,34.27 222.76,34.79 v3(220.98,34.79)
  IN1 w0.508: v3(220.98,34.79) 221.6,34.79 222.43,35.61 222.43,36.86 223.74,38.17 223.74,50.93 230.14,57.33 234.57,57.33 v3(236.98,59.74)
+3.3V_LAN: length 211.2
  TOP w0.254: v3(249.76,176.4) U32.8 ; v3(245.87,176.58) 246.26,176.97 U32.1 ; v3(247.76,176.37) U32.4 ; C473.1 249.99,182.37 250.26,182.11 U32.30 ; U32.21 255.26,179.87 255.46,180.08 255.89,180.08 256.26,179.71 C472.1 ; C474.1 244.5,179.64 244.73,179.87 U32.39 ; U32.14 252.76,176.94 253.11,176.58 v3(253.11,176.39)
  TOP w0.381: U15.5 260.48,174.63 C478.1
  TOP w0.508: v3(261.57,175.35) 261.57,175.2 261.06,174.69 C478.1 ; v3(244.03,180.33) 244.03,179.71 C474.1 ; R546.1 R545.1 234.13,162.68 v3(233.81,162.99) ; R553.1 246.73,157.41 v3(247.22,156.91) ; C472.1 256.59,179.82 v3(257.11,179.82) ; v3(249.37,183.44) C473.1 ; RH174.1 RH175.1 169.93,112.32 171.12,111.13 177.9,111.13 178.08,110.95 181.81,110.95 184.01,113.15 184.34,113.15 185.79,114.59 v3(186.56,114.59)
  IN1 w0.254: v3(244.03,180.33) 243.52,180.84 243.52,205.82 243.91,206.2 JLOM1.9
  IN2 w0.254: v3(267.27,207.13) 267.27,188.97 263.27,184.97 263.27,179.19 261.57,177.49 v3(261.57,175.35)
  IN3 w0.508: v3(233.81,162.99) 233.81,164.96 234.57,165.73 234.57,166.82 238.3,170.56 246.43,170.56 ; v3(186.56,114.59) 187.13,114.02 199.15,114.02 199.73,114.61 207.72,114.61 208.48,113.85 218.39,113.85 222.21,117.66 226.54,117.66 v3(227.71,118.83)
  IN4 w0.508: v3(247.83,151.82) 247.83,151.44 247.44,151.05 244.35,151.05 234.1,140.8 229.21,140.8 227.71,139.3 v3(227.71,118.83)
  BOTTOM w0.508: v3(244.03,180.33) 243.91,180.46 C481.1
  vias: v2(249.07,151.3) v3(246.56,159.91) v3(247.08,160.2) v3(248.45,151.83) v3(249.67,169.73) v3(250.34,169.72) v3(251,169.73)
+3.3V_LAN_OUT: length 3.5
  TOP w0.203: v3(236.35,164.44) 236.39,164.48 U31.29 ; v3(241.68,168.29) 241.86,168.11 241.86,167.74 241.62,167.51 U31.15 ; v3(240.02,167.81) U31.19
  vias: v1(236.98,163.38) v3(244.1,162.98) v3(247.3,160.8) v3(247.78,161.19)
+3.3V_M: length 127.5
  TOP w0.254: v3(165.76,132.67) 165.61,132.67 165.2,132.27 165.2,130.13 165.52,129.81 165.91,129.81
  TOP w0.305: JSPI1.16 212.86,131 213.58,130.29 RH185.1
  TOP w0.508: v3(212.05,120.82) 211.84,121.03 v2(211.84,121.71) 211.84,127.12 214.62,129.9 RH185.1
  IN3 w0.508: v3(166.64,127.37) 168.66,127.37 169.23,126.8 169.23,125.91 170.54,124.6 174.27,124.6 174.84,124.03 175.64,124.03 176.04,124.44 178.57,124.44 180.74,122.27 185.21,122.27 186.32,123.38 190.39,123.38 192.09,121.68 200.69,121.68 201.3,122.29 207.49,122.29 208.41,121.38 211.49,121.38 v3(212.05,120.82)
  IN4 w0.508: v3(212.05,120.82) 212.64,120.23 216.63,120.23 218.33,118.53 218.33,116.36 219,115.68 219,101.29 219.9,100.39 219.9,91.43 220.18,91.15 220.18,76.79 v3(219.71,76.32)
  BOTTOM w0.254: UH1.AD12 165.9,132.67 v3(165.76,132.67)
  BOTTOM w0.508: 224.03,69.65 224.03,70.48 222.8,71.71 222.8,74.02 220.5,76.32 v3(219.71,76.32)
  vias: v3(224.73,69.78) v3(224.73,69.17) v3(224.73,68.56)
+3.3V_OZ_IO_LDO: length 5.8
  TOP w0.102: v1(192.66,20.51) 191.7,21.48 C800.2
  TOP w0.203: U38.25 189.81,24.46 190.02,24.25 190.02,23.97
  TOP w0.508: C800.2 191.7,22.77 C566.2 191.39,23.1 190.88,23.1 190.02,23.97
+3.3V_PCIE_FLASH: length 0.9
  TOP w0.508: v3(276.2,173.47) C624.2
  vias: v2(283.62,165.79) v3(266.96,177.6) v3(267.27,178.17) v3(267.57,177.6) v3(275.72,173.09) v3(276.8,186.24) v3(277.43,186.24) v3(278.96,163.26) v3(278.96,162.68) v3(283.85,166.36) v3(284.46,166.36)
+3.3V_PCIE_WWAN: length 0.6
  TOP w0.102: v3(270.38,190.05) v2(270.38,190.6)
  vias: v3(260.44,182.39) v3(260.44,181.78) v3(264.73,183.63) v3(264.73,183.02) v3(264.73,182.41) v3(264.73,181.78) v3(270.38,189.41) v3(271.02,190.05) v3(271.02,189.41) v3(275.3,200.46) v3(275.3,199.85) v3(275.3,199.24) v3(275.73,177.35) v3(275.91,200.46) v3(275.91,199.85) v3(275.91,199.24) v3(276.23,177.72) v3(282.45,193.86)
+3.3V_RTC_LDO: length 162.9
  TOP w0.508: PD3.3 239.52,154.28 239.52,153.03 239.78,152.77 239.78,152.01 239.87,151.92 v1(239.87,146.93) 239.87,144.66 245.57,138.96 245.57,131.17 v3(245.53,131.13) ; PR103.2 v4(193.11,37)
  IN3 w0.508: v4(193.11,37) 193.11,38.34 194.06,39.3 194.06,48.69 191.96,50.79 191.96,53.84 192.38,54.26 192.38,57.11 194.06,58.79 196.79,58.79 197.36,59.36 218.06,59.36 218.82,60.12 224.56,60.12 232.03,67.6 232.03,68.94 236.44,73.35 236.44,84.14 236.07,84.5 236.07,87.2 234.57,88.7 234.57,101.25 245.53,112.21 v3(245.53,131.13)
+3.3V_RUN: length 313.4
  TOP w0.203: C31.1 22.15,196.98 21.38,197.75 21.38,198 21.29,198.09 U19.11 ; 182.21,23.84 182.66,24.29 182.66,24.6 182.93,24.86 U38.11 ; 13.99,198.79 14.63,199.44 15.07,199.44 15.22,199.29 U19.37 ; U38.42 186.59,30.39 186.12,30.85 186.12,31.35 C581.1
  TOP w0.254: C1503.2 183.66,22.64 184.19,23.17 U38.13 ; 208.96,147.59 208.81,147.73 208.64,147.73 208.46,147.55 RP20.2 ; 208.96,147.59 208.96,148 v3(209.27,148.31) ; 208.96,147.59 RP20.1 ; v3(158.02,122.23) 158.02,122.32 158.38,122.68 RPH16.6 ; RPH14.8 162.36,122.66 162.1,122.41 v3(162.1,122.29) 161.86,122.54 RPH14.7 ; RPH14.6 161.36,122.61 160.97,122.23 v3(160.78,122.23) 160.86,122.3 RPH14.5 ; v3(264.92,165.15) 264.66,164.89 R1099.1 ; RP17.1 214.39,91.56 v3(214.82,91.99) ; RPH16.8 159.38,122.67 159.51,122.53 159.51,122.29 v3(159.45,122.23) 159.26,122.23 159.11,122.38 159.11,122.42 158.88,122.65 RPH16.7 ; RPH18.6 205.24,118.66 v3(205.45,118.87) 205.16,119.16 RPH18.7
  TOP w0.279: U41.4 234.13,65.7 v3(234.06,65.78)
  TOP w0.305: C51.1 43.75,96.14 43.77,96.13 JUSH1.8 ; QH4.2 176.72,115.62 v3(176.91,115.43)
  TOP w0.356: v3(178.82,116.45) 178.82,115.88 178.56,115.62 QH4.5
  TOP w0.381: U20.14 171.03,158.34 170.71,158.65 170.71,159.53 C356.1 ; CH12.1 162.88,118.85 162.44,118.85 162.18,119.12 UH3.5 ; C366.1 174.94,153.58 174.94,154.17 174.67,154.44 U23.14
  TOP w0.406: C725.1 214.56,157.01 214.93,157.39 U54.5
  TOP w0.508: R1700.1 R894.1 184.29,18.74 v3(183.76,18.74) ; R502.1 v3(84.32,47.16) ; R508.1 84.77,36.14 v3(85.41,36.14) ; v3(175.07,152.45) 175.07,152.72 C366.1 ; v3(187.59,97.53) 187.94,97.53 188.22,97.81 R1161.1 ; v3(151.79,128.25) 151.79,127.57 152.29,127.08 RH331.1 ; C356.1 170.44,159.69 v3(169.86,159.12) ; 182.21,23.84 182.21,23.57 181.17,22.53 C1501.2 ; R416.1 R415.1 173.24,159.2 v3(172.91,158.87) ; QV5.2 99.19,95.03 102.06,95.03 102.74,94.35 102.74,93.65 v3(102.81,93.59) ; C51.1 44.32,97.07 44.83,97.58 44.83,99.01 45.61,99.79 v3(47.69,99.79) ; v3(23.86,196.31) 23.39,196.78 22.99,196.78 22.78,196.98 C31.1 ; v3(164.72,132.73) 164.8,132.82 164.8,133.3 CH10.1 164.06,133.36 RH34.1 ; RD12.2 153.43,20.59 v3(153.49,20.65) 152.75,21.39 151.96,21.39 151.77,21.58 CD43.1 CD44.1 ; v3(186.69,31.04) 186.63,31.11 C581.1 ; v3(11.75,198.17) R85.1 ; R501.1 v3(88.22,47.31) ; v3(26.86,197.16) R65.1 ; v3(105.54,113.99) 105.72,114.18 RC52.1 ; v3(211.46,156.14) 212.33,157.01 C725.1 ; v3(183.2,20.37) 183.2,20.02 C1504.2 183.91,19.87 183.91,21.15 C1503.2 ; v3(172.47,147.88) 171.83,147.88 171.26,147.31 RH256.1 RH255.1 ; v3(26.73,199.89) R80.1 ; v3(169.95,140.46) 169.95,140.26 169.54,139.85 CH48.1 ; v3(139.77,148.64) 139.89,148.77 139.89,153.09 138.43,154.55 ; CH49.1 171.53,137.47 171.21,137.8 v3(171.21,138.14) ; 13.99,198.79 C32.1 v3(13.99,198.11) ; v3(164,140.46) 163.03,140.46 CH27.1 ; PR627.1 v3(19.81,143.17) 20.54,143.17 PR691.2 ; v3(26.86,198.05) R79.1 ; R772.1 183.66,58.28 v3(183.66,57.75) ; RH90.1 RH224.1 163.64,120.14 163.9,119.89 v3(163.9,119.88) 163.9,119.43 163.25,118.79 CH12.1 ; v3(82.55,145.85) 82.55,145.72 82.03,145.2 RV33.1 ; v3(26.73,199) R86.1
  TOP w1.524: 78.61,48.12 78.61,56.06 80.77,58.22 81.73,58.22
  IN1 w0.508: v3(15.75,147.18) 15.75,145.24 16.92,144.07 19.37,144.07 19.81,143.63 v3(19.81,143.17) ; v3(102.81,93.59) 103.26,94.04 104.34,94.04 106.68,96.38 106.68,99.62 105.75,100.55 105.75,113.78 v3(105.54,113.99)
  IN1 w0.762: 9.65,183.19 9.21,182.74 7.62,182.74 5.4,180.52
  IN2 w0.508: v3(153.49,20.65) 153.49,23.18 157.61,27.3 157.61,36.25 v3(156.48,37.38)
  IN2 w1.524: 233.81,67.43 232.6,67.43 231.36,68.67 231.36,72.28 227.33,76.32 225.3,76.32 223.75,77.86 223.75,81.8 223.39,82.16
  IN3 w1.016: 232.28,166.63 224.77,166.63 223.76,165.62 221.08,165.62 ; 278.96,164.26 278.45,164.26 277.24,165.47 273.56,165.47 272.97,166.06 271.53,166.06 270.11,164.65 266.07,164.65 263.46,162.04 263.46,157.28
  IN4 w0.508: v3(47.69,99.79) 47.69,96.37 54.34,89.72 v3(57.34,89.72) ; v3(165.33,133.97) 165.41,134.05 165.41,134.24 165.75,134.58 166.66,134.58 167.32,135.25 167.32,136.01 167.83,136.52 170.18,136.52 170.94,137.28 ; v3(164,140.46) 164,139.96 164.53,139.43 169.35,139.43 169.48,139.56
  BOTTOM w0.203: v3(134.73,158.17) U6.29 ; v3(132.72,154.74) 132.76,154.7 U6.23 ; v3(137.92,155.18) 137.83,155.1 U6.4 ; v3(136.39,158.17) 135.93,157.71 U6.32
  BOTTOM w0.254: UH1.L24 171.21,137.93 v3(171.21,138.14) ; UH1.AK30 164,140.39 v3(164,140.46) 163.67,140.79 UH1.AK32 ; v3(171.25,141.1) 171.27,141.09 171.27,140.92 170.94,140.59 UH1.M31 ; UH1.R32 169.62,140.79 v3(169.95,140.46) 169.95,140.39 UH1.R30
  BOTTOM w0.305: R160.1 202.2,172.44 203.25,171.39 203.25,170.98 203.54,170.7 JLVDS1.37
  BOTTOM w0.356: v3(156.48,37.38) 153.9,37.38 153.24,36.72 JDIMM1.199 ; JDIMM2.199 153.24,20.9 v3(153.49,20.65)
  BOTTOM w0.381: CC21.1 103.03,94.57 102.62,94.99 102.62,95.3 102.84,95.53 UC2.5 ; UC3.5 162.74,116.94 162.75,116.96 CH65.1
  BOTTOM w0.508: v3(157.74,119.37) 157.91,119.19 RH93.1 ; 265.43,160.52 265.56,160.65 265.56,164.51 264.92,165.14 v3(264.92,165.15) ; 265.43,160.52 264.03,159.12 264.03,158.3 ; 265.43,160.52 269.88,160.52 270.51,159.88 R1082.1 R1100.1 R1081.1 ; v3(163.9,119.88) 163.9,120.5 RH224.1 ; v3(163.25,116.32) CH65.1 ; v3(102.81,93.59) 103.03,93.82 CC21.1 ; v3(26.61,205.6) 26.17,206.04 R73.1 ; v3(204.54,173.22) 204.85,172.9 R159.1 ; R30.1 R38.1 57.22,89.59 v3(57.34,89.72) ; v3(202.2,173.21) R160.1 ; v3(157.74,120.07) 157.61,120.2 RH37.1 RH228.2 ; RH225.2 162.1,122.65 v3(162.1,122.29) ; PR692.1 v3(101.73,120.51) ; RH328.1 182.21,132.58 v3(182.27,132.64) ; PR519.2 123.83,149.47 v3(124.07,149.72) ; RH89.1 RH88.1 174.93,152.31 v3(175.07,152.45) ; v3(21.02,202.49) R72.1
  BOTTOM w1.524: 222.51,85.46 221.29,85.46 215.83,90.92
  vias: v2(137.57,156.77) v3(3.35,180.27) v3(3.94,180.27) v3(9.4,183.95) v3(9.98,183.95) v3(83.44,58.87) v3(84.02,58.87) v3(84.02,58.28) v3(89.03,56.15) v3(89.03,55.55) v3(89.03,54.92) v3(146.69,125.47) v3(146.69,124.86) v3(146.69,124.25) v3(156.48,37.99) v3(175.01,155.41) v3(175.59,155.41) v3(176.18,155.41) v3(176.85,138.61) v3(177.46,138.61) v3(177.85,22.06) v3(178.44,22.06) v3(182.31,133.25) v3(186.17,138.6) v3(186.78,138.6) v3(188.2,21.14) v3(188.2,20.55) v3(188.66,78.02) v3(188.67,77.43) v3(190.76,167.57) v3(191.26,167.88) v3(191.26,167.27) v3(201.59,173.22) v3(203.65,173.22) v3(207.65,93.65) v3(208.23,93.65) v3(208.81,93.65) v3(209.36,120.01) v3(209.97,120.01) v3(217.55,130.29) v3(217.55,129.68) v3(217.55,129.07) v3(218.12,130.56) v3(218.12,129.95) v3(218.12,129.34) v3(218.63,130.27) v3(218.63,129.66) v3(220.6,166.49) v3(221.18,166.49) v3(222.72,83.05) v3(222.75,84.29) v3(222.75,83.68) v3(232.48,169.66) v3(232.48,168.96) v3(234.95,66.35) v3(235.14,65.78) v3(235.59,66.22) v3(263.97,156.34) v3(263.97,155.76) v3(280.99,163.38) v3(281.57,163.38)
+3.3V_RUN_CARD: length 22
  IN3 w1.016: 188.22,19.68 189.1,19.68 191.58,22.15 194.76,22.15 201.61,29.01 206.31,29.01
  vias: v2(205.27,31.65) v3(186.15,18.8) v3(186.73,18.8) v3(207.68,29.39) v3(207.65,28.69)
+3.3V_RUN_DVDD: length 5.2
  TOP w0.254: v3(267.08,155.76) 267.21,155.76 267.42,155.97 U74.9 ; U74.3 267.44,158.97 267.34,158.87 266.87,158.87 266.36,158.36 266.09,158.36 265.92,158.18 265.9,158.18 C994.1
  TOP w0.508: v3(266.33,157.69) 265.99,157.69 C994.1
  BOTTOM w0.102: v1(268,154.73) 268,155.53
+3.3V_RUN_EDP: length 19.1
  IN2 w1.524: 205.04,152.9 203.71,154.23 202.89,154.23 201.61,155.51 201.61,157.53 198.88,160.26 198.88,167.25 198.19,167.95 198.06,167.95
  BOTTOM w0.102: v3(196.65,168.33) v1(197.3,168.33)
  vias: v3(195.43,168.33) v3(196.04,168.33) v3(204.66,151.7) v3(205.26,151.7) v3(205.87,151.7)
+3.3V_RUN_FFS: length 14.7
  TOP w0.102: v1(91.95,53.58) 91.76,53.77 90.81,53.77 ; C387.1 90.43,53.01
  TOP w0.254: v3(89.05,53.71) 87.76,53.71 87.03,52.98 U88.8 ; U88.14 80.16,52.98 C388.1 ; U88.7 88.81,52.48 ; v3(83.65,48.19) U88.1
  TOP w0.508: v3(80.14,53.65) C388.1
  vias: v3(89.64,53.71)
+3.3V_RUN_GFX: length 128.7
  TOP w0.508: v3(16.61,147.92) 16.64,147.89 PR604.2 ; PR608.2 17.22,150.14 v3(16.64,150.14) ; RV29.1 82.68,147.06 v3(82.42,146.8) ; PR602.2 v3(16.61,146.83) ; v3(58.74,138.8) 59.36,138.8 RV41.2 ; RV103.1 57.34,134.61 v3(57.31,134.64) ; LV30.1 v3(63.44,142.99)
  IN1 w0.508: v3(91.7,117.78) 91.7,119.23 95.19,122.72 95.19,124.25 93.27,126.16 93.27,126.81 92,128.08 89.14,128.08 88.05,129.17 87.16,129.17 84.84,131.5 84.84,144.39 82.43,146.8 v3(82.42,146.8) ; v3(16.64,150.14) 16.98,150.14 17.35,149.77 17.35,148.66 v3(16.61,147.92) v3(16.61,146.83)
  IN2 w0.508: v3(55.5,130.74) 56.25,131.49 56.25,133.58 v3(57.31,134.64) 58.6,135.93 58.6,137.83 58.74,137.98 v3(58.74,138.8) 62.93,142.99 v3(63.44,142.99) 64.96,144.52 78.93,144.52 81.03,146.61 82.23,146.61 v3(82.42,146.8)
  BOTTOM w0.508: v3(16.61,146.83) v1(18.86,144.58) 19.65,143.79 21.91,143.79 25.4,140.3 26.17,140.3 26.92,139.55 29.45,139.55 30.58,138.42 34.05,138.42 41.5,130.97 54.65,130.97
+3.3V_RUN_GFX_VDDR3: length 13.9
  TOP w0.457: CV62.1 72.02,138.43 v3(72.31,138.15) 72.59,138.43 CV49.1
  TOP w0.508: LV30.2 CV61.1 v1(66.42,142.1) 67.22,142.1 69.19,140.14 69.22,140.14 69.41,139.94 70.3,139.94 70.8,139.44 70.8,138.74 71.11,138.43 CV62.1
  BOTTOM w0.356: UV1.AA17 71.78,137.62 v3(72.31,138.15) ; v3(72.31,138.15) 72.76,138.6 UV1.AB18 ; v3(72.31,138.15) 71.86,138.6 UV1.AB17 ; v3(72.31,138.15) 72.78,137.67 UV1.AA18
+3.3V_RUN_HDD: length 1.6
  TOP w0.102: R1635.1 80.89,44.64 v1(81.03,44.5)
  vias: v3(79.44,45.71) v3(80.11,46.35) v3(80.08,45.71)
+3.3V_RUN_HDD_R:
  vias: v1(83,46.09) v3(83.31,45.33) v3(83.63,45.9) v3(83.92,45.33)
+3.3V_RUN_OZVCC: length 30
  TOP w0.102: v3(177.99,24.49) 177.86,24.49 v1(177.4,24.96)
  TOP w0.203: 191.27,24.73 190.88,24.73 190.67,24.95 190.18,24.95 189.87,25.26 U38.27 ; 182.02,25.45 182.25,25.45 182.46,25.66 U38.9
  TOP w0.508: 191.27,24.73 193.38,24.73 C575.1 193.5,24.69 194.31,24.69 v3(194.95,25.33) ; 182.02,25.45 181.97,25.45 181.52,25 C576.1 180.86,24.5 C577.1 179.07,24.5 L45.1 178,24.51 v3(177.99,24.49)
  IN3 w0.508: v3(194.95,25.33) 194.5,25.33 193.7,24.53 178.02,24.53 v3(177.99,24.49)
