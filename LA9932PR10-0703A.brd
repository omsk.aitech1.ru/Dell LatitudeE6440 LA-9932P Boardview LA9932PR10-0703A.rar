# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_CHASSIS: length 2.6
  BOTTOM w0.102: v1(250.2,203.24) 249.64,202.67 C485.2
GNDA: length 92.6
  TOP w0.102: v3(281.18,149.98) v2(282.3,149.98) ; v3(289.55,150.74) v2(289.97,151.16)
  TOP w0.254: U74.26 275.47,154.97 275.81,154.63 v3(275.88,154.63) ; U74.36 276.52,159.97 276.79,159.7 v3(276.93,159.7)
  TOP w0.432: v3(283.62,152.94) 283.62,152.7 283.17,152.25 Q330.1
  TOP w0.508: v3(286.64,160.9) 286.01,160.26 D81.1 ; R1642.2 274.59,150.49 C963.2 274,150.84 v3(274.32,151.16) ; v3(285.18,151.12) 285.18,151.53 D82.1 ; C1556.2 v3(286.31,155.39) ; R1088.2 v3(284.65,156) ; C1557.2 v3(286.6,156.91) ; R5.1 284.66,161.71 v3(284.16,161.22)
  GND1 w0.203: JHP1.8 296.59,166.92 ; JHP1.8 297.72,166.92 ; JHP1.8 295.46,166.92 ; JHP1.8 296.59,165.48 ; JHP1.8 297.72,165.48 ; JHP1.8 297.72,166.2 ; JHP1.8 295.46,166.2 ; JHP1.8 295.46,165.48 ; 294.46,156.28 JHP1.7 ; JHP1.7 295.59,157.72 ; JHP1.7 296.72,156.28 ; JHP1.7 294.46,157.72 ; JHP1.7 294.46,157 ; JHP1.7 296.72,157.72 ; JHP1.7 296.72,157 ; JHP1.7 295.59,156.28
  GND2 w0.203: 294.46,156.28 JHP1.7 ; JHP1.7 296.72,157.72 ; JHP1.7 296.72,156.28 ; JHP1.7 296.72,157 ; JHP1.7 294.46,157.72 ; JHP1.7 295.59,156.28 ; JHP1.7 295.59,157.72 ; JHP1.7 294.46,157 ; JHP1.8 297.72,166.2 ; JHP1.8 295.46,166.92 ; JHP1.8 297.72,166.92 ; JHP1.8 296.59,165.48 ; JHP1.8 295.46,166.2 ; JHP1.8 296.59,166.92 ; JHP1.8 297.72,165.48 ; JHP1.8 295.46,165.48
  VCC w0.203: 295.46,165.48 JHP1.8 ; JHP1.8 295.46,166.92 ; JHP1.8 296.59,165.48 ; JHP1.8 297.72,165.48 ; JHP1.8 297.72,166.2 ; JHP1.8 297.72,166.92 ; JHP1.8 296.59,166.92 ; JHP1.8 295.46,166.2 ; 294.46,157.72 JHP1.7 ; JHP1.7 294.46,157 ; JHP1.7 296.72,156.28 ; JHP1.7 296.72,157.72 ; JHP1.7 296.72,157 ; JHP1.7 295.59,156.28 ; JHP1.7 295.59,157.72 ; JHP1.7 294.46,156.28
  GND3 w0.203: JHP1.8 297.72,166.2 ; JHP1.8 295.46,166.2 ; JHP1.8 297.72,165.48 ; JHP1.8 296.59,166.92 ; JHP1.8 297.72,166.92 ; JHP1.8 296.59,165.48 ; JHP1.8 295.46,165.48 ; JHP1.8 295.46,166.92 ; 295.59,156.28 JHP1.7 ; JHP1.7 294.46,156.28 ; JHP1.7 296.72,156.28 ; JHP1.7 295.59,157.72 ; JHP1.7 296.72,157.72 ; JHP1.7 294.46,157 ; JHP1.7 296.72,157 ; JHP1.7 294.46,157.72
  BOTTOM w0.406: Q106.4 288.7,152.53 289.55,151.68 v3(289.55,150.74)
  BOTTOM w0.432: Q106.1 286.17,151.23 285.98,151.04 285.26,151.04 v3(285.18,151.12)
  BOTTOM w0.508: v3(287.54,155.37) 287.54,154.23 R1676.2 ; v3(293.82,166.12) R15.1
  vias: v2(280.8,156.84) v3(272.42,152.77) v3(272.42,152.19) v3(278.75,158.57) v3(279.36,158.59) v3(280.33,158.02) v3(280.33,157.42) v3(280.54,149.98)
GNDA_CHG:
  vias: v1(52.07,161.53) v3(51.06,163.95) v3(51.06,162.68) v3(51.5,163.31) v3(52.14,163.9) v3(52.14,162.74)
GNDA_GPU_CORE: length 9.4
  TOP w0.102: v1(30.84,143.13) 29.59,143.13 29.58,143.12
  TOP w0.508: PR634.2 v3(20.05,141.54) 20.13,141.47 PR632.2 ; PC617.2 PC618.2 29.15,150.23 v3(28.58,149.66) ; v3(23.24,139.94) PR644.2
  IN2 w0.508: v3(23.24,139.94) 21.66,139.94 v3(20.05,141.54)
  vias: v3(28.07,143.94) v3(28.7,143.94) v4(22.16,149.6) v4(22.16,148.58) v4(22.16,147.56) v4(23.18,149.6) v4(23.18,148.58) v4(23.18,147.56) v4(24.2,149.6) v4(24.2,148.58) v4(24.2,147.56)
VCCPWRGOOD_0_R: length 16.1
  TOP w0.089: v2(114.14,109.9) 114.47,109.56 v3(114.47,109.2)
  BOTTOM w0.089: 114.01,111.73 114.47,111.27 v3(114.47,109.2) JCPU1.AL34
  BOTTOM w0.102: 114.01,111.73 113.48,112.27 113.48,112.9 111.52,114.86 105.36,114.86 RC33.2 RC56.1
VCCSENSE: length 81.5
  TOP w0.102: PC545.1 129.63,143.3 130.41,143.3 131.47,144.36 131.47,147.25 128.52,150.2 123.45,150.2 118.24,144.99 102.68,144.99 99.05,141.35 99.05,140.57 98.59,140.11 98.59,137.82 98.36,137.59 98.36,123.19 v4(103.26,118.3) 104.12,117.44 104.12,116.05 103.78,115.71 103.48,115.71 v3(103.29,115.52) ; PC545.1 128.68,143.64 v3(128.54,143.5) 128.53,143.5 128.13,143.9 127.35,143.9 PC541.2 ; PC545.1 129.55,143.91 130.39,143.91 131,144.52 131,145.47 130.57,145.9 PC520.1 PR537.1
  BOTTOM w0.102: RC91.2 103.02,115.7 103.12,115.7 v3(103.29,115.52) 103.48,115.71 103.53,115.71 RC92.2
VCCSENSE_R: length 14.4
  BOTTOM w0.102: RC92.1 104.98,115.43 v4(110.31,115.43) 111.63,115.43 114.11,112.95 114.11,112.32 115.34,111.08 115.34,109.85 115.23,109.73 JCPU1.AL35
VDD_1.35V: length 9.3
  TOP w0.203: PR203.2 178.82,89.08 v3(177.38,89.08) 177.52,88.94 PU200.11
  TOP w0.254: PC210.1 180.53,90.8 PR203.2 ; PR201.1 v3(175.58,90.62)
  IN2 w0.254: v3(177.38,89.08) 175.85,90.62 v3(175.58,90.62)
  BOTTOM w0.102: v1(178.25,88.45) 177.61,89.08 v3(177.38,89.08)
VDDP_1.35V: length 2.9
  TOP w0.203: PR211.2 176.87,89.41 176.87,88.93 177.12,88.68 PU200.12
  TOP w0.254: PC213.1 178.23,89.7 PR211.2
VSSSENSE: length 77.9
  TOP w0.102: PC546.2 127.14,142.81 127.82,143.49 v3(127.95,143.49) 128.72,142.73 PC545.2 129.63,143.07 130.51,143.07 131.7,144.26 131.7,147.34 128.62,150.43 123.36,150.43 118.14,145.21 102.59,145.21 98.82,141.45 98.82,140.66 98.36,140.2 98.36,137.92 98.13,137.69 98.13,123.1 103.89,117.34 103.89,116.15 103.75,116 103.4,116 v3(103.29,116.11)
  BOTTOM w0.102: RC94.1 102.9,115.93 103.12,115.93 v3(103.29,116.11) 103.46,115.94 103.68,115.94 RC93.2
  BOTTOM w0.18: v3(127.95,143.49) PU500.13
VSSSENSE_R: length 14.9
  BOTTOM w0.102: RC93.1 105.39,115.66 v4(107.25,115.66) 111.72,115.66 114.34,113.05 114.34,112.41 115.57,111.18 115.57,109.85 115.69,109.73 JCPU1.AK35
3301_DSCHRG_FET_GC: length 62.8
  TOP w0.254: PU800.29 36.58,143.73 36.32,143.48 v3(36.32,142.87) ; PR821.2 69.75,150.89 68.58,149.72 66.54,149.72 v1(64,147.19) 60.64,143.83 60.64,141.44 57.53,138.32 57.53,138.14 54.47,135.08 v3(54.47,126.12)
  IN3 w0.254: v3(54.47,126.12) 53.45,126.12 49.53,130.04 49.53,132.59 48.07,134.05 48.07,134.84 47.51,135.4 45.87,135.4 42.6,138.67 41.6,138.67 37.41,142.87 v3(36.32,142.87)
3301_PWRSRC: length 6.4
  TOP w0.254: PR877.1 46.14,140.03 PC819.1 46.04,141.7 v1(45.01,142.73) PU800.15
+ALC3226_CPVEE: length 3.9
  TOP w0.254: U74.34 275.5,158.97 275.74,159.2 276.21,159.2 276.51,158.9 v1(276.51,158.78) 276.51,158.76 277.65,157.62 C965.2
+ALC3226_LDO_CAP: length 3.9
  TOP w0.102: C963.1 273.74,151.62 v1(272.51,151.62)
  TOP w0.254: C963.1 273.08,152.8 273.08,152.87 272.79,153.16 U74.21
+ALC3226_VREF:
  vias: v1(276.38,152.45)
+BATT_SUM:
  vias: v1(86.3,150.1)
+BL_PWR_SRC: length 2.1
  TOP w0.102: C247.1 213.73,169.69 v2(213.37,169.69)
  vias: v3(218.58,168.71) v3(218.59,168.07) v3(219.19,168.71) v3(219.2,168.07)
+CAMERA_VDD: length 10
  BOTTOM w0.102: Q23.1 231.52,166.91 230.39,168.04 v2(229.39,168.04)
  BOTTOM w0.508: Q23.1 232.41,166.16 231.65,165.39 C300.1 231.57,164.89 C299.1 231.57,162.7 231.21,162.34 JCAM1.4
+CAP_LDO: length 6.6
  TOP w0.305: U46.B46 181.65,66.31 181.93,66.59 v3(181.93,66.72)
  TOP w0.508: v3(177.48,67.05) 177.74,67.3 C714.1
  BOTTOM w0.508: v3(181.93,66.72) 180.84,66.72 180.42,66.3 v1(179.45,66.3) 178.23,66.3 v3(177.48,67.05)
+COINCELL: length 3.6
  TOP w0.508: v3(242.13,152.87) PR1.1
  BOTTOM w0.102: v3(242.13,152.87) 242.13,152.39 v1(242.89,151.63)
  BOTTOM w0.508: v3(242.13,152.87) 242.01,152.99 JRTC1.1
+DC_IN: length 314
  TOP w0.102: 14.29,177.68 v2(14.29,178.77) ; 15.77,177.69 15.77,178.51 v2(16.08,178.82) ; v2(12.46,178.64) 12.64,178.64 13.57,177.71
  TOP w0.508: 12.96,177.73 11.18,177.73 10.8,177.35 PQ6.3 ; 12.77,174.3 12.74,174.27 PC8.2 10.02,174.28 PR18.1 ; PR835.1 32.68,139.61 32.45,139.84 32.45,142.89 v3(32.68,143.12) ; v3(222.32,151.06) 224.86,148.52 PR732.1
  IN1 w0.508: v3(13.21,148.9) 13.21,151.15 13.69,151.63 16.59,151.63 18.14,150.08 18.14,146.45 18.73,145.85 24.51,145.85 25.66,146.99 31.75,146.99 32.73,146.01 32.73,143.17 v3(32.68,143.12) ; v3(117.4,152.9) 117.4,156.91 116.87,157.44 116.87,160.61 119.32,163.06 v3(119.83,163.06)
  IN2 w0.508: v3(117.4,152.9) 116.84,153.46 104.74,153.46 102.34,151.06 92.03,151.06 90.21,152.88 75.28,152.88 73.9,151.5 66.78,151.5 66.03,152.25 48.55,152.25 47.8,151.5 47.52,151.5 43.9,147.88 38.67,147.88 37.28,146.48 34.16,146.48 32.68,145 v3(32.68,143.12) ; v3(119.83,163.06) 120.52,163.76 125.03,163.76 125.73,164.46 126.68,164.46 128.97,166.74 131.51,166.74 133.86,164.39 138.94,164.39 140.02,165.47 140.02,169.03 142.28,171.29 143.19,171.29 143.98,170.5 143.98,170.3 144.49,169.79 150.88,169.79 151.51,170.42 151.51,171.31 152.33,172.13 192.54,172.13 193.57,171.1 198.62,171.1 200.65,169.07 206.97,169.07 209.75,166.29 217.81,166.29 219.34,164.76 219.34,154.03 v3(222.32,151.06)
  IN3 w0.508: v4(13.46,173.35) 12.96,172.84 11.78,172.84 9.11,170.17 9.11,167.53 6.29,164.71 6.29,153.01 10.4,148.9 v3(13.21,148.9)
  vias: v4(13.46,174.62) v4(13.46,173.98) v4(14.1,174.62) v4(14.1,173.98) v4(14.1,173.35) v4(14.73,174.62) v4(14.73,173.98) v4(14.73,173.35) v4(15.37,174.62) v4(15.37,173.98) v4(15.37,173.35) v4(16,174.62) v4(16,173.98)
+DC_IN_SS: length 300.3
  TOP w0.254: v3(44.75,163.78) 44.54,163.99 32.83,163.99 29.79,167.02 27.14,167.02 25.43,168.72 20.21,168.72 18.13,170.81 ; PR831.1 33.38,140.02 v3(33.33,139.97) ; PR840.2 184.89,43.63 PQ822.3 v3(182.04,43.63) ; PD701.3 44.64,166.35 v3(44.64,165.92)
  IN3 w0.254: v3(88.01,42.09) 91.98,42.09 92.91,43.02 155.66,43.02 158.93,39.74 168.98,39.74 172.28,43.04 177.48,43.04 178.07,43.63 v3(182.04,43.63)
  IN4 w0.254: v3(33.33,139.97) 33.33,139.03 45.4,126.95 45.4,124.35 46.47,123.28 46.47,102.85 51.06,98.26 51.06,94.9 55.28,90.67 57.86,90.67 59.53,89 79.69,89 84.48,84.22 84.48,80.04 90.16,74.36 90.16,47.98 88.01,45.84 v3(88.01,42.09)
  BOTTOM w0.254: v3(33.33,139.97) 33.33,141.32 v1(37.34,145.34) 38.49,146.48 38.49,148.19 39.74,149.44 41.38,149.44 45.15,153.22 45.15,163.38 v3(44.75,163.78) 44.64,163.88 v3(44.64,165.92)
+DCIN: length 2
  BOTTOM w0.102: PR742.2 55.06,165.73 v1(56.07,164.71)
  vias: v3(53.85,166.44) v3(53.85,165.85)
+DCIN_JACK:
  vias: v2(19.23,179.17) v2(21.26,180.63) v2(23.19,179.17) v4(21.26,179.17)
+DDR_CHG: length 5
  TOP w0.102: R927.2 157.12,24.1 v1(157.93,23.29)
  TOP w0.508: R927.2 157.11,25.98 Q72.1
+DIMM1_VREF_CA: length 10.3
  TOP w0.102: v1(132.91,23.87) 133.22,24.18 v3(133.22,25.01)
  TOP w0.508: RD5.2 135.94,22.02 CD16.1 CD15.1 135.93,23.82 RD13.2 135.07,24.31 134.56,24.82 133.42,24.82 v3(133.22,25.01)
  BOTTOM w0.356: v3(133.22,25.01) 131.95,25.01 131.34,25.62 JDIMM1.126
+DIMM1_VREF_DQ: length 7
  TOP w0.102: v3(90.35,34.1) 90.35,34.65 v1(90.49,34.79)
  TOP w0.508: RD3.2 RD1.2 ; RD3.2 v3(90.35,34.1) ; RD3.2 91.75,34.11 CD1.1 CD2.1
  BOTTOM w0.356: JDIMM1.1 91.44,34.34 91.2,34.1 v3(90.35,34.1)
+DIMM2_VREF_CA: length 7
  TOP w0.102: v1(133.68,13.88) 133.68,13.74 132.83,12.89 RD10.2
  TOP w0.508: v3(131.34,15.57) 131.34,14.82 CD38.1 CD37.1 131.5,12.91 RD23.2 RD10.2
  BOTTOM w0.356: JDIMM2.126 v3(131.34,15.57)
+DIMM2_VREF_DQ: length 6
  TOP w0.508: CD23.1 91.9,23.35 v3(91.25,23.99) ; CD23.1 CD24.1 ; CD23.1 92.76,23.1 RD9.2 93.02,23.12 93.33,22.8 RD8.2
  BOTTOM w0.356: JDIMM2.1 91.44,23.8 v3(91.25,23.99)
+DOCK_PWR_BAR: length 105
  TOP w0.508: v3(43.26,168.03) PD701.2 ; PR832.2 v3(33.72,142.93)
  IN4 w0.508: v3(43.26,168.03) 46.12,168.03 46.27,168.18 52.07,168.18 52.54,168.65 55.06,168.65 56.71,167 66.17,167 66.54,167.36 76.87,167.36 77.56,166.68 85.09,166.68 87.56,164.2 95.7,164.2 96.39,164.9 101.03,164.9 104.78,168.65 v3(110.81,168.65)
  BOTTOM w0.508: v3(43.26,168.03) 43.26,163.99 44.52,162.73 44.52,153.48 42.41,151.37 41.09,151.37 40.64,150.93 40.64,150.49 40.35,150.19 39.41,150.19 37.85,148.63 37.85,146.74 v1(34.99,143.88) 34.91,143.88 33.96,142.93 v3(33.72,142.93)
  vias: v3(110.81,168.01) v3(110.81,167.38) v3(110.81,165.79) v3(110.81,165.15) v3(110.81,164.52) v3(110.81,163.19) v3(111.44,168.65) v3(111.44,167.38) v3(111.44,163.19)
+GPU_CORE: length 85
  TOP w0.254: v3(28.64,159.12) 28.51,158.99 28.51,158.32 31.75,155.08 v3(31.75,154.23) 31.75,153.86 PR654.1 ; PR656.2 33.33,153.61 33.78,153.15 33.78,151.82 v3(33.34,151.37) ; v3(17.15,164.48) 17.04,164.38 17.04,164.18 17.27,163.95 23.47,163.95 23.81,163.6 32.41,163.6 34.23,161.79 34.23,153.82 34.8,153.25 34.8,151.37 v3(34.93,151.25) 34.8,151.12 34.8,150.88 PR624.1 ; PR626.2 35.51,151.12 v3(35.51,151.19)
  TOP w0.457: v3(67.38,135.12) 67.69,135.44 PC927.1 PC933.1 68,133.86 v3(68.45,133.4) 68.91,132.95 PC931.1 68.91,132.82 v3(69.47,132.26) 70.03,131.7 PC950.1 ; CV78.1 68,137.61 v3(68.45,137.15) 68.91,136.69 CV79.1 68.96,136.58 v3(69.47,136.07) 69.97,135.57 CV82.1 PC946.1 69.97,133.89 70.48,133.37 v3(70.49,133.37) 70.49,133.37 70.94,132.92 PC929.1 70.94,132.67 71.22,132.4 71.22,132.39 71.38,132.24 v3(71.38,132.24) 71.81,131.81 PC945.1 ; PC948.1 73.84,131.67 v3(73.28,132.23) 72.79,132.72 PC947.1 72.79,132.95 v3(72.33,133.4) 71.87,133.86 PC928.1 PC934.1 71.87,135.58 v3(71.38,136.07) 70.88,136.56 CV80.1 70.88,136.76 v3(70.48,137.16) 70.46,137.18 70.43,137.18 69.9,137.7 CV81.1 ; v3(74.23,137.15) 74.69,136.69 PC951.1 ; PC932.1 68,131.77 v3(67.5,132.26) ; v3(72.33,137.16) 72.35,137.13 72.35,137.13 72.79,136.7 CV83.1 72.79,136.45 v3(73.22,136.02) 73.78,135.46 PC930.1 73.78,134.04 PC944.1 73.84,133.86 v3(74.3,133.4) 74.75,132.95 PC949.1 74.75,132.69 v3(75.25,132.2)
  TOP w0.508: CV78.1 67.67,138.07 CV84.1
  BOTTOM w0.254: v3(17.15,164.48) 17.08,164.54 17.08,166.08 17.49,166.49 PL600.1 ; v3(35.51,151.19) 35.51,151.43 34.99,151.95 34.04,151.95 v3(31.75,154.23) ; PL601.1 28.89,159.63 28.64,159.38 v3(28.64,159.12) ; v3(34.93,151.25) 34.8,151.37 v3(33.34,151.37)
  vias: v2(38.69,160.25) v3(60.12,138.86) v3(60.39,137.15) v3(62.36,137.21) v3(62.49,139.94) v3(62.49,138.86) v3(63.37,138.99) v3(63.5,135.37) v3(63.5,134.17) v3(64.14,136.58) v3(64.14,135.37) v3(64.2,140.58) v3(64.2,138.93) v3(64.26,137.85) v3(64.26,134.23) v3(64.39,132.96) v3(64.9,137.85) v3(64.96,141.4) v3(64.96,140.64) v3(64.96,139.82) v3(64.96,136.58) v3(65.03,135.37) v3(65.6,137.79) v3(65.72,139.82) v3(65.79,141.47) v3(65.79,140.64) v3(65.78,138.95) v3(65.85,136.58) v3(66.23,133.02) v3(66.61,140.64) v3(66.61,139.82) v3(66.61,139.06) v3(66.68,141.47) v3(67.5,137.15) v3(67.5,136.07) v3(67.48,130.27) v3(67.82,139.82) v3(67.88,140.58) v3(69.47,130.29) v3(70.49,130.29) v3(71.38,130.29) v3(72.26,130.29) v3(73.28,130.29) v3(74.3,130.29) v4(18.94,164.76) v4(19.95,164.76) v4(20.97,164.76) v4(21.99,166.79) v4(21.99,165.78) v4(21.99,164.76) v4(23,166.79) v4(23,165.78) v4(23,164.76) v4(24.02,165.78) v4(24.02,164.76) v4(25.03,164.76) v4(27.65,162.42) v4(27.65,161.41) v4(28.67,162.42) v4(28.67,161.41) v4(29.68,162.42) v4(29.68,161.41) v4(30.7,162.42) v4(30.7,161.41) v4(30.93,157.8) v4(31.71,162.42) v4(31.71,161.41) v4(31.94,157.8) v4(31.94,156.78) v4(32.73,161.41) v4(32.96,157.8) v4(32.96,156.78) v4(32.96,155.77) v4(35.32,159.91) v4(35.32,158.89) v4(35.32,157.88) v4(35.32,156.86) v4(35.32,155.84) v4(35.32,154.83) v4(36.34,159.91) v4(36.34,158.89) v4(36.34,157.88) v4(36.34,156.86) v4(36.34,155.84) v4(36.34,154.83) v4(37.35,157.88) v4(37.35,156.86) v4(37.35,155.84) v4(37.35,154.83) v4(38.37,157.88) v4(38.37,156.86) v4(38.37,155.84) v4(38.37,154.83) v4(39.38,157.88) v4(39.38,156.86) v4(39.38,155.84) v4(39.38,154.83) v4(40.4,157.88) v4(40.4,156.86) v4(40.4,155.84) v4(40.4,154.83) v4(41.42,156.86) v4(41.42,155.84) v4(41.42,154.83) v4(41.42,153.81) v4(41.42,152.8) v4(42.43,155.84) v4(42.43,154.83) v4(42.43,153.81) v4(43.45,154.83) v4(48.58,136.9) v4(49.21,136.9) v4(49.28,136.26) v4(49.85,136.9) v4(49.91,136.26) v4(50.48,136.9) v4(50.55,136.26) v4(50.87,137.53) v4(51.12,136.9) v4(51.06,130.29) v4(51.18,136.26) v4(51.69,130.29) v4(51.69,129.66) v4(52.33,130.29) v4(52.33,129.66) v4(55.31,148.54) v4(55.44,146.8) v4(55.44,145.21) v4(55.37,143.5) v4(55.37,141.79) v4(55.37,140.07) v4(55.37,138.36)
+LCDVDD: length 19.7
  TOP w0.406: C727.1 211.17,154.53 U56.5
  TOP w0.508: v3(210.39,154.5) C727.1
  IN2 w0.508: v3(207.07,163.11) 209.49,160.7 209.49,159.88 210.39,158.98 v3(210.39,154.5)
  BOTTOM w0.508: 203.14,167.95 204.09,167 204.09,163.91 204.89,163.11 v3(207.07,163.11)
  vias: v2(200.92,171.26) v3(200.01,171.86) v3(200.6,171.86) v3(201.18,171.86)
+LOM_VCT: length 6.4
  TOP w0.102: C701.1 v1(147.02,168.82)
  TOP w0.508: v3(148.66,167.57) 148.46,167.76 C701.1
  BOTTOM w0.254: JDOCK1.118 148.84,167.75 v3(148.66,167.57) 148.34,167.88 JDOCK1.116
+NBDOCK_DC_IN_SS: length 233.4
  TOP w0.254: v3(171.26,77.08) 170.12,77.08 169.32,76.28 PQ801.1 ; v3(184.91,38.05) PR827.2 184.32,37.4 184.06,37.15 PQ814.3 ; v3(214.82,95.18) 214.64,95 PQ823.1
  IN2 w0.254: v3(171.26,77.08) 171.32,77.02 174.87,77.02 180.07,82.23 180.07,90.66 180.45,91.04 180.45,103.48 v3(180.79,103.81)
  IN3 w0.254: v3(139.26,149.09) 139.35,149.18 139.93,149.18 142.31,146.8 142.31,124.62 149.14,117.78 149.14,113.49 149.58,113.05 153.63,113.05 156.12,110.56 161.71,110.56 163.49,108.78 165.67,108.78 168.15,106.3 177.01,106.3 179.49,103.81 v3(180.79,103.81) 181.25,103.81 184.92,100.14 187.8,100.14 189.77,98.16 199.01,98.16 199.65,97.53 211.08,97.53 213.43,95.18 v3(214.82,95.18) ; v3(168.98,47.71) 171.61,47.71 173.1,49.2 178.26,49.2 179.78,47.68 181.95,47.68 184.91,44.72 v3(184.91,38.05)
  IN4 w0.254: v3(171.26,77.08) 171.26,76.92 169.23,74.89 169.23,62.33 167.48,60.58 167.48,49.52 168.3,48.69 168.3,48.29 168.88,47.71 v3(168.98,47.71)
  BOTTOM w0.254: JDOCK1.41 v1(127.84,157.53) 127.84,156.97 126.62,155.75 126.62,153.28 127.95,151.95 129.41,151.95 133.52,147.84 137.31,147.84 138.56,149.09 v3(139.26,149.09)
+PBATT: length 296.1
  TOP w0.508: PQ830.3 173.34,13.53 172.89,13.99 172.89,16.55 PR833.2 173.31,17.15 v3(173.75,17.59) ; v3(36.96,149.6) 36.96,149.37 v1(34.99,147.4) 34.66,147.07 PR838.2
  IN2 w0.508: v3(109.11,158.16) 106.94,158.16 103.11,161.98 96.53,161.98 95.01,163.5 87.55,163.5 87.05,164 84.11,164 83.17,163.06 76.53,163.06 75.3,161.83 v3(75.3,160.56) 75.3,155.24 73.22,153.15 67.46,153.15 66.71,153.9 52.3,153.9 48.96,157.23 48.96,159.69 47.44,161.22 46.55,161.22 45.34,160.01 45.34,153.66 41.28,149.6 v3(36.96,149.6) ; v3(118.49,146.49) 120.14,146.49 122.12,148.47 127.77,148.47 128.79,149.49 131.01,149.49 131.71,148.8 135.8,148.8 141.91,142.69 141.91,140.83 142.53,140.21 142.53,123.75 147.66,118.62 147.66,108.65 147.27,108.26 147.27,100.33 150.47,97.13 150.47,90.87 152.4,88.94 152.4,80.84 155.87,77.37 155.87,55.13 156.29,54.71 156.29,46.51 160.67,42.13 160.67,35.22 159.79,34.34 159.79,25.94 164.67,21.06 169.86,21.06 173.33,17.59 v3(173.75,17.59)
  BOTTOM w0.508: v3(118.49,146.49) 118.05,146.93 118.05,150.53 115.19,153.38 115.19,156.16 112.66,158.69 109.64,158.69 v3(109.11,158.16)
+PBATT_C:
  vias: v1(76.71,167.88)
+PBATT_IN_SS: length 203.7
  TOP w0.508: v3(172.26,77.51) 171.52,78.26 PD807.2 ; 79.16,150.83 78.68,150.35 78.68,146.71 77.85,145.88 v3(77.85,145.34)
  IN1 w0.508: v3(77.85,145.34) 77.85,145.76 78.2,146.1 79.05,146.1 81.85,143.3 81.85,130.28 82.46,129.67 83.81,129.67 85.23,128.25 87.73,128.25 88.65,127.33 91.77,127.33 92.52,126.58 92.52,125.88 94.4,124 94.4,123.18 90.04,118.83 90.04,111.22 92.28,108.98 92.28,93.91 91.84,93.46 v3(89.92,93.46)
  IN3 w0.508: v3(89.92,93.46) 91.61,91.77 91.61,80.82 90.74,79.95 90.74,64.29 92.08,62.96 106.78,62.96 116.66,53.08 143.12,53.08 150.92,60.87 156.13,60.87 172.26,77 v3(172.26,77.51)
  vias: v1(75.99,151.7)
+PCH_DCPRTC: length 2.8
  TOP w0.102: CH54.1 v1(169.77,132.36)
  TOP w0.508: CH54.1 169.94,133.48 v3(169.94,133.96)
  BOTTOM w0.254: UH1.P16 169.94,134.02 v3(169.94,133.96) 169.94,133.89 UH1.P14
+PCH_VCC: length 9.2
  BOTTOM w0.102: RH246.2 157.74,153.15 157.74,153.15 v1(157.74,153.56)
  BOTTOM w0.254: UH1.AP45 161.96,146.73 161.96,147.24 159.98,149.22 159.45,149.22 158.82,149.84 CH64.1
  BOTTOM w0.508: CH64.1 158.63,150.29 158.02,150.9 CH63.1 157.74,150.93 RH246.2
+PCH_VCCCFUSE: length 19.4
  TOP w0.102: v3(169.96,135.57) 169.96,134.95 v1(170.55,134.36)
  TOP w0.508: v3(182.18,136.88) 181.57,136.88 181.27,137.19 RH242.2 180.98,137.79 180.58,137.39 CH66.1
  IN1 w0.508: v3(169.96,135.57) 169.96,136.29 171.18,137.52 174.92,137.52 175.35,137.95 181.12,137.95 v3(182.18,136.88)
  BOTTOM w0.254: UH1.P18 169.96,135.5 v3(169.96,135.57) 169.96,135.67 UH1.P20
+PCH_VCCCLK: length 23.5
  TOP w0.381: v3(167.31,140.43) 167.31,140.05 167.22,139.96 167.22,139.94 CH71.1 ; v3(165.76,142.61) 165.89,142.48 166.05,142.48 CH70.1
  IN3 w0.254: v3(167.31,140.43) 167.31,140.74 167.78,141.22 167.78,144.82 166.31,146.29
  IN3 w0.508: 166.31,146.29 166.31,148.9 165.67,149.53 v3(165.04,149.53) 165.04,146.23 166.44,144.83 166.44,142.29 166.08,141.94 v3(165.7,141.94)
  BOTTOM w0.254: UH1.AA30 166.98,140.1 v3(167.31,140.43) ; v3(167.31,140.43) 166.98,140.76 UH1.AA32 ; v3(167.31,140.43) 167.64,140.76 UH1.Y32 ; v3(165.7,141.94) 165.82,141.82 166.11,141.82 UH1.AD34
  vias: v1(164.15,145.15) v3(165.32,140.46)
+PCH_VCCCLK3_3: length 2.4
  BOTTOM w0.254: v3(171.14,140.1) 170.88,139.84 UH1.M29 ; UH1.L29 171.73,139.86 v3(171.73,140.1) ; UH1.M26 170.88,138.8 v3(171.21,139.12) 171.48,138.85 UH1.L26
  vias: v1(174.18,139.77) v3(169.29,140.46)
+PCH_VCCDSW: length 3.2
  TOP w0.508: RH232.2 176.73,132.02 v1(177.42,132.02) 178.05,132.02 178.44,131.64 v3(178.44,131.44)
  BOTTOM w0.254: UH1.U14 168.89,133.55 168.56,133.88 v3(168.56,133.96)
+PCH_VCCDSW3_3: length 372.9
  TOP w0.254: RH112.1 v3(176.85,120.45) ; RP17.2 213.89,92.2 214.28,92.59 v3(214.82,92.59) ; v3(93.92,62.35) 94.39,61.88 94.39,57.33 v1(95.84,55.88) 100.31,51.4 101.56,51.4 101.84,51.12 RC12.1 RC5.1 103.07,51.13 CC19.1 103.82,52 104.13,51.69 UC1.5 ; RPH21.1 186.58,131.32 186.09,131.8 186.09,132.06 185.22,132.93 v3(185.22,133.26) ; v3(179.45,120.39) 179.52,120.45 RH80.1 ; JAPS1.3 v3(231.19,94.4) ; v3(247.14,154.74) 247.96,155.55 247.96,157.66 247.79,157.83 R566.2
  IN1 w0.254: v3(185.22,133.26) 185.22,133.16 186.15,132.24 189.08,132.24 189.54,132.69 194.46,132.69 v3(195.06,132.1) ; v3(194.77,118.87) 194.5,118.87 192.93,120.43 189.1,120.43 188.25,119.58 184.49,119.58 182.97,118.06 181.1,118.06 180.53,118.63 180.53,119.31 v3(179.45,120.39) 179.45,120.58 179.07,120.96 177.17,120.96 176.85,120.64 v3(176.85,120.45) ; v3(231.19,94.4) 229.38,92.59 v3(214.82,92.59) 213.4,92.59 212.05,91.24 206.15,91.24 205.96,91.43 201.47,91.43 v3(200.92,91.99)
  IN2 w0.254: v3(199.91,82.74) 200.13,82.96 200.13,91.19 200.92,91.98 v3(200.92,91.99) 200.92,92.8 202.99,94.88 203.85,94.88 205.04,96.07 205.04,99.08 206.81,100.85 206.81,112.39 207.24,112.83 207.24,114.44 205.97,115.71 205.97,120.46 v3(205.83,120.6)
  IN3 w0.254: v3(247.14,154.74) 246.06,153.66 241.1,153.66 239.08,151.64 239.08,149.05 240.08,148.05 240.08,138.2 238.46,136.58 236.3,136.58 233.95,134.23 223.84,134.23 222.89,133.28 212.92,133.28 211.34,131.7 202.75,131.7 202.35,132.1 v3(195.06,132.1) ; v3(194.77,118.87) 199.41,118.87 199.65,118.63 203.86,118.63 v3(205.83,120.6) ; v3(93.92,62.35) 106.67,62.35 116.45,52.57 143.33,52.57 151.13,60.36 156.34,60.36 173.02,77.04 178.81,77.04 180.69,78.92 181.93,78.92 183.08,80.08 193.26,80.08 194.35,81.17 194.35,81.57 195.99,83.21 199.52,83.21 199.91,82.82 v3(199.91,82.74)
  IN4 w0.254: v3(195.06,132.1) 195.16,132 195.16,122.2 195.51,121.85 195.51,120.13 194.77,119.4 v3(194.77,118.87)
  BOTTOM w0.254: RH92.1 174.5,123.29 174.93,122.87 174.93,121.61 176.09,120.45 v3(176.85,120.45) ; UH1.A16 176.2,134.51 176.33,134.37 179.34,134.37 179.83,134.87 CH44.1 180.55,135.76 RH237.2 181.49,135.05 181.87,135.05 182.18,134.74 RH238.2 182.72,134.54 182.89,134.71 RH216.2 183.35,134.29 183.71,133.94 184.55,133.94 v3(185.22,133.26)
+PCH_VCCDSW_R: length 2.2
  TOP w0.102: v1(174.55,132.81) 174.97,132.39 RH232.1
  TOP w0.508: RH232.1 175.45,132.21 176,131.66 CH40.1
+PCH_VCCSST: length 2.6
  TOP w0.102: v3(166.66,133.98) 166.66,134.55 v1(167.21,135.11)
  TOP w0.508: CH46.1 166.63,133.96 v3(166.66,133.98)
  BOTTOM w0.254: UH1.AA14 166.98,133.67 v3(166.66,133.98)
+PECI_VREF: length 5.8
  TOP w0.305: U51.B51 205.33,83.75 205.04,83.75
  TOP w0.508: 205.04,83.75 204.6,84.19 202.73,84.19 v1(202.72,84.2) 202.31,84.2 C740.1 R866.1
+PWR_SRC: length 214.4
  TOP w0.102: v3(94.06,95.47) v2(95.52,95.47)
  TOP w0.508: v3(112.64,149.59) 113.16,150.1 114.05,150.1 116.27,152.32 116.27,153.56 116.82,154.1 116.82,155.72 112.9,159.63 108.19,159.63 107.84,159.97 100.93,159.97 100.71,159.76 v3(100.08,159.76) ; v3(173.17,104.78) 172.33,104.78 165.15,111.95 163.79,111.95 162.87,111.04 R930.1 ; RV67.1 v3(94.06,95.47)
  IN1 w0.508: v3(94.06,95.47) 94.06,99.77 93.32,100.51 93.32,103.93 94.06,104.66 v3(94.06,113.79)
  IN2 w0.508: v3(94.06,113.79) 93.79,114.06 93.79,116.82 87.48,123.14 87.48,125.49 86.78,126.19 86.78,126.51 83.71,129.58 82.42,129.58 81.92,130.09 81.92,144.39 82.42,144.9 83.19,144.9 84.27,145.98 84.27,147.69 85.15,148.57 89.54,148.57 90.11,148.01 111.06,148.01 v3(112.64,149.59)
  IN2 w4.318: 37.21,168.77 32.07,168.77 30.99,169.85 15.8,169.85 12.63,166.68 8.51,166.68
  IN2 w5.08: 181.52,53.6 181.47,53.6 171.25,63.82 171.25,69.66 166.88,74.03
  IN3 w1.016: 197.99,166.04 200.09,166.04 200.79,165.34 207.65,165.34 208.54,164.46 215.34,164.46 216.09,163.7
  vias: v3(98.81,160.39) v3(98.81,159.78) v3(99.42,160.39) v3(99.42,159.78) v3(100.03,160.39) v3(196.55,166.3) v3(197.16,166.3) v3(217.11,163.31) v3(217.11,162.73) v3(217.72,163.31) v4(2.41,163.57) v4(2.41,162.93) v4(2.41,162.3) v4(2.41,161.66) v4(3.05,164.2) v4(3.05,163.57) v4(3.05,162.93) v4(3.05,162.3) v4(3.05,161.66) v4(39.69,173.03) v4(39.69,172.39) v4(39.69,171.76) v4(40.32,173.03) v4(40.32,172.39) v4(40.32,171.76) v4(40.96,173.03) v4(40.96,172.39) v4(40.96,171.76) v4(84.52,163.06) v4(84.52,162.42) v4(84.52,161.79) v4(84.52,161.15) v4(85.16,163.06) v4(85.16,162.42) v4(85.16,161.79) v4(85.16,161.15) v4(85.79,162.42) v4(85.79,161.79) v4(85.79,161.15) v4(86.43,162.42) v4(86.43,161.79) v4(87.06,161.79) v4(168.28,93.08) v4(168.28,92.45) v4(168.91,93.08) v4(168.91,92.45) v4(169.55,93.08) v4(169.55,92.45) v4(170.18,93.08) v4(170.18,92.45) v4(170.82,93.08) v4(170.82,92.45) v4(171.45,92.7) v4(171.45,92.07) v4(172.02,92.38) v4(172.02,91.75) v4(194.95,46.98) v4(194.95,46.35) v4(194.95,45.71) v4(194.95,45.08) v4(195.58,46.98) v4(195.58,46.35) v4(195.58,45.71) v4(195.58,45.08) v4(196.22,45.71) v4(196.22,45.08)
+PWR_SRC_AC: length 25.9
  TOP w0.508: PR877.2 v3(47.56,137.51)
  BOTTOM w0.508: v3(47.56,137.51) 47.56,140.58 48.83,141.85 51.02,141.85 53.61,144.43 53.61,152.32 v1(51.15,154.77) 50.36,155.57 v3(50.36,157.47)
  vias: v4(33.53,172.39) v4(33.53,171.76) v4(34.16,173.03) v4(34.16,172.39) v4(34.16,171.76) v4(34.8,173.03) v4(34.8,172.39) v4(34.8,171.76) v4(35.43,173.03) v4(35.43,172.39) v4(35.43,171.76) v4(36.07,173.03) v4(36.07,172.39) v4(36.07,171.76) v4(57.53,166.36) v4(57.53,165.73) v4(57.53,165.09) v4(58.17,166.36) v4(58.17,165.73) v4(58.17,165.09) v4(58.8,166.36) v4(59.44,166.36) v4(60.07,166.36) v4(60.71,166.36) v4(61.34,166.36) v4(61.98,166.36) v4(97.6,168.27) v4(97.6,167.63) v4(97.6,167) v4(98.24,168.27) v4(98.24,167.63) v4(98.24,167) v4(98.87,168.27) v4(98.87,167.63) v4(98.87,167) v4(99.51,168.27) v4(99.51,167.63) v4(99.51,167)
+RSVD_VCC3P3_1: length 5.9
  TOP w0.203: R553.2 244.54,157.41 244.07,157.88 v1(244.07,158.44) 244.32,158.69 244.32,161.09 243.73,161.68 U31.1
+RTC_CELL: length 210.2
  TOP w0.508: RH5.1 v3(178.08,127.04) RH44.1 RH42.1 ; PD3.1 240.69,152.95 v3(241.11,152.95) 241.37,152.69 PC3.1 ; R1703.1 v3(267.64,151.01)
  IN2 w0.508: v3(267.64,151.01) 264.75,151.01 263.71,149.97 254.44,149.97 252.1,147.63 252.1,141.4 250.38,139.69 v3(240.65,139.69) ; v3(199.8,68.87) 197.68,71 197.68,76.38 198.34,77.04 198.34,81.17 198.54,81.37 198.54,86.65 199.55,87.66 199.55,92.15 203.9,96.5 203.9,99.74 204.92,100.75 204.92,103.88 205.86,104.82 205.86,112 204.75,113.11 204.75,116.26 204.69,116.32 204.69,119.19 205.08,119.59 205.08,122.12 204.15,123.05 v3(204.15,125.67)
  IN3 w0.508: v3(186.56,128.96) 189.8,128.96 192.56,126.2 194.53,126.2 195.58,125.15 203.63,125.15 v3(204.15,125.67) 207.17,125.67 209.3,123.54 220.05,123.54 221.15,122.44 233.19,122.44 236.08,125.33 236.08,134.45 237.67,136.04 238.63,136.04 240.65,138.06 v3(240.65,139.69) 240.65,148.19 239.59,149.26 239.59,151.42 v3(241.11,152.95)
  IN4 w0.508: v3(178.08,127.04) 178.08,127.24 180.51,129.67 180.95,129.67 v3(181.54,129.07)
  BOTTOM w0.254: CH55.1 178.54,130.2 178.54,130.2 178.3,130.44 175.88,130.44 UH1.A6
  BOTTOM w0.508: CH55.1 CH56.1 CH57.1 181.03,129.58 v3(181.54,129.07) 181.68,129.21 182.41,129.21 182.78,128.84 183.44,128.84 183.83,129.24 183.83,131.45 ; 183.83,131.45 RH67.2 182.83,131.63 RH43.1 ; 183.83,131.45 185.34,131.45 v1(186.06,130.74) 186.56,130.23 v3(186.56,128.96)
+RTC_CELL_VBAT: length 13.5
  TOP w0.305: U51.B64 205.78,76.79 v3(205.82,76.83)
  TOP w0.508: R830.2 200.92,68.85 200.9,68.86 v3(200.9,68.94) ; v3(203.53,74.22) 203.52,74.21 203.04,74.21 C724.1
  IN3 w0.508: v3(200.9,68.94) 200.9,69.8 203.53,72.43 v3(203.53,74.22) 203.53,74.74 204.6,75.81 204.6,76.32 205.11,76.83 v3(205.82,76.83)
  BOTTOM w0.102: v3(200.9,68.94) v1(201.74,68.94)
+SA_DIMM1_VREFDQ: length 7.9
  TOP w0.102: RD1.1 93.87,33.19 v1(93.92,33.14)
  TOP w0.508: RD19.2 94.27,27.82 RD17.2 92.99,28.23 RD18.1 92.71,28.97 92.71,33.12 RD1.1
+SA_DIMM_VREFDQ: length 147.3
  TOP w0.102: v3(90.43,26.72) 89.73,27.42 89.73,28.25 v1(89.66,28.31)
  TOP w0.406: v3(90.43,26.72) 91.24,25.91 QD6.1
  TOP w0.457: QD6.1 91.62,26.15 RD26.1
  TOP w0.508: RD26.1 91.58,27.02 RD27.1
  IN2 w0.508: v3(90.43,26.72) 90.43,29.71 91.06,30.34 91.06,47.55 94.88,51.37 94.88,59.55 99.57,64.24 v3(99.57,69.84)
  IN3 w0.254: 140.96,91.68 145.92,91.68 146.43,91.18 146,90.74 140.93,90.74 v3(140.47,91.2) 140.96,91.68
  IN3 w0.508: v3(99.57,69.84) 102.81,66.6 107.89,66.6 114.81,59.68 144.46,59.68 146.81,62.03 146.81,90.8 146.43,91.18
  BOTTOM w0.305: JCPU1.F16 140,90.73 v3(140.47,91.2)
+SA_DIMM_VREFDQ_Q: length 4.9
  TOP w0.102: v1(91.99,28.82) 92.53,28.27 RD26.2
  TOP w0.356: RD17.1 93.28,26.77 QD6.6
  TOP w0.508: RD26.2 93.33,26.98 RD17.1 93.42,26.91 CD47.1
+SB_DIMM2_VREFDQ: length 4.1
  TOP w0.102: v1(93.28,20.69) 93.79,21.2 RD8.1
  TOP w0.508: RD8.1 RD14.2 95.54,21.88 RD16.1 RD15.2
+SB_DIMM_VREFDQ: length 155.9
  TOP w0.406: v3(93.73,24.12) 93.73,24.38 93.5,24.61 QD6.4
  TOP w0.508: RD30.1 89.21,22.51 RD31.2 89.79,22.77 89.97,22.6 v3(90.17,22.6)
  IN4 w0.254: 140.7,87.7 144.86,87.7 145.16,88 145.16,88.32 144.8,88.68 140.95,88.68 v3(140.47,88.2) 140.47,87.93 140.7,87.7
  IN4 w0.508: v3(90.17,22.6) 91,22.6 92.52,24.12 v3(93.73,24.12) 93.92,24.12 95.14,22.9 153.78,22.9 157.62,26.74 157.62,31.73 155.77,33.57 155.77,71.27 158.31,73.81 158.31,78.58 155.64,81.25 155.64,82.19 148.87,88.95 146.31,88.95 145.92,88.57 145.42,88.57 145.16,88.32
  BOTTOM w0.305: JCPU1.F13 140,87.73 v3(140.47,88.2)
+SB_DIMM_VREFDQ_Q: length 10.2
  TOP w0.381: CD46.1 90.42,24.61 QD6.3
  TOP w0.508: v3(95.32,24.25) 95.06,24.25 94.68,23.87 v1(94.68,23.74) RD14.1 ; RD31.1 89.65,23.87 v3(90.17,23.87) 90.37,24.07 CD46.1
  IN4 w0.508: v3(90.17,23.87) 91.06,24.76 94.3,24.76 94.81,24.25 v3(95.32,24.25)
+SDC_IN: length 73.6
  TOP w0.254: PU700.3 51.5,165.78 v3(51.04,166.23) ; 25.44,169.26 27.29,167.4 29.95,167.4 32.98,164.37 45.61,164.37 v3(45.96,164.71) ; v3(40.93,136.21) 40.93,135.52 40.69,135.28 PR854.1
  IN1 w0.254: v3(45.96,164.71) 47.12,165.87 47.12,167.69 v3(45.47,169.34)
  IN4 w0.254: v3(51.04,166.23) 51.04,165.71 50.48,165.15 48.45,165.15 48.01,164.71 v3(45.96,164.71)
  BOTTOM w0.254: v3(40.93,136.21) 40.93,136.95 41.45,137.47 42.08,137.47 43.09,138.48 43.09,148.14 43.44,148.49 43.44,149.17 47.26,152.99 47.26,158.35 47.06,158.55 47.06,160.88 47.56,161.39 47.56,162.45 v1(46.72,163.29) 46.48,163.53 46.48,163.98 45.96,164.5 v3(45.96,164.71) 46.1,164.85 47.09,164.85 PR713.2 ; v3(45.47,169.34) PC720.1
  BOTTOM w0.406: PU703.3 45.52,168.53 PC720.1
+SIM_PWR: length 67.8
  TOP w0.508: C639.1 222.98,155.25 C636.1 C616.1 223.81,155.32 223.81,155.9 223.76,155.95 v3(223.76,155.97) 223.76,156.19 224.09,156.52 JSIM1.1
  IN2 w0.508: v3(223.76,155.97) 226.24,158.45 226.24,159.97 231.55,165.28 234.64,165.28 242.83,173.47 254.5,173.47 257.8,176.77 257.8,177.97 261.1,181.27 261.1,191.94 v3(260.92,192.12)
  BOTTOM w0.102: v1(223.83,155.02) 223.83,155.88 223.76,155.95 v3(223.76,155.97)
  BOTTOM w0.508: JMINI1.8 260.76,192.28 v3(260.92,192.12)
+SM_VREF: length 80.9
  TOP w0.381: RD29.1 101.64,21.35 98.45,21.35 QD7.3
  TOP w0.508: RD28.1 98.24,21.57 QD7.3 98.43,18.09 v1(98.93,17.58) v3(99.38,17.14)
  IN2 w0.254: 113.41,74.09 113.98,74.67 113.98,76.69 v3(113.47,77.2) 112.97,76.7 112.97,74.54 113.41,74.09
  IN2 w0.508: v3(99.38,17.14) 98.62,17.9 98.62,55.11 113.41,69.9 113.41,74.09
  BOTTOM w0.381: JCPU1.AM3 113.94,77.67 v3(113.47,77.2)
+SM_VREF_DIMM: length 54.4
  TOP w0.508: RD20.2 RD22.2 RD21.1 105.59,22.77 107.39,20.97 107.39,14.52 108.48,13.43 108.48,11.98 109.68,10.79 v1(120.46,10.79) 130.32,10.79 RD23.1 131.21,11.98 130.68,12.5 130.68,15.93 132.53,17.77 132.53,21.26 132.84,21.58 134.24,21.58 135.07,22.41 RD13.1
+SM_VREF_Q: length 2.4
  TOP w0.102: v1(104.28,25.19) 102.78,25.19 RD20.1
+SW_LX:
  vias: v1(201.49,157.28)
+SWR_V12: length 19
  TOP w0.203: v3(201.32,166.98) 201.22,166.87 U27.43
  TOP w0.254: U27.11 197.78,161.32 197.37,160.91 197.37,160.42 196.39,159.44 196.29,159.44 196.28,159.45
  TOP w0.508: v3(194.18,158.55) 194.18,158.98 194.65,159.45 C111.1 196.28,159.45
  BOTTOM w0.508: v3(201.32,166.98) 201.32,165.26 C112.1 200.69,164.85 200.46,165.08 199.73,165.08 199.23,164.58 v1(199.23,163.69) 199.23,161.96 200.55,160.64 200.55,158.09 v3(199.99,157.53)
  vias: v3(198.54,155.25) v3(198.88,156.33) v3(199.15,155.25)
+TRM_CT1: length 6.9
  TOP w0.102: v1(265.08,189.14) 265.08,189.47 264.2,190.35 262.69,190.35 C479.1
  TOP w0.508: C479.1 260.91,189.73 260.67,189.97 T156.3
+TRM_CT2: length 6.5
  TOP w0.102: v1(265.03,190.92) 264.25,191.7 262.76,191.7 C480.1
  TOP w0.508: T156.4 260.78,191.24 261.02,191 C480.1
+TRM_CT3: length 4.5
  TOP w0.102: v1(262.93,196.22) 262.07,197.08 C483.1
  TOP w0.508: C483.1 262.02,197.59 T156.9
+TRM_CT4: length 6
  TOP w0.102: v1(264.96,198.17) 262.7,198.17 C484.1
  TOP w0.508: T156.10 262.02,198.86 C484.1
+TSVDD: length 9.5
  TOP w0.508: LV16.2 71.83,148.09 CV98.1 71,146.68 71.24,146.43 CV93.1 CV92.1 v1(71.24,143.56) 71.24,142.54 70.74,142.04 70.74,141.02 71.27,140.5 v3(71.43,140.5)
  BOTTOM w0.4: UV1.AD17 71.68,140.5 v3(71.43,140.5)
+UIM_VPP: length 72.2
  TOP w0.102: v3(263.96,195.65) v1(264.87,195.65)
  TOP w0.508: v3(226.67,156.02) 225.91,155.26 C628.1 225.9,156.31 226.19,156.61 JSIM1.6
  IN2 w0.508: v3(263.96,195.65) 263.96,195.36 261.75,193.15 261.75,181.02 258.43,177.7 258.43,176.51 254.77,172.84 243.1,172.84 240.2,169.95 240.2,168.86 237.87,166.52 237.87,159.69 236.56,158.38 229.03,158.38 v3(226.67,156.02)
  BOTTOM w0.508: JMINI1.16 v3(263.96,195.65)
+UTLGND:
  vias: v1(199.96,156.26)
+V_DDR_REF: length 188.2
  TOP w0.203: PC209.1 177.04,83.44 177.04,84.38 177.12,84.46 PU200.4
  TOP w0.508: 136.92,13.53 158.45,13.53 161.67,16.75 v1(161.67,39.11) 161.67,51.74 159.39,54.03 159.39,57.75 165.23,63.59 v3(165.23,71.26) ; 136.92,13.53 136.59,13.2 134.24,13.2 133.02,11.98 RD10.1 132.4,11.04 131.19,9.83 108.7,9.83 106.61,11.93 93.03,11.93 92.52,12.44 92.52,21.45 ; 136.92,13.53 RD5.1 ; 92.52,21.45 91.38,21.45 90.74,20.82 89.09,20.82 88.46,21.45 88.46,28.13 91.05,30.72 91.05,32.48 RD3.1 ; 92.52,21.45 92.78,21.71 RD9.1 ; v3(176.09,83.43) 176.26,83.25 PC209.1
  IN3 w0.508: v3(165.23,71.26) 170.18,76.21 170.18,77.07 172.79,79.68 174.31,79.68 176.09,81.46 v3(176.09,83.43)
+VCHGR: length 1.3
  TOP w0.102: 97.98,158.44 v2(99.33,158.44)
  vias: v4(91,156.96) v4(91.63,157.6) v4(91.63,156.96) v4(91.63,156.33) v4(92.27,157.6) v4(92.27,156.96) v4(92.27,156.33) v4(92.27,155.69) v4(92.9,157.6) v4(92.9,156.96) v4(92.9,156.33) v4(92.9,155.69) v4(94.43,155.37) v4(94.43,154.74) v4(95.06,155.37) v4(95.06,154.74) v4(95.7,155.37) v4(95.7,154.74) v4(96.33,155.37) v4(96.33,154.74)
+VCOMP_OUT: length 2.2
  TOP w0.508: v3(139.46,96.38) 139.38,96.38 139.22,96.22 RC1.1 RC73.1
  BOTTOM w0.305: v3(139.46,96.38) 139.46,96.38 139.81,96.73 JCPU1.F22
+VDISPLAY_VCC: length 13.3
  TOP w0.102: v2(11.37,201.15) 12.1,201.15
  IN2 w1.016: 22.67,207.32 22.1,206.75 19.18,206.75 15.81,203.38 14.35,203.38 13.27,202.3 13.27,201.22
  vias: v3(12.32,201.48) v3(12.32,200.87) v3(22.93,209.48) v3(22.93,208.87) v3(27.69,206.91) v3(27.69,206.3)
+VGA_B+: length 21.8
  TOP w0.254: v3(31.88,148.39) 31.88,149.66 31.48,150.06 PR643.2
  IN1 w0.254: v4(15.43,155.95) 15.55,155.95 20.98,150.51 24.89,150.51 26.4,149 31.46,149 31.88,148.58 v3(31.88,148.39)
  vias: v1(15.31,153.6) v4(13.46,155.95) v4(14.1,155.95) v4(14.8,155.95)
+VGA_PCIE: length 72.7
  TOP w0.381: RV298.2 74.92,137.35 75.25,137.02 75.25,136.07 75.64,135.68 RV296.2
  TOP w0.457: v3(75.25,133.4) 75.38,133.53 CV74.1 ; CV74.1 CV73.1 ; CV74.1 75.87,133.62 76.4,134.14 76.4,134.14 76.46,134.2 ; 76.46,134.2 76.27,134.39 76.27,134.39 75.94,134.72 CV75.1 75.6,134.8 v3(75.31,135.1) ; 76.46,134.2 v3(76.46,134.2)
  TOP w0.508: v3(76.46,135.46) 76.24,135.68 RV296.2 ; v3(70.14,140.77) 69.47,140.77 67.9,142.34 CV204.1 CV199.1 67.88,145.74 CV202.1 ; v3(55.86,126.85) 55.87,126.84 57.55,126.84 LV21.2 ; CV77.1 82.11,131.3 CV69.1 CV71.1 80.99,131.19 v2(79.05,131.19) v3(78.46,130.6) 78.46,130.38 CV76.1
  IN2 w0.508: v3(70.14,140.77) 70.55,140.77 70.8,140.52 70.8,138.1 71.09,137.82 71.09,136.86 70.68,136.45 70.68,135.82 71.4,135.1 v3(75.31,135.1) ; v3(76.39,131.7) 76.39,131.05 75.88,130.55 75,130.55 74.33,131.21 62.55,131.21 58.19,126.85 v3(55.86,126.85)
  BOTTOM w0.254: UV1.N23 76.58,131.51 v3(76.39,131.7)
  BOTTOM w0.35: UV1.AD14 69.58,140.25 70.11,140.77 v3(70.14,140.77)
  BOTTOM w0.381: UV1.R21 74.78,132.94 v3(75.25,133.4) ; UV1.R22 UV1.N22 75.78,131.47 75.88,131.37 75.88,130.9 UV1.M22 UV1.L23 76.58,129.73 v3(76.97,129.35) ; v3(75.31,135.1) 74.81,134.6 UV1.U21 75.15,134.23 75.35,134.23 UV1.T22 ; v3(76.46,134.2) 76.06,134.6 UV1.U22 ; UV1.V22 75.92,135.46 v3(76.46,135.46)
  BOTTOM w0.4: UV1.L25 v3(78.46,130.6) UV1.L26 ; UV1.L25 v3(77.78,129.35) UV1.L24 ; UV1.L25 v3(77.66,130.6) ; v3(76.97,129.35) UV1.L24 ; UV1.L24 v3(77.66,130.6) ; v3(77.66,130.6) UV1.N24
  vias: v3(85.85,129.4) v3(86.17,128.9) v4(99.19,139.44) v4(99.19,138.8) v4(99.19,138.17) v4(99.19,137.53) v4(99.19,136.9) v4(99.19,136.26) v4(99.82,139.63) v4(99.82,138.99) v4(99.82,138.36) v4(99.82,137.72) v4(99.82,137.09) v4(99.82,136.45)
+VGA_PCIE_SPLL_VDDC: length 6.4
  TOP w0.508: v3(63.38,127) 62.87,127 62.66,126.79 CV223.1 CV225.1 60.53,126.61 CV224.1 58.69,126.61 LV21.1
  BOTTOM w0.254: v3(63.38,127) 64.18,127 UV1.H8
+VGA_PCIEP: length 27.1
  BOTTOM w0.254: 102.94,140.13 102.94,141.6 103.51,142.17 109.24,142.17 110.49,140.92 v1(110.49,131.82) 110.49,128.13 110.15,127.79 107.66,127.79 107.24,128.21 PC668.1 PR683.1
  vias: v3(104.08,138.93) v3(104.69,138.93) v3(105.3,138.93)
+VR_CAP: length 11.4
  TOP w0.305: v3(210.5,75.49) 210.89,75.49 211.08,75.3 211.08,74.79 211.18,74.69 U51.B12
  TOP w0.508: v3(213.3,68.81) 212.75,68.25 C779.1
  IN2 w0.508: v3(213.3,68.81) 213.18,68.93 213.18,72.18 211.12,74.24 211.12,75.13 210.76,75.49 v3(210.5,75.49)
  BOTTOM w0.102: v1(211.01,75.87) 210.63,75.49 v3(210.5,75.49)
+VREFC1: length 6.9
  TOP w0.102: v1(93.89,104.45) 93.53,104.08 RV139.2
  TOP w0.254: 90.43,102.99 90.31,102.87 89.42,102.87 UV4.J14
  TOP w0.381: 90.43,102.99 91.52,104.08 CV208.2 CV326.1 RV110.1 RV139.2
+VREFC2: length 8
  BOTTOM w0.102: v1(94.69,103.65) 94.69,103.58 94.02,102.91 94.02,102.85 RV183.2
  BOTTOM w0.254: UV5.J14 89.42,102.87 90.53,102.87
  BOTTOM w0.381: 90.53,102.87 91.76,102.87 92.04,102.59 92.04,102.47 92.27,102.25 CV328.2 RV183.2 RV184.1 CV329.1
+VREFC3: length 7.3
  TOP w0.254: UV3.J14 59,102.92 58.45,102.92 57.86,103.51
  TOP w0.381: 57.86,103.51 57.86,104.19 57.59,104.46 v1(57.15,104.46) 56.65,104.46 56.12,103.93 CV349.1 RV194.1 RV193.2 CV350.2
+VREFC4: length 10.1
  BOTTOM w0.102: v1(55.78,106.17) CV353.1
  BOTTOM w0.254: UV6.J14 59,102.86 58.98,102.88 58.42,102.88 57.91,103.38 57.91,104.27 57.79,104.4
  BOTTOM w0.381: CV354.2 RV197.2 55.88,107.43 56.28,107.04 RV198.1 CV353.1 56.78,106.1 57.53,106.1 57.79,105.84 57.79,104.4
+VREFD1_1: length 8.2
  TOP w0.102: RV128.1 83.49,113.58 v1(83.57,113.66)
  TOP w0.254: 85.73,109.26 UV4.A10
  TOP w0.381: RV128.1 RV109.2 CV322.2 CV207.1 83.49,110.35 84.58,109.26 85.73,109.26
+VREFD1_2: length 6.6
  TOP w0.102: v1(84.2,92.45) 84.2,92.76 84.7,93.26 RV131.1
  TOP w0.254: 85.8,96.06 UV4.U10
  TOP w0.381: 85.8,96.06 84.7,94.96 CV324.1 CV323.2 RV129.2 RV131.1
+VREFD2_1: length 6.8
  BOTTOM w0.102: RV181.1 84.7,92.78 v1(85.22,92.26)
  BOTTOM w0.254: UV5.A10 86.18,96.46 85.79,96.07
  BOTTOM w0.381: 85.79,96.07 84.7,94.97 CV327.1 CV325.2 RV140.2 RV181.1
+VREFD2_2: length 6.4
  TOP w0.102: RV185.2 87.05,113.41 v1(86.93,113.53)
  TOP w0.381: v3(86.6,109.66) 86.18,110.08 CV331.1 RV186.1 RV185.2 CV330.2
  BOTTOM w0.254: UV5.U10 v3(86.6,109.66)
+VREFD3_1: length 6.2
  TOP w0.102: CV210.1 62.44,92.14 v1(62.36,92.07)
  TOP w0.254: UV3.A10 62.44,96.29 62.44,95.94
  TOP w0.381: 62.44,95.94 RV120.1 RV119.2 CV209.2 CV210.1
+VREFD3_2: length 6.4
  TOP w0.254: 62.55,109.53 62.28,109.26 UV3.U10
  TOP w0.381: 62.55,109.53 62.55,110.92 v1(62.94,111.3) CV332.1 RV192.1 65.7,112.31 RV191.2 CV333.2
+VREFD4_1: length 6.5
  BOTTOM w0.102: v1(61.34,113.31) 61.05,113.31 60.47,112.73 RV195.2
  BOTTOM w0.254: UV6.A10 62.26,109.37 62.49,109.59
  BOTTOM w0.381: RV195.2 CV352.2 60.48,111.36 RV196.1 CV351.1 62.49,111.1 62.49,109.59
+VREFD4_2: length 6.1
  BOTTOM w0.102: v1(62.44,92.21) RV205.1
  BOTTOM w0.254: 62.44,95.92 62.44,96.29 UV6.U10
  BOTTOM w0.381: 62.44,95.92 CV355.1 CV356.2 RV203.2 RV205.1
+VREFOUT: length 17.9
  TOP w0.254: v3(275.06,152.83) 274.87,152.83 274.19,152.83 273.79,153.24 U74.23
  TOP w0.508: R1146.2 282.12,157.33 v1(282.63,156.82) 282.63,156.49 282.39,156.25 v3(282.39,155.46) 282.37,155.45 R1145.2
  IN3 w0.508: v3(282.39,155.46) 282.89,154.96 282.89,152.64 281.65,151.4 276.49,151.4 v3(275.06,152.83)
-DCIN_JACK: length 1
  TOP w0.102: v4(23.75,180.25) v2(23.75,181.3)
A_ON: length 71.6
  TOP w0.102: v3(200.91,91.19) 199.94,92.15 188.69,92.15 184.48,96.37 182.55,96.37 181.04,94.86 PR308.1 ; U36.3 228.11,70.65 228.51,70.25 v3(229.52,70.25) ; U51.B24 213.79,77.79 v3(213.59,77.6) ; R424.2 221.06,77.9 v3(221.06,76.7)
  IN1 w0.102: v3(221.06,76.7) 220.74,77.01 214.63,77.01 214.05,77.6 v3(213.59,77.6)
  IN4 w0.102: v3(213.59,77.6) 213.59,77.8 213.36,78.03 207.65,78.03 206.38,79.3 205.54,79.3 204.72,80.12 204.72,83.94 204.32,84.35 204.32,88.61 201.74,91.19 v3(200.91,91.19)
  BOTTOM w0.102: v3(229.52,70.25) v1(228.41,70.25) 227.55,70.25 227.27,69.97 225.15,69.97 223.23,71.89 223.23,74.2 221.06,76.37 v3(221.06,76.7)
AC_DIS: length 378.1
  TOP w0.102: U46.B12 190.47,69.3 190.12,69.3 189.95,69.13 189.77,69.13 189.17,69.74 v3(189.17,69.75)
  TOP w0.254: v3(6,174.87) 5.4,175.47 v2(5.4,175.57) 5.4,177.85 5.84,178.3 PQ6.5 ; v3(177.93,37.4) 175.84,37.4 173.88,35.44 PR828.1
  IN3 w0.254: v3(177.93,37.4) 177.6,37.07 170.94,37.07 169.04,38.98 158.37,38.98 155.22,42.13 93.15,42.13 90.98,39.96 82.8,39.96 77.85,44.9 77.85,56.88 83.37,62.39 83.37,84.71 78.95,89.13 49.23,89.13 43.94,94.41 43.94,105.43 47.5,108.99 47.5,125.29 v3(47.47,125.31)
  IN4 w0.102: v3(177.93,37.4) 178.44,37.91 178.44,40.99 176.99,42.44 176.99,43.43 175.5,44.92 175.5,51.86 177.38,53.75 182.23,53.75 187.11,58.63 187.11,59.84 187.69,60.42 188.29,60.42 188.42,60.55 188.66,60.8 188.66,60.93 189.25,61.52 189.25,62.79 190.08,63.63 190.08,64.29 190.57,64.78 190.57,68.92 190.41,69.08 189.42,69.08 189.17,69.33 v3(189.17,69.75)
  IN4 w0.254: v3(6,174.87) 5.97,174.87 6,174.84 6,174.68 6.49,174.18 6.99,174.18 8.06,173.12 8.06,166.48 6.59,165.02 6.59,146.65 13.13,140.11 21.3,140.11 22.05,140.86 26.01,140.86 26.7,140.17 29.05,140.17 32.53,143.65 36.23,143.65 36.98,142.9 36.98,138.7 44.67,131.02 46.16,131.02 47.47,129.7 v3(47.47,125.31)
AC_PRESENT: length 104.5
  TOP w0.102: v3(202.54,80.64) 202.54,80.64 203.15,80.04 U51.A54 ; RP17.7 213.89,89.67 v3(214.36,89.19)
  IN1 w0.102: v3(204.81,90.44) 204.97,90.29 208.95,90.29 209.48,89.77 213.79,89.77 v3(214.36,89.19)
  IN2 w0.127: v3(202.54,80.64) 203.03,81.13 203.47,81.13 204.75,82.41 204.75,88.97 204.75,88.97 204.75,90.38 v3(204.81,90.44) 204.78,90.48 204.78,92.66 209.77,97.65 209.77,98.49 209.77,113.8 208.6,114.97 207.3,116.27 207.3,126.45 205.6,128.15 v3(205.6,132.26)
  IN3 w0.089: 178.68,129.49 178.47,129.49 178.11,129.86 175.29,129.86 174.99,130.15 174.42,130.15 v3(174.35,130.08)
  IN3 w0.127: v3(205.6,132.26) 205.27,132.59 189.28,132.59 186.18,129.49 178.68,129.49
  BOTTOM w0.089: v3(174.35,130.08) 174.37,130.08 174.37,130.1 174.33,130.15 174.33,130.34 UH1.E6
  BOTTOM w0.102: v1(201.61,80.44) 201.81,80.64 v3(202.54,80.64)
ACAV_DOCK_SRC#: length 128.1
  TOP w0.254: v3(44.96,135.63) 43.87,134.53 42.33,134.53 41.39,133.59 39.94,133.59 39.61,133.92 PR846.2 39.12,134.23 38.29,135.05 PR847.1
  IN2 w0.254: v3(44.96,135.63) 52.26,135.63 53.85,137.21 53.85,148.39 55.67,150.21 61.84,150.21 65.2,146.84 78.55,146.84 80.36,148.65 80.67,148.65 82.02,150 89.73,150 90.58,149.15 110.43,149.15 112.04,150.76 117.97,150.76 v3(119.27,149.47)
  BOTTOM w0.102: v3(119.27,149.47) 119.27,153.65 v1(117.41,155.5) 117.22,155.69 117.22,161.21 117.53,161.52 117.53,161.98 117.54,161.98 117.54,162.15 119.46,164.07 121.99,164.07 124.72,166.8 126.05,166.8 127.19,167.95 127.57,167.95 127.84,168.21 JDOCK1.42
ACAV_IN: length 364.9
  TOP w0.102: v2(49.09,166.32) 49.18,166.32 v3(49.54,166.69) ; U51.A64 203.27,75.04 v3(202.76,75.56)
  TOP w0.254: v3(41.91,138.17) 41.82,138.25 PU800.8 ; PQ825.2 194.3,79.63 195,78.93 v3(195,78.55) ; v3(243.87,136.57) 243.87,138.17 241.61,140.43 PQ710.2 238.01,141.23 238.09,141.31 238.09,142.97 v3(238.08,142.97) ; PR717.1 50.01,167.77 49.94,167.69 PR741.2 v3(49.54,166.69)
  IN1 w0.254: v3(195,78.55) 196.72,76.83 197.58,76.83 198.69,75.71 202.6,75.71 v3(202.76,75.56)
  IN2 w0.254: v3(49.54,166.69) 50.6,167.74 52.86,167.74 53.25,167.35 56.43,167.35 56.53,167.25 66.23,167.25 66.52,167.54 75.95,167.54 79.42,164.07 82.93,164.07 83.74,164.89 87.42,164.89 87.92,164.39 95.38,164.39 96.9,162.87 103.57,162.87 107.01,159.42 115.3,159.42 116.62,160.75 129.44,160.75 129.92,160.27 131.12,160.27 132.89,162.04 139.58,162.04 141.32,163.78 144.42,163.78 146.47,165.83 148.89,165.83 150.61,167.55 151.34,167.55 152.72,168.93 155.31,168.93 156.99,170.61 173.68,170.61 184.51,159.78 187.83,159.78 189.67,157.94 193.41,157.94 197.36,153.99 197.36,153.05 201.91,148.5 201.91,148.07 208.57,141.4 215.11,141.4 216.95,143.25 221.4,143.25 222.09,143.94 231.08,143.94 231.54,144.4 236.65,144.4 v3(238.08,142.97)
  IN3 w0.127: v3(202.76,75.56) 202.8,75.56 204.52,77.28 207.08,77.28 207.84,78.03 213.7,78.03 215.54,79.87 217.36,79.87 217.64,80.15 220.56,80.15 223.17,82.76 223.17,103.29 225.71,105.83 225.71,106.85 227.22,108.36 227.22,115.17 229.83,117.78 234.93,117.78 240.45,123.31 240.45,133.03 243.87,136.45 v3(243.87,136.57)
  BOTTOM w0.254: v3(41.91,138.17) 41.91,138.93 41.28,139.56 41.28,144.01 42.71,145.44 42.71,148.3 43.05,148.64 43.05,149.33 46.75,153.02 46.75,158.14 46.55,158.34 46.55,161.09 47.06,161.6 47.06,162.17 46.04,163.19 46.04,163.88 45.4,164.52 45.4,165.1 45.62,165.32 49.24,165.32 PR743.1 49.52,166.66 v3(49.54,166.69)
ACAV_IN#: length 56.1
  TOP w0.102: v1(193.07,83.18) PR864.2
  TOP w0.254: PU806.2 v3(190.31,46.73) ; v3(193.7,81.26) 194.07,81.63 PQ825.1 194.95,82.72 PR864.2 ; PQ819.5 v3(180.1,49.84)
  IN1 w0.254: v3(190.31,46.73) 190.31,47.79 191.34,48.82 191.34,52.02 192.48,53.17 192.48,57.87 191.83,58.52 191.83,61.38 v3(193.23,62.78)
  IN3 w0.254: v3(180.1,49.84) 181.77,49.84 184.61,46.99 189.28,46.99 189.55,46.73 v3(190.31,46.73)
  IN4 w0.254: v3(193.7,81.26) 193.78,81.18 193.78,76.14 194.69,75.23 194.69,71.39 195.39,70.69 195.39,68.38 195.77,68 195.77,66.03 193.23,63.49 v3(193.23,62.78)
ACAV_IN_NB: length 336.2
  TOP w0.102: v3(213.62,75.9) 213.72,75.79 U51.B20
  TOP w0.254: v3(244.96,136.98) 244.96,138.85 238.13,145.68 232.18,145.68 230.94,146.93 226.63,146.93 225.39,148.17 225.39,149.02 222.78,151.63 221.05,151.63 v2(219.81,150.4) 219.81,147.7 PR737.2 220.28,146.62 220.15,146.62 219.32,145.79 v3(219.32,145.64) ; v3(39.37,146.8) 39.42,146.8 39.82,146.4 PU800.24
  IN1 w0.254: v3(118.12,152.9) 117.91,153.11 117.91,157.12 117.38,157.65 117.38,160.4 119.53,162.55 120.4,162.55 v3(120.91,163.06)
  IN2 w0.254: v3(39.37,146.8) 39.37,146.86 39.88,147.37 44.39,147.37 48.76,151.74 65.82,151.74 66.57,150.99 74.11,150.99 75.49,152.37 90,152.37 91.82,150.55 103.09,150.55 105.49,152.95 114.6,152.95 115.35,152.2 117.42,152.2 v3(118.12,152.9) ; v3(120.91,163.06) 121.54,163.06 122.47,162.13 126.52,162.13 127.99,163.6 139.23,163.6 140.91,165.28 140.91,165.71 141.96,166.76 148.74,166.76 150.3,168.32 151.03,168.32 152.4,169.69 154.99,169.69 156.67,171.37 173.99,171.37 184.83,160.54 193.64,160.54 196.34,157.84 196.34,156.08 198.12,154.31 198.12,153.5 202.62,149 202.89,149 203.39,148.5 203.39,147.75 208.89,142.25 214.81,142.25 218.2,145.64 v3(219.32,145.64)
  IN3 w0.127: v3(213.62,75.9) 214.06,75.9 214.82,76.66 214.82,78.03 215.27,78.48 215.97,78.48 216.85,79.36 217.57,79.36 217.85,79.64 220.77,79.64 223.67,82.55 223.67,102.32 227.98,106.62 227.98,114.78 230.22,117.02 235.24,117.02 241.21,122.99 241.21,132.56 244.96,136.3 v3(244.96,136.98)
ACAVDK_SRC: length 5.6
  TOP w0.102: v1(37.83,134.69) 37.83,136.64 PR847.2
  TOP w0.254: PR847.2 38.52,137.33 38.8,137.33 39.82,138.35 PU800.4
ADBIA0: length 34.8
  TOP w0.089: UV4.J4 v3(81,102.46)
  IN4 w0.127: v3(72.63,129.15) 72.08,128.59 72.08,128.23 72.43,127.88 72.81,127.88 73.03,127.66 73.03,126.05 73.26,125.82 73.26,124.3 73.73,123.82 73.73,122.6 74.21,122.12 74.21,119.11 75.1,118.22 75.1,113.66 76.55,112.21 76.55,103.29 76.98,102.86 80.61,102.86 81,102.46 v3(81,102.46)
  BOTTOM w0.089: UV4.J4 v3(81,102.46) ; v3(72.63,129.15) 72.78,129.3 UV1.L18
ADBIA1: length 31.1
  TOP w0.089: UV3.J4 v3(66.66,103.26)
  IN4 w0.089: v3(71.43,127.92) 70.61,127.1 70.61,126.38 70.51,126.28 70.51,124.76
  IN4 w0.127: 70.51,124.76 70.51,120.48 70.85,120.14 70.85,112.08 69.38,110.61 69.38,106.44 69.25,106.31 67.19,106.31 67.06,106.19 67.06,105.4 66.92,105.26 66.51,105.26 66.27,105.02 66.27,103.65 v3(66.66,103.26)
  BOTTOM w0.089: UV3.J4 v3(66.66,103.26)
  BOTTOM w0.13: UV1.K16 70.78,128.96 v3(71.43,127.92)
ALW_PWRGD_3V_5V: length 51.7
  TOP w0.102: U51.A1 205.93,73 205.67,72.74 205,72.74 204.2,71.94 202.95,71.94 201.08,70.07 198.83,70.07 196.39,67.63 v1(196.39,65.34) 196.39,64.71 194.47,62.78 v3(193.82,62.78)
  TOP w0.254: v3(195.43,33.51) PR118.1
  IN1 w0.102: v3(195.43,33.51) 193.45,35.49 192.6,35.49 192.47,35.61 192.47,42.59 192.09,42.97 192.09,45.84 191.64,46.28 191.64,51.55 192.91,52.82 192.91,58.6 194.02,59.71 194.02,62.58 v3(193.82,62.78)
