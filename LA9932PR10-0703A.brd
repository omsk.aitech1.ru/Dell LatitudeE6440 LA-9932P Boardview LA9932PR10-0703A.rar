# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_MA4: length 77.2
  IN1 w0.089: v3(125.45,82.22) 125.03,81.8 125.01,81.8 123.82,80.61 123.35,80.61 123.05,80.31 123.05,79.84 122.85,79.64 122.85,79.04 122.63,78.82 122.57,78.82 122.1,78.35 122.1,75.04 122.37,74.77 122.37,73.69 122.31,73.63
  IN1 w0.165: 122.31,73.63 122.31,61.98 116.7,56.38 116.7,34.35 117.27,33.78 117.27,22.81 119.37,20.71 119.37,19.46 119.94,18.89 119.94,17.78 120.1,17.62 120.33,17.62 120.45,17.49 120.45,17.08 120.33,16.96 120.1,16.96 119.94,16.79 119.94,16.02 120.06,15.89 120.52,15.89 120.65,16.02 120.65,16.28 120.78,16.4 v3(120.89,16.4)
  BOTTOM w0.089: v3(125.45,82.22) 125.45,82.22 JCPU1.Y7
  BOTTOM w0.165: JDIMM2.92 121.14,15.26 121.33,15.45 121.33,15.97 v3(120.89,16.4)
DDR_B_MA5: length 77.7
  IN1 w0.089: 123.9,73.63 123.9,74.43 123.86,74.46 123.86,78.79 124.04,78.96 124.04,79.51 124.26,79.73 124.26,79.98 v3(124.51,80.23)
  IN1 w0.165: v3(118.75,24.27) 119.23,24.27 119.35,24.4 119.35,26.25 119.19,26.42 118.88,26.42 118.75,26.54 118.75,26.95 118.88,27.08 119.19,27.08 119.35,27.24 119.35,27.57 119.19,27.74 118.94,27.74 118.81,27.86 118.81,28.27 118.94,28.4 119.19,28.4 119.35,28.56 119.35,32.7 119.19,32.86 119.04,32.86 118.87,33.03 118.87,33.36 119.04,33.52 119.19,33.52 119.35,33.69 119.35,34.36 119.19,34.53 118.62,34.53 118.49,34.66 118.49,35.06 118.62,35.19 119.19,35.19 119.35,35.35 119.35,35.75 119.19,35.91 118.31,35.91 118.19,36.04 118.19,36.45 118.31,36.57 119.19,36.57 119.35,36.74 119.35,41.19 119.19,41.36 118.4,41.36 118.24,41.52 118.24,41.85 118.4,42.02 119.19,42.02 119.35,42.18 119.35,42.51 119.19,42.68 118.4,42.68 118.24,42.84 118.24,43.17 118.4,43.34 119.19,43.34 119.35,43.5 119.35,43.83 119.19,44 118.4,44 118.24,44.16 118.24,44.49 118.4,44.66 119.19,44.66 119.35,44.82 119.35,45.15 119.19,45.32 118.4,45.32 118.24,45.48 118.24,45.81 118.4,45.98 119.19,45.98 119.35,46.14 119.35,46.47 119.19,46.64 118.4,46.64 118.24,46.81 118.24,47.14 118.4,47.3 119.19,47.3 119.35,47.47 119.35,56.92 123.9,61.47 123.9,73.63
  BOTTOM w0.089: v3(124.51,80.23) 124.94,80.66 JCPU1.AA6
  BOTTOM w0.165: v3(118.75,24.27) 119.9,24.27 120.84,23.33 JDIMM2.91
DDR_B_MA6: length 80.2
  IN1 w0.089: v3(125.45,81.44) 124.92,81.44 123.85,80.37 123.85,80.05 123.63,79.82 123.57,79.82 123.04,79.29 123.04,78.96 122.91,78.83 122.91,74.78 122.86,74.74 122.86,73.63
  IN1 w0.165: 122.86,73.63 122.86,61.83 118.36,57.34 118.36,56.57 118.23,56.44 117.47,56.44 117.34,56.31 117.34,55.82 117.47,55.69 118.23,55.69 118.36,55.57 118.36,55.16 118.23,55.03 117.36,55.03 117.2,54.87 117.2,54.54 117.36,54.37 118.23,54.37 118.36,54.25 118.36,53.84 118.23,53.71 117.36,53.71 117.2,53.55 117.2,53.22 117.36,53.05 118.23,53.05 118.36,52.92 118.36,52.52 118.23,52.39 117.36,52.39 117.2,52.23 117.2,34.55 117.76,33.98 117.76,23.01 119.86,20.92 119.86,19.66 120.43,19.09 120.43,18.39 v3(120.89,17.93)
  BOTTOM w0.089: v3(125.45,81.44) 125.94,80.95 JCPU1.Y6
  BOTTOM w0.165: JDIMM2.90 120.54,15.19 120.39,15.34 120.39,17.43 v3(120.89,17.93)
DDR_B_MA7: length 77
  IN1 w0.089: 121.81,73.63 121.81,74.73 121.91,74.82 121.91,78.53 122.08,78.71 122.08,79.34 122.32,79.57 122.38,79.57 122.86,80.06 122.86,80.39 123.27,80.8 123.65,80.8 124.46,81.6 124.46,82.09 v3(124.47,82.1)
  IN1 w0.165: v3(119.37,17.93) 118.87,18.42 118.87,20.51 116.77,22.6 116.77,27.5 116.65,27.63 115.81,27.63 115.69,27.75 115.69,28.14 115.81,28.27 116.65,28.27 116.77,28.4 116.77,28.8 116.65,28.93 115.81,28.93 115.69,29.06 115.69,40.75 116.21,41.27 116.21,56.58 121.81,62.19 121.81,73.63
  BOTTOM w0.089: v3(124.47,82.1) 124.85,81.73 JCPU1.AA7
  BOTTOM w0.165: JDIMM2.86 119.34,14.99 119.89,15.54 119.89,17.41 v3(119.37,17.93)
DDR_B_MA8: length 79.6
  IN1 w0.089: 123.36,73.63 123.36,74.59 123.1,74.85 123.1,78.35 123.57,78.82 123.63,78.82 123.85,79.04 123.85,79.59 124.04,79.78 124.04,80.29 124.81,81.06 125.6,81.06 125.82,81.29 125.82,82.66 v3(126.4,83.24)
  IN1 w0.165: v3(120.89,19.45) 120.36,19.98 120.36,21.12 118.26,23.22 118.26,34.19 117.69,34.76 117.69,47.69 117.82,47.81 118.69,47.81 118.86,47.98 118.86,48.31 118.69,48.47 117.82,48.47 117.69,48.6 117.69,49.01 117.82,49.14 118.69,49.14 118.86,49.3 118.86,49.63 118.69,49.8 117.82,49.8 117.69,49.92 117.69,50.33 117.82,50.46 118.69,50.46 118.86,50.62 118.86,50.95 118.69,51.12 117.82,51.12 117.69,51.24 117.69,51.65 117.82,51.78 118.69,51.78 118.86,51.94 118.86,57.13 123.36,61.63 123.36,73.63
  BOTTOM w0.089: v3(126.4,83.24) 125.94,82.77 JCPU1.Y8
  BOTTOM w0.165: JDIMM2.89 120.24,20.1 v3(120.89,19.45)
DDR_B_MA9: length 75.7
  IN1 w0.089: 120.82,73.63 120.82,74.99 120.91,75.08 120.91,79.21 121.35,79.65 121.43,79.65 121.86,80.08 121.86,82.12 122.35,82.61 124.17,82.61 124.4,82.84 124.57,82.84 124.84,83.11 124.84,83.57 v3(125.47,84.2)
  IN1 w0.165: v3(117.84,19.45) 117.01,20.29 117.01,20.38 115.33,22.06 115.33,26.71 114.7,27.34 114.7,41.16 115.22,41.68 115.22,56.99 120.82,62.6 120.82,73.63
  BOTTOM w0.089: v3(125.47,84.2) JCPU1.AA10
  BOTTOM w0.165: v3(117.84,19.45) 119.04,20.65 JDIMM2.85
DDR_B_MA10: length 84
  IN1 w0.089: 127.92,73.63 127.92,73.67 127.87,73.71 127.87,78.98 128.88,79.99 128.88,80.17 129.3,80.6 130.4,80.6 131.07,81.27 131.07,81.33 131.54,81.8 131.6,81.8 131.85,82.04 131.85,82.82 v3(131.47,83.2)
  IN1 w0.165: 127.92,73.63 127.92,63.21 128.26,62.86 128.26,57.89 124.41,54.03 124.41,50.22 124.54,50.1 125.67,50.1 125.8,49.97 125.8,49.56 125.67,49.44 124.54,49.44 124.41,49.31 124.41,48.9 124.54,48.78 125.65,48.78 125.78,48.65 125.78,39.89 125.62,39.73 125.09,39.73 124.96,39.6 124.96,39.2 125.09,39.07 125.62,39.07 125.78,38.9 125.78,38.32 125.65,38.19 125.39,38.19 125.16,37.97 125.16,37.76 125.39,37.53 125.65,37.53 125.78,37.41 125.78,36.95 125.65,36.82 124.71,36.82 124.58,36.69 124.58,36.29 124.71,36.16 126.13,36.16 126.26,36.03 126.26,35.63 126.13,35.5 124.14,35.5 124.01,35.37 124.01,34.97 124.14,34.84 126.13,34.84 126.26,34.71 126.26,34.31 126.13,34.18 125.01,34.18 124.84,34.01 124.84,33.49 125.01,33.32 125.74,33.32 125.87,33.19 125.87,32.79 125.74,32.66 124.54,32.66 124.41,32.53 124.41,32.13 124.54,32 125.75,32 125.88,31.87 125.88,31.17 125.75,31.04 125.62,31.04 125.49,30.91 125.49,24.75 v3(125.93,24.31)
  BOTTOM w0.089: v3(131.47,83.2) JCPU1.R9
  BOTTOM w0.165: v3(125.93,24.31) 125.48,23.86 125.48,23.38 125.64,23.22 JDIMM2.107
DDR_B_MA11: length 77.1
  IN1 w0.089: 121.32,73.63 121.32,74.85 121.1,75.07 121.1,78.34 121.89,79.14 121.89,79.42 122.05,79.58 122.05,80.31 122.31,80.57 122.45,80.57 122.87,81 123.59,81 124.08,81.5 124.08,82.25 124.44,82.6 124.73,82.6 v3(125.41,83.28)
  IN1 w0.165: v3(119.37,16.4) 118.38,17.39 118.38,20.3 115.82,22.85 115.82,26.92 115.19,27.55 115.19,40.95 115.71,41.47 115.71,56.79 121.32,62.39 121.32,73.63
  BOTTOM w0.089: v3(125.41,83.28) 125.86,83.73 JCPU1.Y9
  BOTTOM w0.165: v3(119.37,16.4) 118.74,15.78 JDIMM2.84
DDR_B_MA12: length 74.8
  IN1 w0.089: 120.33,73.63 120.33,74.95 120.07,75.21 120.07,80.33 120.57,80.82 120.63,80.82 120.85,81.04 120.85,81.82 v3(120.47,82.2)
  IN1 w0.165: 120.33,73.63 120.33,62.81 114.72,57.2 114.72,41.88 114.2,41.36 114.2,27.14 114.83,26.51 114.83,21.32 117.38,18.77 117.38,18.39 v3(117.84,17.93)
  BOTTOM w0.089: v3(120.47,82.2) 120,81.73 JCPU1.AF7
  BOTTOM w0.165: v3(117.84,17.93) 117.23,18.54 117.23,20.26 117.79,20.82 118.03,20.82 118.44,21.23 JDIMM2.83
DDR_B_MA13: length 84.1
  IN1 w0.089: v3(132.43,83.26) 132.97,83.26 133.1,83.13 133.1,78.16 132.72,77.78 132.72,75.11 133.1,74.73 133.48,74.34 133.48,73.63
  IN1 w0.165: 133.48,73.63 133.48,67.19 135.01,65.66 135.01,64.95 135.14,64.82 135.77,64.82 135.9,64.7 135.9,64.22 135.77,64.1 135.01,64.1 134.89,63.97 134.89,63.56 135.01,63.44 135.77,63.44 135.9,63.31 135.9,62.69 135.73,62.52 135.4,62.52 135.28,62.39 135.28,61.99 135.4,61.86 135.73,61.86 135.9,61.7 135.9,61.37 135.73,61.2 135.4,61.2 135.28,61.07 135.28,60.67 135.4,60.54 135.73,60.54 135.9,60.37 135.9,60.04 135.73,59.88 135.4,59.88 135.28,59.75 135.28,59.35 135.4,59.22 135.73,59.22 135.9,59.05 135.9,58.72 135.73,58.56 135.4,58.56 135.28,58.43 135.28,58.03 135.4,57.9 135.73,57.9 135.9,57.73 135.9,44.14 135.77,44.02 135.08,44.02 134.96,43.89 134.96,42.71 133.48,41.24 132.78,40.53 132.78,23.39 131.29,21.9 131.29,21.1 131.29,20.61 132.18,19.72 132.18,17.24 132.06,17.11 131.57,17.11 131.45,17.24 131.45,19.32 131.32,19.45 v3(130.81,19.45)
  BOTTOM w0.089: JCPU1.P9 131.96,83.73 v3(132.43,83.26)
  BOTTOM w0.165: JDIMM2.119 129.24,21.02 v3(130.81,19.45)
DDR_B_MA14: length 82.3
  IN1 w0.089: 119.83,73.63 119.83,74.89 119.88,74.94 119.88,82.14 120.54,82.8 123.92,82.8 124.36,83.23 v3(124.44,83.23)
  IN1 w0.165: v3(117.84,16.4) 117.44,16.4 117.35,16.31 117.35,15.61 117.22,15.48 116.6,15.48 116.47,15.61 116.47,17.32 116.6,17.45 116.96,17.45 117.09,17.57 117.09,17.98 116.96,18.11 116.6,18.11 116.47,18.23 116.47,18.94 114.34,21.07 114.34,26.3 113.71,26.93 113.71,28.77 113.18,29.29 113.18,32.99 113.71,33.52 113.71,41.57 114.22,42.09 114.22,57.4 119.83,63.01 119.83,73.63
  BOTTOM w0.089: JCPU1.AA8 v3(124.44,83.23)
  BOTTOM w0.165: JDIMM2.80 117.54,15.22 117.3,15.46 117.3,15.86 v3(117.84,16.4)
DDR_B_MA15: length 73.7
  IN1 w0.089: 118.84,75 118.85,75.01 118.85,80.82 v3(118.47,81.2)
  IN1 w0.165: v3(115.98,16.4) 115.05,17.34 115.05,18.96 113.35,20.66 113.35,23.5 112.78,24.07 112.78,26.35 112.61,26.52 112.36,26.52 112.19,26.68 112.19,27.01 112.36,27.18 112.59,27.18 112.71,27.31 112.71,27.71 112.59,27.84 112.36,27.84 112.19,28.01 112.19,33.4 112.72,33.93 112.72,41.98 113.23,42.5 113.23,57.81 118.84,63.42 118.84,75
  BOTTOM w0.089: JCPU1.AG7 118.94,81.67 v3(118.47,81.2)
  BOTTOM w0.165: JDIMM2.78 116.94,15.12 116.74,15.31 116.74,15.64 v3(115.98,16.4)
DDR_B_RAS#: length 80.3
  IN1 w0.089: v3(131.47,80.2) 131.26,79.99 131.26,79.82 130.88,79.44 130.88,79.08 130.6,78.8 129.23,78.8 129.06,78.63 129.06,75.42 129.86,74.62 129.86,73.63
  IN1 w0.165: v3(126.06,15.64) 127.62,15.64 127.75,15.77 127.75,48.79 127.87,48.91 129.7,48.91 129.86,49.08 129.86,49.41 129.7,49.58 127.99,49.58 127.83,49.74 127.83,50.07 127.99,50.24 129.7,50.24 129.86,50.4 129.86,50.73 129.7,50.9 127.99,50.9 127.83,51.06 127.83,51.39 127.99,51.56 129.7,51.56 129.86,51.72 129.86,73.63
  BOTTOM w0.089: v3(131.47,80.2) JCPU1.R6
  BOTTOM w0.165: v3(126.06,15.64) 126.54,15.16 JDIMM2.110
DDR_B_WE#: length 81.5
  IN1 w0.089: v3(132.47,80.2) 132.78,80.2 132.91,80.07 132.91,79.81 132.78,79.68 132.22,79.68 132.1,79.56 132.1,78.92 131.97,78.79 131.26,78.79 130.87,78.4 130.87,77.96 130.61,77.7 130.18,77.7 130.1,77.62 130.1,75.04 130.86,74.28 130.86,73.63
  IN1 w0.165: 130.86,73.63 130.86,43.89 130.69,43.72 128.86,43.72 128.74,43.59 128.74,43.19 128.86,43.06 130.73,43.06 130.86,42.93 130.86,42.45 130.73,42.33 128.91,42.33 128.78,42.2 128.78,41.52 128.91,41.39 129.37,41.39 129.58,41.18 129.58,37.15 130.07,36.65 130.07,34.21 129.95,34.08 129.63,34.08 129.5,33.96 129.5,33.5 129.66,33.34 129.95,33.34 130.07,33.21 130.07,32.8 129.95,32.68 129.66,32.68 129.5,32.51 129.5,32.18 129.66,32.02 129.95,32.02 130.07,31.89 130.07,31.48 129.95,31.36 129.66,31.36 129.5,31.19 129.5,29.24 129.66,29.08 129.88,29.08 130.01,28.95 130.01,28.54 129.88,28.42 129.66,28.42 129.5,28.25 129.5,27.92 129.66,27.76 129.95,27.76 130.07,27.63 130.07,27.22 129.95,27.1 129.66,27.1 129.5,26.93 129.5,26.6 129.66,26.44 129.95,26.44 130.07,26.31 130.07,25.9 129.95,25.78 129.7,25.78 129.58,25.65 129.58,23.2 129.45,23.07 128.37,23.07 128.24,22.95 128.24,22.48 128.41,22.31 129.03,22.31 129.16,22.18 129.16,21.78 129.03,21.65 128.41,21.65 128.24,21.49 128.24,19.58 128.37,19.45 v3(128.68,19.45)
  BOTTOM w0.089: v3(132.47,80.2) JCPU1.P6
  BOTTOM w0.165: v3(128.68,19.45) 127.44,20.69 JDIMM2.113
DDR_CKE0_DIMMA: length 60.8
  IN4 w0.089: v3(121.47,83.2) 120.85,82.57 120.85,75.4 119.94,74.49 119.94,73.63
  IN4 w0.165: v3(113.72,31.65) 112.61,32.77 112.61,52.3 113.32,53 113.32,63.88 119.94,70.5 119.94,73.63
  BOTTOM w0.089: JCPU1.AD9 121.94,83.67 v3(121.47,83.2)
  BOTTOM w0.165: JDIMM1.73 115.44,33.37 v3(113.72,31.65)
DDR_CKE1_DIMMA: length 62.2
  IN4 w0.089: v3(122.47,83.2) 122.47,82.85 121.04,81.42 121.04,74.9 120.43,74.29 120.43,73.63
  IN4 w0.165: v3(113.72,30.13) 113.72,30.27 114.22,30.77 114.22,32.54 113.11,33.65 113.11,51.66 113.81,52.36 113.81,63.68 120.43,70.3 120.43,73.63
  BOTTOM w0.089: JCPU1.AC9 122.94,83.67 v3(122.47,83.2)
  BOTTOM w0.165: v3(113.72,30.13) 115.74,28.11 JDIMM1.74
DDR_CKE2_DIMMB: length 77.7
  IN1 w0.089: v3(119.47,84.2) 119.25,84.2 118.88,84.57 118.32,84.57 117.85,84.1 117.85,75.84 117.78,75.77 117.78,73.63
  IN1 w0.165: v3(113.69,17.93) 112.98,18.64 112.98,19.52 112.28,20.22 112.28,23.06 111.71,23.63 111.71,25.55 111.12,26.14 111.12,33.85 111.65,34.37 111.65,42.42 112.17,42.94 112.17,58.25 112.96,59.05 117.78,63.86 117.78,73.63
  BOTTOM w0.089: JCPU1.AF10 119.94,84.67 v3(119.47,84.2)
  BOTTOM w0.165: JDIMM2.73 115.44,19.67 v3(113.69,17.93)
DDR_CKE3_DIMMB: length 76.4
  IN1 w0.089: 118.27,73.63 118.27,74.66 118.08,74.85 118.08,83.81 v3(118.47,84.2)
  IN1 w0.165: 118.27,73.63 118.27,63.66 112.66,58.05 112.66,42.73 112.14,42.21 112.14,34.17 111.62,33.64 111.62,26.34 112.21,25.76 112.21,23.84 112.78,23.26 112.78,20.42 114.3,18.9 114.3,17.01 v3(113.69,16.4)
  BOTTOM w0.089: v3(118.47,84.2) 118.94,84.67 JCPU1.AG10
  BOTTOM w0.165: v3(113.69,16.4) 114.12,16.4 115.74,14.79 JDIMM2.74
DDR_CS0_DIMMA#: length 65.2
  IN4 w0.089: 135.98,73.63 135.98,74.31 135.73,74.56 134.58,74.56 134.1,75.04 134.1,81.05 134.22,81.17 v3(134.47,81.17)
  IN4 w0.165: 135.98,73.63 135.98,45.35 131.66,41.03 131.66,37.89 131.49,37.72 131.18,37.72 131.03,37.57 131.03,37.22 131.18,37.06 131.49,37.06 131.66,36.9 131.66,35.92 131.19,35.46 129.1,35.46 128.97,35.33 128.97,34.93 129.1,34.8 130.56,34.8 130.68,34.67 130.68,34.28 130.56,34.15 129.6,34.15 129.47,34.02 129.47,31.71 129.42,31.65 v3(128.94,31.65)
  BOTTOM w0.089: JCPU1.M7 133.94,81.7 v3(134.47,81.17)
  BOTTOM w0.165: v3(128.94,31.65) 127.74,30.46 JDIMM1.114
DDR_CS1_DIMMA#: length 65.4
  IN4 w0.089: 134.86,73.63 134.86,74.01 133.87,75 133.87,82.5 133.96,82.59 134.83,82.59 134.94,82.7 134.94,82.84 134.83,82.95 133.96,82.95 133.87,83.04 133.87,83.3 134,83.43 135.34,83.43 135.47,83.3 v3(135.47,83.2)
  IN4 w0.165: 134.86,73.63 134.86,73.24 135.02,73.07 135.35,73.07 135.48,72.95 135.48,72.54 135.35,72.41 135.02,72.41 134.86,72.25 134.86,71.92 135.02,71.75 135.31,71.75 135.48,71.59 135.48,71.26 135.31,71.09 135.02,71.09 134.86,70.93 134.86,70.6 135.02,70.43 135.31,70.43 135.48,70.27 135.48,69.94 135.31,69.77 135.02,69.77 134.86,69.61 134.86,69.28 135.02,69.11 135.31,69.11 135.48,68.95 135.48,68.62 135.31,68.45 135.02,68.45 134.86,68.29 134.86,67.96 135.02,67.79 135.31,67.79 135.48,67.63 135.48,67.3 135.31,67.13 135.02,67.13 134.86,66.96 134.86,66.63 135.02,66.47 135.31,66.47 135.48,66.3 135.48,65.97 135.31,65.81 135.02,65.81 134.86,65.64 134.86,65.31 135.02,65.15 135.31,65.15 135.48,64.98 135.48,64.65 135.31,64.49 134.99,64.49 134.86,64.36 134.86,63.93 134.99,63.81 135.35,63.81 135.48,63.68 135.48,46.3 135.35,46.17 133.8,46.17 133.67,46.04 133.67,45.62 133.8,45.5 134.76,45.5 134.89,45.37 134.89,44.96 134.76,44.83 133.8,44.83 133.67,44.71 133.67,43.74 131.16,41.23 131.16,38.46 131.03,38.33 v3(130.59,38.33)
  BOTTOM w0.089: v3(135.47,83.2) JCPU1.L9
  BOTTOM w0.165: JDIMM1.121 129.84,36.55 129.97,36.68 130.27,36.68 130.4,36.81 130.4,37.13 130.11,37.42 130.11,37.85 v3(130.59,38.33)
DDR_CS2_DIMMB#: length 81.6
  IN1 w0.089: v3(132.47,78.2) 132.47,77.7 132.34,77.57 131.16,77.57 131.04,77.45 131.04,75.93 132.42,74.55 132.42,73.63
  IN1 w0.165: 132.42,73.63 132.42,66.75 133.74,65.43 133.74,60.33 133.9,60.17 134.08,60.17 134.21,60.04 134.21,59.63 134.08,59.51 133.9,59.51 133.74,59.34 133.74,59.01 133.9,58.85 134.08,58.85 134.21,58.72 134.21,58.31 134.08,58.19 133.9,58.19 133.74,58.02 133.74,57.69 133.9,57.52 134.08,57.52 134.21,57.4 134.21,56.99 134.08,56.86 133.9,56.86 133.74,56.7 133.74,53.6 133.9,53.44 134.08,53.44 134.21,53.31 134.21,52.9 134.08,52.78 133.9,52.78 133.74,52.61 133.74,52.28 133.9,52.12 134.08,52.12 134.21,51.99 134.21,51.58 134.08,51.46 133.9,51.46 133.74,51.29 133.74,50.96 133.9,50.8 134.08,50.8 134.21,50.67 134.21,50.26 134.08,50.14 133.9,50.14 133.74,49.97 133.74,44.97 133.57,44.81 132.75,44.81 132.59,44.64 132.59,44.31 132.75,44.14 133.57,44.14 133.74,43.98 133.74,43.49 133.61,43.36 132.79,43.36 132.67,43.23 132.67,41.95 131.71,40.99 131.71,23.83 130.23,22.34 130.23,21.72 130.23,21.72 130.23,21.09 129.75,20.61 129.75,16.78 129.87,16.65 131.23,16.65 131.36,16.53 131.36,16.12 131.23,15.99 130.02,15.99 129.86,15.83 129.86,15.36 129.73,15.23 129.24,15.23 129.12,15.36 129.12,16.28 128.99,16.4 v3(128.68,16.4)
  BOTTOM w0.089: v3(132.47,78.2) JCPU1.P4
  BOTTOM w0.165: v3(128.68,16.4) 128.5,16.4 127.74,15.65 JDIMM2.114
DDR_CS3_DIMMB#: length 78.4
  IN1 w0.089: 131.43,73.63 131.43,74.77 130.47,75.73 v3(130.47,76.2)
  IN1 w0.165: v3(130.15,24.4) 130.39,24.4 130.65,24.65 130.65,36.89 130.15,37.39 130.15,40.83 131.43,42.11 131.43,52.53 131.59,52.7 132.55,52.7 132.72,52.86 132.72,53.19 132.55,53.36 131.59,53.36 131.43,53.52 131.43,53.85 131.59,54.02 132.55,54.02 132.72,54.19 132.72,54.52 132.55,54.68 131.59,54.68 131.43,54.85 131.43,55.18 131.59,55.34 132.55,55.34 132.72,55.51 132.72,55.84 132.55,56 131.59,56 131.43,56.17 131.43,56.5 131.59,56.66 132.55,56.66 132.72,56.83 132.72,57.16 132.55,57.32 131.59,57.32 131.43,57.49 131.43,57.82 131.59,57.98 132.55,57.98 132.72,58.15 132.72,58.48 132.55,58.64 131.59,58.64 131.43,58.81 131.43,59.14 131.59,59.3 132.55,59.3 132.72,59.47 132.72,59.8 132.55,59.96 131.59,59.96 131.43,60.13 131.43,60.46 131.59,60.62 132.55,60.62 132.72,60.79 132.72,61.12 132.55,61.28 131.59,61.28 131.43,61.45 131.43,61.78 131.59,61.94 132.55,61.94 132.72,62.11 132.72,62.44 132.55,62.61 131.59,62.61 131.43,62.77 131.43,63.1 131.59,63.27 132.55,63.27 132.72,63.43 132.72,63.76 132.55,63.93 131.59,63.93 131.43,64.09 131.43,64.42 131.59,64.59 132.52,64.59 132.65,64.71 132.65,65.12 132.52,65.25 131.59,65.25 131.43,65.41 131.43,73.63
  BOTTOM w0.089: JCPU1.R2 130.94,76.67 v3(130.47,76.2)
  BOTTOM w0.165: v3(130.15,24.4) 129.58,23.83 129.58,23.3 129.84,23.04 JDIMM2.121
DDR_HVREF_RST_PCH: length 211.5
  TOP w0.102: 101.67,46.15 100.97,46.15 97.41,49.71 97.41,52.95 92.97,57.39 92.97,63.8 v3(92.46,64.32) ; 101.67,46.15 105.09,46.15 105.78,46.84 RC104.2 ; 101.67,46.15 96.59,41.07 96.59,26.77 QD9.2 97.46,25.52 CD45.1 ; CD45.1 97.27,24.44 v1(96.52,24.44) 95.95,24.44 95.68,24.7 94.34,24.7 93.78,25.26 QD6.5 QD6.2 ; CD45.1 97.46,24.36 96.97,23.87 96.97,23.51 97.56,22.91 97.7,22.91 97.94,22.67 QD7.2 ; RH170.2 172.7,118.38 v3(173.42,119.1)
  IN2 w0.089: v3(171.2,130.81) 170.82,130.43 170.82,128.76 171.13,128.45 171.13,126.62
  IN2 w0.127: v3(153.53,92.37) 156.02,94.86 156.02,101.72 157.79,103.5 157.79,106.99 163.44,112.64 168.62,112.64 170.52,114.54 171.9,114.54 172.79,115.43 172.79,117.14 173.42,117.77 v3(173.42,119.1) 173.25,119.27 173.23,119.27 172.94,119.57 172.94,122.06 172.67,122.33 172.67,124.56 172.42,124.81 172.42,124.82 171.13,126.1 171.13,126.62
  IN3 w0.127: v3(153.53,92.37) 153.99,91.91 153.99,80.19 156.52,77.66 156.52,68.18 146.24,57.9 114.08,57.9 107.26,64.72 92.86,64.72 v3(92.46,64.32)
  BOTTOM w0.089: v3(171.2,130.81) 171.06,130.81 UH1.N8
DDR_XDP_WAN_SMBCLK: length 360.8
  TOP w0.102: U27.13 199.22,159.46 199.31,159.38 199.31,159.22 198.69,158.6 198.69,157.89 198.33,157.53 197.86,157.53 197.24,156.91 197.24,156.39 v3(197.02,156.17) ; 85.16,48.07 85.49,47.74 86.81,47.74 86.93,47.62 86.93,38.34 86.32,37.73 86.32,28.22 87.47,27.08 87.47,24.45 v3(87.26,24.25) ; QH4.1 176.64,116.27 177.31,115.6 177.31,114.33 177.77,113.87 178.28,113.87 178.82,114.42 181.94,114.42 182.11,114.25 182.11,114.09 v3(181.93,113.91)
  TOP w0.254: 85.16,48.07 85.15,48.08 U88.4
  IN4 w0.102: v3(197.02,156.17) 197.17,156.01 197.17,155.5 196.51,154.84 186.03,154.84 183.76,152.57 183.76,140.29 184.87,139.19 184.87,137.32 183.24,135.7 183.24,128.57 180.66,126 180.66,122.71 183,120.37 183,116.29 182.06,115.35 182.06,114.04 v3(181.93,113.91) 182.12,113.72 182.12,113.17 184.84,110.46 184.84,108.36 185.07,108.14 185.07,103.28 185.92,102.43 185.92,100.26 186.34,99.84 186.34,99.28 186.95,98.67 186.95,98.32 v3(186.77,98.14) 186.96,97.95 186.96,90.05 186.46,89.56 186.46,87.96 187.03,87.39 187.03,81.13 185.84,79.93 185.11,79.93 184.68,79.5 184.1,79.5 175.64,71.04 175.64,56.06 174.46,54.88 174.46,49.36 173.99,48.89 173.99,45.46 176.3,43.15 176.3,42.15 177.5,40.96 177.5,38.44 177.29,38.24 177.29,36.5 178.02,35.77 178.02,34.19 178.31,33.9 178.83,33.9 v3(179.01,33.72)
  BOTTOM w0.102: RH31.1 215.99,97.25 216.3,97.25 216.4,97.15 216.4,96.19 216.15,95.94 214.5,95.94 213.64,95.07 196.19,95.07 193.13,98.14 189.45,98.14 188.6,98.99 187.33,98.99 186.89,98.55 186.89,98.26 v3(186.77,98.14) ; v3(87.26,24.25) 87.47,24.04 87.47,12.72 88.43,11.76 107.35,11.76 107.54,11.57 153.11,11.57 153.95,12.42 153.95,12.61 154.14,12.8 JDIMM2.202 154.14,15.1 153.95,15.29 153.95,16.82 156.63,19.5 156.63,23.71 155.46,24.88 154.31,24.88 153.95,25.23 153.95,25.81 154.14,26 JDIMM1.202 154.14,28.3 153.95,28.49 153.95,29.71 154.21,29.96 156.02,29.96 156.91,29.07 156.91,26.34 159.2,24.05 169.42,24.05 175.17,29.81 175.17,33.11 176.02,33.96 178.77,33.96 v3(179.01,33.72)
DDR_XDP_WAN_SMBCLK_R2: length 3.1
  BOTTOM w0.102: JXDP2.53 213.16,97.38 213.3,97.52 214.02,97.52 RH31.2
DDR_XDP_WAN_SMBDAT: length 359.4
  TOP w0.102: v3(182.51,113.91) 182.34,114.09 182.34,114.35 182.04,114.65 178.73,114.65 178.18,114.1 177.87,114.1 177.54,114.42 177.54,114.74 177.78,114.97 QH4.4 ; U27.14 199.62,159.46 199.54,159.38 199.54,159.12 198.92,158.51 198.92,157.8 198.43,157.3 197.96,157.3 197.47,156.82 197.47,156.3 v3(197.6,156.17) ; v3(87.85,24.25) 87.7,24.4 87.7,27.17 86.55,28.32 86.55,37.64 87.16,38.25 87.16,47.92 R501.2
  TOP w0.254: R501.2 87.3,51.62 86.94,51.98 U88.6
  IN4 w0.102: v3(179.01,34.31) 178.83,34.13 178.4,34.13 178.25,34.29 178.25,35.87 177.52,36.59 177.52,38.14 177.73,38.35 177.73,41.05 176.53,42.25 176.53,43.24 174.22,45.55 174.22,48.8 174.69,49.27 174.69,54.78 175.87,55.97 175.87,70.95 184.19,79.27 184.77,79.27 185.21,79.7 185.93,79.7 187.26,81.03 187.26,87.48 186.69,88.06 186.69,89.46 187.19,89.96 187.19,97.97 v3(187.35,98.14) 187.17,98.32 187.17,98.77 186.56,99.38 186.56,99.94 186.15,100.36 186.15,102.53 185.29,103.38 185.29,108.23 185.07,108.46 185.07,110.55 182.35,113.27 182.35,113.74 v3(182.51,113.91) 182.28,114.14 182.28,115.26 183.22,116.2 183.22,120.46 180.89,122.8 180.89,125.9 183.47,128.48 183.47,135.6 185.09,137.23 185.09,139.29 183.99,140.39 183.99,152.48 186.12,154.61 196.6,154.61 197.4,155.41 197.4,155.96 v3(197.6,156.17)
  BOTTOM w0.102: v3(179.01,34.31) 178.89,34.19 175.93,34.19 174.94,33.21 174.94,29.9 169.32,24.28 159.29,24.28 157.14,26.44 157.14,29.17 156.12,30.19 154.11,30.19 153.73,29.8 153.73,28.49 153.54,28.3 JDIMM1.200 153.54,26 153.73,25.81 153.73,25.14 154.21,24.65 155.36,24.65 156.4,23.61 156.4,19.6 153.73,16.92 153.73,15.29 153.54,15.1 JDIMM2.200 153.54,12.8 153.73,12.61 153.73,12.51 153.02,11.8 107.63,11.8 107.44,11.99 88.52,11.99 87.7,12.82 87.7,24.09 v3(87.85,24.25) ; v3(187.35,98.14) 187.12,98.37 187.12,98.46 187.42,98.76 188.51,98.76 189.36,97.91 193.04,97.91 196.1,94.85 213.74,94.85 214.6,95.71 216.25,95.71 216.63,96.1 216.63,97.24 216.4,97.48 215.99,97.48 RH30.1
DDR_XDP_WAN_SMBDAT_R2: length 2.9
  BOTTOM w0.102: JXDP2.51 213.16,97.88 213.3,97.75 v4(213.68,97.75) 214.56,97.75 RH30.2
DEVICE_DET#: length 68.6
  TOP w0.102: RP16.3 194.9,76.1 194.68,76.32 193.84,76.32 193.41,75.89 193.41,74.26 194.38,73.29 196.05,73.29 198.16,71.19 199.06,71.19 R1070.2 198.93,70.53 198.92,70.53 196.04,67.64 v1(196.04,67.19) 196.04,64.67 194.78,63.41 194.32,63.41 194.09,63.19 193.05,63.19 192.8,62.94 192.8,61.9 191.43,60.53 191.43,58.24 192.26,57.41 192.26,55.78 191.34,54.87 185.32,54.87 182.93,52.48 174.86,52.48 172.91,50.54 170.03,50.54 v3(168.65,49.16)
  IN2 w0.127: JSATA2.8 162.82,45.05 162.82,48.25 163.9,49.34 168.47,49.34 v3(168.65,49.16)
DGPU_HOLD_RST#: length 152
  TOP w0.102: RV33.2 82.95,145.05 83.81,145.91 ; 83.81,145.91 85.09,145.91 85.18,145.82 85.84,145.82 86.63,146.61 89.98,146.61 90.11,146.74 v1(93.6,146.74) v3(98.17,146.74) ; 83.81,145.91 UV14.1
  IN1 w0.102: v3(137.36,141.37) 136.98,141.37 133.14,145.21 131.63,145.21 130.93,145.91 124.44,145.91 123.5,146.85 122.63,146.85 121.73,147.75 118.61,147.75 117.98,148.38 117.98,149.66 117.03,150.61 114.94,150.61 112.71,152.83 104.23,152.83 98.17,146.77 v3(98.17,146.74)
  IN4 w0.089: v3(176.91,132.96) 174.24,132.96 173.99,133.21 170.37,133.21 170.29,133.3 164.45,133.3 164.15,133 164.15,129.93 164.03,129.8 164.03,128.06 162.06,126.09
  IN4 w0.102: v3(164.04,111.34) 163.21,112.18 163.21,115.25 162.27,116.19 162.27,118.52 161.93,118.86 161.93,120.96 161.16,121.72 160.72,121.72 159.8,122.64 159.8,125.14 160.75,126.09 162.06,126.09
  BOTTOM w0.089: UH1.A12 175.88,132.96 v3(176.91,132.96)
  BOTTOM w0.102: v3(137.36,141.37) 139.35,141.37 139.92,140.8 139.92,134.39 144.95,129.36 144.95,122.17 155.77,111.34 v3(164.04,111.34)
DGPU_PEX_RST: length 42.6
  TOP w0.102: v3(78.55,145.34) 78.55,145.65 79.44,146.54 79.44,148.58 80.03,149.17 v1(80.58,149.17) RV29.2 83.19,148.65 83.19,147.99 83.37,147.82 84.2,147.82 84.46,148.08 84.46,148.52 84.65,148.71 UV14.4 ; v3(91.19,126.67) 90.81,127.06 D71.1
  IN1 w0.102: v3(78.55,145.34) 81.09,142.8 81.09,128.98 82.39,127.69 87.07,127.69 88.09,126.67 v3(91.19,126.67)
  BOTTOM w0.102: v3(78.55,145.34) 77.97,145.93 RV18.1
DGPU_PEX_RST_R: length 5.8
  BOTTOM w0.102: v1(76.56,147.3) 77.05,147.79 78.4,147.79 RV18.2 78.88,146.34 79.78,145.44 UV1.AL27
DGPU_PWR_EN: length 184.3
  TOP w0.254: PR681.1 106.24,134.42 105.92,134.1 105.92,130.36 106.17,130.1 106.17,124.83 v1(104.49,123.15) 103.51,122.16 v3(103.51,119.56) ; PR600.1 14.9,144.71 14.67,144.48 v3(14.67,144.4)
  IN1 w0.254: v3(103.51,119.56) 100.9,119.56 99,117.66 95.19,117.66 94.11,116.58 92.29,116.58 91.2,115.49 91.2,110.78 92.79,109.19 92.79,93.03 89.22,89.46 80.01,89.46 79.45,90.02 59.52,90.02 58.07,91.47 54.26,91.47 49.44,96.28 49.44,120.98 50.5,122.04 v3(50.93,122.04)
  IN3 w0.254: v3(14.67,144.4) 14.78,144.4 18.17,141.02 21.84,141.02 22.52,141.7 27.94,141.7 28.27,141.37 31.88,141.37 32.61,140.63 34.99,140.63 38.23,137.39 42.1,137.39 45.11,134.38 45.74,134.38 47.04,133.08 47.04,130.4 50.93,126.52 v3(50.93,122.04)
  BOTTOM w0.254: PR688.1 PR697.2 PR692.2 103.51,120.34 v3(103.51,119.56) 103.44,119.5 PQ610.1
DGPU_PWR_EN#: length 223.8
  TOP w0.102: QV6.2 100.48,92.43 RV82.2 v2(101.79,92.43) ; QV6.2 98.15,93.41 98.15,95.94 98.48,96.27 QV5.3 ; QV6.2 98.39,91.7 92.65,91.7 92.26,92.09 90.26,92.09 89.69,91.52 v3(89.69,90.86)
  IN2 w0.127: v3(178.37,132.51) 178.94,132.51 179.71,131.75 179.71,126.95 180.64,126.02 185.53,126.02 186.03,125.51 186.03,123.28 185.37,122.62 185.37,112.55 184.48,111.66 184.48,100.88 183.5,99.91 183.5,96 183.5,96 183.5,94.92 183.5,94.92 183.5,90.89 184.59,89.81 184.59,89.01 183.72,88.14 183.72,82.69 179.72,78.69 179.72,76.95 179,76.23 v3(178.05,76.23)
  IN3 w0.127: v3(89.6,78.29) 89.97,77.92 89.97,76.44 89.33,75.81 89.33,64.08 91.74,61.67 106.53,61.67 116.21,52 143.57,52 151.37,59.79 156.58,59.79 173.26,76.47 177.81,76.47 v3(178.05,76.23)
  BOTTOM w0.089: UH1.C12 175.01,132.77 175.45,132.77 175.47,132.76 175.47,132.76 175.65,132.58 176.34,132.58 176.4,132.51 ; 179.38,132.51 178.44,132.51
  BOTTOM w0.102: RH328.2 180.65,132.51 179.38,132.51 ; 178.44,132.51 v3(178.37,132.51) 176.4,132.51
  BOTTOM w0.254: v3(89.6,78.29) 88.71,79.17 88.71,80.38 89.43,81.1 89.43,90.6 v3(89.69,90.86)
DGPU_PWR_EN#_Q: length 65.6
  TOP w0.102: CV411.1 94.24,115.08 v3(94.48,114.84) 95.21,114.1 QV12.2 95.21,113.16 95.49,112.88 v2(95.49,110.42) 95.49,97.35 QV5.1 QV6.1 97.22,92.58 96.95,92.31 RV81.1 95.75,92.31 95.62,92.43 QV2.2 94.77,92.43 94.35,92.01 94.25,92.01 94.24,92 92.97,92 92.65,92.32 89.73,92.32 87.7,90.29 87.7,85.08 87.25,84.64 85.35,84.64 84.96,85.02 84.96,85.84 82.86,87.95 82.37,87.95 80.84,89.49 80.84,90.92 80.44,91.32 QV11.2
  BOTTOM w0.102: PR697.1 101.73,121.47 101.04,120.78 101.04,119.17 100.72,118.85 PQ610.2 98.49,118.85 v3(94.48,114.84)
DGPU_PWROK: length 310.7
  TOP w0.102: U46.A56 185.62,61.77 v3(185.8,61.59) ; RPH15.4 174.62,120.21 174.69,120.13 174.82,120.13 175.07,120.38 v3(175.41,120.38)
  TOP w0.254: v3(18.92,143.18) PR629.1
  IN2 w0.127: v3(58.13,149.6) 58.09,149.56 58.09,139.97 56.07,137.95 56.07,137.48 54.04,135.45 54.04,125.78 v3(54.28,125.54) ; v3(185.8,61.59) 184.67,62.72 181.45,62.72 180.66,63.51 180.66,64.46 178.4,66.72 178.4,67.08 177.46,68.02 177.46,72.33 176.43,73.36 176.43,77.24 181.03,81.83 181.03,90 181.95,90.93 181.95,104.73 181.73,104.96 181.73,108.15 176.04,113.83 176.04,119.54 175.41,120.17 v3(175.41,120.38)
  IN3 w0.089: 155.67,132.13 156.31,131.49 158.79,131.49 159.1,131.18 160.02,131.18 160.72,131.88 162.1,131.88 162.6,132.39 162.88,132.39 163.62,133.13 170.37,133.13 170.46,133.04 171.93,133.04 172.12,133.23 174.9,133.23 175.39,133.72 178.44,133.72 178.81,133.35 v3(178.91,133.35)
  IN3 w0.127: v3(58.13,149.6) 67.57,149.6 70.99,146.17 80.12,146.17 80.8,146.84 80.8,147.67 81.64,148.52 85.89,148.52 86.39,149.02 102.87,149.02 109,155.15 125.58,155.15 127.1,153.63 132.85,153.63 133.72,152.76 135.85,152.76 136.14,152.47 138.52,152.47 144.11,146.88 144.11,138.79 150.77,132.13 155.67,132.13
  IN4 w0.089: 179.22,131.49 179.22,133.04 v3(178.91,133.35)
  IN4 w0.102: 179.22,131.49 179.22,130.37 176.68,127.84 176.68,127.17 176.47,126.96 176.47,122.86 175.39,121.78 175.39,120.4 v3(175.41,120.38) ; v3(18.92,143.18) 18.43,142.69 18.43,141.44 18.95,140.92 20.85,140.92 21.49,141.56 28.04,141.56 28.39,141.21 29.25,141.21 32.48,144.44 36.46,144.44 37.7,143.21 37.7,140.25 40.57,137.38 42.08,137.38 44.8,134.65 45.58,134.65 46.72,133.51 46.72,132.73 53.91,125.54 v3(54.28,125.54)
  BOTTOM w0.089: UH1.C14 174.99,133.78 175.47,133.78 175.68,133.99 176.07,133.99 176.15,133.91 176.82,133.91
  BOTTOM w0.102: v3(178.91,133.35) 178.35,133.91 176.82,133.91 ; v3(18.92,143.18) 18.92,142.8 v1(18.29,142.17)
DH_1.35V: length 11.8
  IN1 w1.016: 161.29,88.06 171.58,88.06 172.02,87.62
  BOTTOM w0.102: v1(174.44,86.35) 174.37,86.41 v3(174.37,87.18)
  vias: v3(160.71,87.18) v3(161.29,87.18) v3(173.86,87.56)
DIMM1_SA0: length 3.5
  TOP w0.102: v3(152.59,33.84) 152.4,34.03 v1(152.4,34.34) 152.4,35.09 152.54,35.23 RD6.2
  BOTTOM w0.102: v3(152.59,33.84) 152.64,33.88 JDIMM1.197
DIMM1_SA1: length 5.9
  TOP w0.102: RD7.2 152.88,32.53 152.81,32.53 v3(152.59,32.31) 153.04,31.87 v1(153.54,31.87)
  BOTTOM w0.102: v3(152.59,32.31) 152.91,32.31 153.84,33.24 JDIMM1.201
DIMM2_SA0: length 3.9
  TOP w0.102: RD11.1 152.66,23.85 v3(152.64,23.87) 152.27,23.87 v1(151.58,24.56)
  BOTTOM w0.102: JDIMM2.197 v3(152.64,23.87)
DIMM2_SA1: length 4.9
  TOP w0.102: v3(154.18,20.69) 154.18,19.71 RD12.1 153.43,17.88 v1(153.58,17.73)
  BOTTOM w0.102: v3(154.18,20.69) 154.18,20.82 153.84,21.16 JDIMM2.201
DIS_BAT_PROCHOT#: length 82.7
  TOP w0.102: U46.B51 180.85,63.81 180.41,63.36 180.41,63.35 179.59,62.54 v3(179.59,62.54)
  TOP w0.254: PR812.1 228.79,84.7 229.26,85.17 v1(231.65,85.17) v3(233.75,85.17)
  IN3 w0.127: v3(179.59,62.54) 180.2,63.15 180.7,63.15 181.3,62.55 192.19,62.55 192.85,63.21 195.54,63.21 196.29,63.97 203.23,63.97 204.72,62.48 207.72,62.48 208.5,63.26 217.74,63.26 217.98,63.5 225.92,63.5 230.57,68.15 230.57,69.54 235.08,74.05 235.08,80.72 233.75,82.05 v3(233.75,85.17)
DISP_ON: length 11.7
  TOP w0.102: R1138.1 217.67,161.07 D10.1 216.64,161.6 216.4,161.84 v3(216.4,162.46)
  BOTTOM w0.102: JLVDS1.9 217.54,169.6 217.1,169.15 217.1,168.39 215.23,166.52 215.23,163.63 v1(215.88,162.98) v3(216.4,162.46)
DK_AC_OFF: length 256.4
  TOP w0.254: PD815.3 v3(173.68,23.37) ; v3(39.32,146.21) PU800.25
  IN3 w0.254: v3(173.68,23.37) 166.8,23.37 158.37,31.8 158.37,38.44 155.06,41.75 93.31,41.75 91.14,39.58 82.64,39.58 77.47,44.74 77.47,57.03 82.99,62.55 82.99,84.55 78.79,88.75 49.07,88.75 43.56,94.26 43.56,105.59 47.12,109.15 47.12,124.88 46.8,125.2 46.8,126.29 40.67,132.42 40.67,134.24 v3(38.99,135.92)
  BOTTOM w0.254: v3(39.32,146.21) 39.32,145.85 37.31,143.83 v1(37.31,142.93) 37.31,137.84 38.99,136.16 v3(38.99,135.92)
DK_AC_OFF_EN: length 2.4
  TOP w0.254: PR857.1 41.15,147.11 v3(41.15,146.68) 41.15,146.43 40.82,146.1 PU800.22
DK_CSS_GC: length 147.1
  TOP w0.102: PR709.2 147.54,162.42 v1(148.72,162.42)
  TOP w0.254: PU800.11 43.79,140.73 44.45,140.07 v3(44.45,139.69) ; PR709.2 146.71,163.62 147.04,163.95 v3(147.32,163.95)
  IN1 w0.254: v3(146.8,144.74) 146.08,145.46 146.08,150.04 141.54,154.57 141.54,157.6 142.49,158.54 144.2,158.54 147.32,161.66 v3(147.32,163.95)
  IN2 w0.254: v3(44.45,139.69) 45.59,139.69 46.61,140.71 51.63,140.71 53.47,142.55 53.47,148.55 55.51,150.59 61.99,150.59 65.36,147.22 78.4,147.22 80.21,149.03 80.51,149.03 81.86,150.39 89.89,150.39 90.74,149.53 109.88,149.53 111.79,151.44 130.89,151.44 132.39,149.94 139.85,149.94 145.06,144.74 v3(146.8,144.74)
DK_PWRBAR: length 5.2
  TOP w0.102: PR832.1 34.24,143.94 v2(33.34,143.94)
  TOP w0.254: PU800.33 36.32,141.73 36.31,141.75 36.12,141.75 35.84,142.03 35.84,142.34 PR832.1
DL_1.35V: length 8.7
  IN4 w1.016: 166.37,88.26 167.01,88.89 173.86,88.89
  BOTTOM w0.102: v3(175.33,88.57) 175.64,88.57 v1(176.09,88.13)
  vias: v3(165.98,87.05) v3(166.56,87.05) v3(175.01,89.08)
DMI_CRX_PTX_N0: length 57
  IN4 w0.089: v3(142.47,95.2) 142.88,94.79 143.77,94.79 143.88,94.9 143.88,96.57 144.12,96.81 144.61,96.81 145.66,97.86 145.95,97.86 145.97,97.88 146.11,98.02 146.15,98.06 146.15,98.08 146.17,98.1
  IN4 w0.114: 146.17,98.1 148.53,100.46 148.53,113.99 147.82,114.7 147.82,132.74 151.33,136.26 152.85,136.26 153.1,136 153.1,135.79 153.32,135.57 v3(153.47,135.57)
  BOTTOM w0.089: UH1.BD21 157.78,136.52 157.85,136.45 157.85,136.3 157.75,136.2 157.51,136.2 157.28,136.43 156.39,136.43 156.26,136.57 155.59,136.57 ; v3(142.47,95.2) JCPU1.D21
  BOTTOM w0.102: 155.59,136.57 154.57,136.57 154.48,136.48 153.28,136.48 152.96,136.16 152.96,135.93 153.15,135.74 153.15,135.63 153.21,135.57 v3(153.47,135.57)
DMI_CRX_PTX_N1: length 55.8
  IN4 w0.089: v3(143.47,96.2) 143.58,96.2 143.69,96.09 143.69,95.63 143.63,95.57 143.38,95.57 143.07,95.89 143.07,97.49 143.17,97.6 145.06,97.6 146.3,98.84 146.31,98.84 146.33,98.85
  IN4 w0.114: 146.33,98.85 148.11,100.63 148.11,113.81 147.4,114.53 147.4,132.92 151.19,136.71 153.1,136.71 153.58,136.22 154.21,136.22 154.38,136.05 154.38,135.73 154.23,135.57 v3(154.06,135.57)
  BOTTOM w0.089: v3(143.47,96.2) 143.47,96.15 143.05,95.73 JCPU1.C21 ; UH1.BE20 157.08,136.03 156.47,136.03 156.24,136.25 155.67,136.25
  BOTTOM w0.102: 155.67,136.25 155.23,136.25 154.97,135.99 154.61,135.99 154.37,135.75 154.19,135.57 v3(154.06,135.57)
DMI_CRX_PTX_N2: length 52.6
  IN4 w0.089: v3(144.47,96.2) 144.47,95.78 144.58,95.67 144.74,95.67 144.89,95.82 144.89,96.46 145.46,97.03 146.29,97.03 146.31,97.04 146.33,97.04
  IN4 w0.114: v3(151.56,135.57) 151.74,135.39 151.74,135.12 148.46,131.84 148.46,114.97 149.18,114.26 149.18,99.76 146.46,97.04 146.33,97.04
  BOTTOM w0.089: 155.95,134.72 155.97,134.72 155.98,134.72 156.91,134.72 156.99,134.81 157.28,134.81 157.51,134.58 157.64,134.58 157.76,134.7 157.76,134.83 157.69,134.89 UH1.BD17 ; v3(144.47,96.2) 144,95.73 JCPU1.B21
  BOTTOM w0.102: v3(151.56,135.57) 151.93,135.2 151.93,134.98 152.19,134.72 155.95,134.72
DMI_CRX_PTX_N3: length 55.7
  IN4 w0.114: v3(155.43,135.57) 155.63,135.37 155.63,135.24 155.53,135.14 152.68,135.14 149.11,131.57 149.11,115.73 150.24,114.6 150.24,113.71 155.79,108.15 155.79,104.6 152.41,101.21 151.54,101.21 145.96,95.63 145.49,95.63 145.37,95.76 145.37,96.09 v3(145.47,96.2)
  BOTTOM w0.089: JCPU1.A21 145,95.73 v3(145.47,96.2) ; UH1.BE18 157.05,135.45 156.54,135.45 156.28,135.19 155.94,135.19 155.67,135.46
  BOTTOM w0.102: v3(155.43,135.57) 155.55,135.57 155.67,135.46
DMI_CRX_PTX_P0: length 57.2
  IN4 w0.089: v3(142.47,94.2) 142.38,94.29 142.38,94.63 142.48,94.73 142.65,94.73 142.79,94.59 143.86,94.59 144.08,94.81 144.08,96.48 144.2,96.61 144.7,96.61 145.74,97.65 146.03,97.65 146.3,97.92 146.31,97.92 146.33,97.93
  IN4 w0.114: 146.33,97.93 148.76,100.37 148.76,114.08 148.05,114.8 148.05,132.65 151.43,136.03 152.75,136.03 152.87,135.91 152.87,135.69 v3(152.75,135.57)
  BOTTOM w0.089: 155.59,136.78 155.61,136.78 155.61,136.77 155.68,136.77 155.68,136.77 156.34,136.77 156.48,136.63 157.29,136.63 157.48,136.82 157.8,136.82 158.08,136.54 UH1.BB21 ; v3(142.47,94.2) JCPU1.D20
  BOTTOM w0.102: v3(152.75,135.57) 152.75,136.25 153.19,136.69 154.4,136.69 154.48,136.78 155.59,136.78
DMI_CRX_PTX_P1: length 56
  IN4 w0.089: 146.17,99.01 146.15,99 146.15,98.98 144.97,97.8 143.09,97.8 142.87,97.57 142.87,95.8 v3(143.47,95.2)
  IN4 w0.114: 146.17,99.01 147.88,100.73 147.88,113.72 147.17,114.43 147.17,133.01 151.09,136.93 153.19,136.93 153.67,136.45 154.31,136.45 154.61,136.15 154.61,135.73 v3(154.77,135.57)
  BOTTOM w0.089: 155.67,136.04 155.68,136.04 155.69,136.05 155.75,136.05 155.76,136.06 156.16,136.06 156.22,136 156.39,135.83 157.31,135.83 157.49,136.02 157.97,136.02 UH1.BC20 ; v3(143.47,95.2) 143,94.73 JCPU1.C20
  BOTTOM w0.102: 155.67,136.04 155.32,136.04 155.06,135.78 154.98,135.78 v3(154.77,135.57)
DMI_CRX_PTX_P2: length 52.7
  IN4 w0.089: 146.33,96.81 146.32,96.81 146.31,96.83 145.54,96.83 145.1,96.38 145.1,95.74 144.56,95.2 v3(144.47,95.2)
  IN4 w0.114: v3(152.14,135.57) 151.97,135.4 151.97,135.02 148.69,131.75 148.69,115.06 149.41,114.35 149.41,99.67 146.55,96.81 146.33,96.81
  BOTTOM w0.089: v3(144.47,95.2) 144,94.73 JCPU1.B20 ; UH1.BB17 158.43,134.99 157.99,134.99 157.96,135.02 157.96,135.02 157.79,135.19 157.49,135.19 157.31,135.01 156.91,135.01 156.83,134.92 155.98,134.92 155.97,134.93 155.95,134.93
  BOTTOM w0.102: v3(152.14,135.57) 152.14,135.06 152.28,134.93 155.95,134.93
DMI_CRX_PTX_P3: length 55.7
  IN4 w0.114: v3(145.47,95.2) 145.68,95.41 146.06,95.41 151.63,100.98 152.5,100.98 156.02,104.5 156.02,108.24 150.46,113.8 150.46,114.7 149.34,115.82 149.34,131.48 152.78,134.91 155.63,134.91 155.86,135.14 155.86,135.46 155.96,135.57 v3(156.09,135.57)
  BOTTOM w0.089: UH1.BC18 158,135.4 157.53,135.4 157.28,135.65 156.17,135.65 v3(156.09,135.57) ; JCPU1.A20 145,94.73 v3(145.47,95.2)
DMI_CTX_PRX_N0: length 62.4
  IN4 w0.089: v3(141.47,92.2) 141.59,92.32 141.59,92.79 141.88,93.08 141.88,97.43 143.24,98.78 143.65,98.78 144.12,99.25 144.12,99.27 144.16,99.31 144.16,99.32 144.18,99.34
  IN4 w0.102: v3(159.96,136.58) 159.96,136.58 159.59,136.95 159.18,136.95 158.9,136.67 155.87,136.67 155.86,136.66 155.82,136.66 155.79,136.66
  IN4 w0.114: 155.79,136.66 155.24,136.66 154.78,137.12 153.93,137.12 153.45,137.59 150.83,137.59 146.52,133.28 146.52,126.21 146.05,125.73 146.05,114.64 147.24,113.45 147.24,101 145.86,99.62 144.46,99.62 144.18,99.34
  BOTTOM w0.089: JCPU1.D18 141.47,92.26 v3(141.47,92.2) ; v3(159.96,136.58) 159.96,136.58 159.71,136.83 UH1.AW22
DMI_CTX_PRX_N1: length 64.6
  IN4 w0.089: 155.67,134.27 155.86,134.27 156.65,135.06 157.36,135.06 158.25,135.95 161.46,135.95 161.55,135.86 161.55,135.72 161.4,135.57 v3(161.26,135.57) ; v3(143.47,92.2) 143.47,92.61 143.59,92.72 143.87,92.72 144.07,92.93 144.07,93.36 144.3,93.59 146.29,93.59 146.31,93.58 146.33,93.58
  IN4 w0.114: 146.33,93.58 146.41,93.58 147.36,94.52 147.36,95.79 151.9,100.33 152.77,100.33 156.67,104.23 156.67,108.51 151.11,114.07 151.11,114.97 149.99,116.09 149.99,131.21 153.05,134.27 155.67,134.27
  BOTTOM w0.089: v3(143.47,92.2) 143,91.73 JCPU1.C17 ; UH1.AR20 161.26,135.83 v3(161.26,135.57)
DMI_CTX_PRX_N2: length 63.8
  IN4 w0.089: v3(162.55,134.62) 162.31,134.38 162.31,134.31 162,134 159.17,134 157.18,132.01 156.26,132.01 156.26,132 156.19,132 156.18,131.99 156.17,131.99 ; v3(144.47,92.2) 144.47,92.37 144.61,92.5 144.79,92.5 144.86,92.43 144.86,91.86 145.16,91.56 146.29,91.56 146.31,91.55 146.33,91.55
  IN4 w0.114: 146.33,91.55 146.49,91.55 148.66,93.71 148.66,94.39 157.97,103.7 157.97,109.05 152.41,114.61 152.41,115.5 151.32,116.59 151.32,130.59 152.72,131.99 156.17,131.99
  BOTTOM w0.089: v3(162.55,134.62) 162.1,135.07 UH1.AP17 ; JCPU1.B17 144,91.73 v3(144.47,92.2)
DMI_CTX_PRX_N3: length 60.8
  IN4 w0.089: v3(159.95,135.58) 159.78,135.41 159.78,135.2 159.56,134.98 159.06,134.98 158.99,134.9 158.16,134.9 158.06,134.9 158,134.84 157.93,134.84 157.92,134.82 157.91,134.82
  IN4 w0.114: v3(145.47,92.2) 145.81,92.54 146.57,92.54 148.01,93.98 148.01,95.52 150.65,98.16 151.51,98.16 157.32,103.96 157.32,108.78 151.76,114.34 151.76,115.24 150.64,116.36 150.64,130.88 152.4,132.64 156.97,132.64 157.81,133.48 157.81,134.73 157.91,134.82
  BOTTOM w0.089: v3(159.95,135.58) 159.95,135.71 UH1.AV20 ; v3(145.47,92.2) 145,91.73 JCPU1.A17
DMI_CTX_PRX_P0: length 62.4
  IN4 w0.089: 144.34,99.18 143.74,98.58 143.32,98.58 142.08,97.34 142.08,92.99 141.8,92.71 141.8,92.38 141.85,92.33 141.85,92 142.04,91.81 142.37,91.81 142.47,91.91 v3(142.47,92.2)
  IN4 w0.102: v3(159.36,136.57) 159.24,136.45 155.96,136.45 155.95,136.45 155.88,136.45 155.88,136.44 155.82,136.44 155.81,136.43 155.79,136.43
  IN4 w0.114: 155.79,136.43 155.15,136.43 154.69,136.89 153.83,136.89 153.35,137.37 150.93,137.37 146.75,133.19 146.75,126.11 146.27,125.64 146.27,114.73 147.46,113.54 147.46,100.9 145.96,99.39 144.55,99.39 144.34,99.18
  BOTTOM w0.089: v3(159.36,136.57) 159.36,136.8 UH1.AY22 ; v3(142.47,92.2) 142,91.73 JCPU1.D17
DMI_CTX_PRX_P1: length 64.5
  IN4 w0.089: v3(161.91,135.57) 161.76,135.72 161.76,135.94 161.54,136.16 158.17,136.16 157.27,135.26 156.57,135.26 155.8,134.5 155.67,134.5 ; 146.32,93.81 146.31,93.79 144.21,93.79 143.87,93.45 143.87,93.01 143.78,92.93 143.59,92.93 143.47,93.04 v3(143.47,93.2)
  IN4 w0.114: 155.67,134.5 152.95,134.5 149.76,131.31 149.76,116 150.88,114.87 150.88,113.98 156.44,108.42 156.44,104.33 152.68,100.56 151.81,100.56 147.13,95.88 147.13,94.62 146.32,93.81
  BOTTOM w0.089: UH1.AP20 161.91,135.88 v3(161.91,135.57) ; v3(143.47,93.2) 143,92.73 JCPU1.C18
DMI_CTX_PRX_P2: length 63.7
  IN4 w0.089: 156.17,132.22 156.18,132.22 156.19,132.21 157.09,132.21 159.09,134.21 161.92,134.21 162.04,134.33 162.04,134.46 v3(161.9,134.6) ; 146.33,91.78 146.31,91.78 146.29,91.76 145.25,91.76 145.07,91.94 145.07,92.51 144.87,92.7 144.5,92.7 144.38,92.83 144.38,93.1 v3(144.47,93.2)
  IN4 w0.114: 146.33,91.78 146.4,91.78 148.43,93.8 148.43,94.48 157.74,103.79 157.74,108.96 152.18,114.51 152.18,115.41 151.09,116.5 151.09,130.69 152.63,132.22 156.17,132.22
  BOTTOM w0.089: v3(161.9,134.6) 161.9,134.69 UH1.AR17 ; JCPU1.B18 144,92.73 v3(144.47,93.2)
DMI_CTX_PRX_P3: length 60.8
  IN4 w0.089: v3(159.3,135.58) 159.48,135.58 159.58,135.48 159.58,135.28 159.48,135.18 158.98,135.18 158.9,135.11 158.16,135.11 157.98,135.11 157.91,135.04 157.82,135.04 157.77,134.99 157.75,134.99 157.74,134.99
  IN4 w0.114: 157.74,134.99 157.59,134.83 157.59,133.58 156.88,132.87 152.3,132.87 150.41,130.97 150.41,116.26 151.53,115.14 151.53,114.24 157.09,108.69 157.09,104.06 151.42,98.39 150.55,98.39 147.78,95.62 147.78,94.07 146.47,92.77 145.9,92.77 145.6,92.77 145.47,92.9 v3(145.47,93.2)
  BOTTOM w0.089: JCPU1.A18 145,92.73 v3(145.47,93.2) ; v3(159.3,135.58) 159.3,135.66 UH1.AW20
DMI_IREF: length 4.1
  TOP w0.254: v3(155.92,133.8) 155.54,134.18 RH98.1
  BOTTOM w0.102: v3(155.92,133.8) 155.12,133.8 v1(154.66,133.34)
  BOTTOM w0.254: v3(155.92,133.8) 156.48,134.36 157.03,134.36 UH1.BE16
DMI_RCOMP: length 5.4
  TOP w0.089: RH100.2 v1(157.35,132.26) 157.84,132.26 158.94,133.36 158.94,134.24 v3(159.3,134.6)
  BOTTOM w0.254: UH1.AY17 159.3,134.9 v3(159.3,134.6)
DMIC0: length 45
  TOP w0.102: U74.4 267.16,158.47 v3(267.08,158.38)
  IN1 w0.102: v3(267.08,158.38) 266.34,158.38 265.78,157.83 262.61,157.83 260.25,155.47 256.48,155.47 255.36,154.35 253.86,154.35 250.5,150.99 248.86,150.99 248.52,150.64 248.52,150.4 v3(248.72,150.2)
  BOTTOM w0.102: JCAM1.7 234.21,159.55 233.4,158.74 233.4,158.39 235.43,156.37 236.57,156.37 241.02,151.92 241.52,151.92 242.48,150.97 248.25,150.97 248.54,150.68 248.54,150.37 v3(248.72,150.2)
DMIC_CLK: length 44.5
  TOP w0.102: L13.2 v3(266.27,158.96)
  IN1 w0.102: v3(266.27,158.96) 265.61,158.3 262.75,158.3 260.16,155.7 256.39,155.7 255.27,154.58 253.76,154.58 250.41,151.22 248.77,151.22 248.29,150.74 248.29,150.35 v3(248.13,150.2)
  BOTTOM w0.102: v3(248.13,150.2) 248.31,150.37 248.31,150.58 248.15,150.74 v4(245.37,150.74) 242.38,150.74 241.43,151.69 240.92,151.69 236.48,156.14 235.33,156.14 233.17,158.3 233.17,158.74 232.21,159.7 JCAM1.5
DMIC_CLK_L: length 2.6
  TOP w0.102: U74.2 266.81,159.47 v1(266.74,159.54) 266.57,159.71 L13.1
DOCK_AC_OFF: length 197.4
  TOP w0.254: v3(169.94,21.72) 169.98,21.68 PR844.1 170.92,22 PD815.1
  IN2 w0.127: v3(169.94,21.72) 165.9,21.72 161.23,26.39 161.23,51.55 157.51,55.27 157.51,78.53 153.1,82.93 153.1,89.45 151.65,90.9 151.65,97.07 148.01,100.71 148.01,107.74 150.28,110.01 150.28,115.57 148.46,117.39 148.46,135.54 143.26,140.74 143.26,143.85 137.87,149.24 131.95,149.24 131.25,149.94 128.61,149.94 127.59,148.92 121.94,148.92 120.12,147.1 v3(119.39,147.1)
  BOTTOM w0.102: v3(119.39,147.1) 119.38,147.1 118.86,147.61 118.86,150.86 116.99,152.73 v1(116.99,153.41) 116.99,161.31 117.31,161.62 117.31,162.25 119.36,164.3 121.89,164.3 122.43,164.84 122.43,165.6 121.54,166.49 118.81,166.49 117.84,167.46 JDOCK1.2
DOCK_AC_OFF_EC: length 241.2
  TOP w0.102: v3(188.84,61.69) 189.12,61.96 U46.A63
  TOP w0.254: v3(40.96,148.83) PR857.2 PR858.1
  IN3 w0.127: v3(188.84,61.69) 188.84,61.14 188.22,60.52 187.64,60.52 187.07,59.95 187.07,59.25 183.03,55.21 170.51,55.21 169.42,54.12 162.97,54.12 160.59,51.74 152.79,51.74 150.63,49.58 115.21,49.58 105.53,59.26 90.31,59.26 86.92,62.65 86.92,80.17 87.62,80.87 87.62,86.68 86.36,87.94 83.64,87.94 79.28,92.29 78.5,92.29 77.82,91.6 68.09,91.6 67.4,92.29 53.46,92.29 48.4,97.36 48.4,125.94 41.73,132.61 v3(41.73,133.19)
  BOTTOM w0.254: v3(41.73,133.19) 39.75,135.17 39.75,135.93 37.69,137.99 37.69,141.75 39.88,143.94 v1(39.88,145.15) 39.88,147.75 v3(40.96,148.83)
DOCK_DCIN_IS+: length 7.3
  TOP w0.102: v3(152.73,167.65) 153.09,167.3 153.09,167.12 152.93,166.96 151.9,166.96 v4(151.62,166.68) 151.14,166.2 151.14,165.9 150.85,165.6 150.71,165.6 150.64,165.67 150.64,166.36 150.51,166.48 PQ703.6
  BOTTOM w0.102: JDOCK1.134 152.84,168.35 152.98,168.21 152.98,167.89 v3(152.73,167.65)
DOCK_DCIN_IS-: length 7.3
  TOP w0.102: v3(153.32,167.65) 153.32,167.02 153.02,166.73 152,166.73 151.37,166.11 151.37,165.8 150.94,165.37 150.78,165.37 150.61,165.2 150.61,164.75 150.45,164.58 PQ703.4
  BOTTOM w0.102: JDOCK1.136 153.34,168.33 153.2,168.19 153.2,167.77 v3(153.32,167.65)
DOCK_DET#: length 208.4
  TOP w0.102: U46.B41 181.93,68.81 v3(181.97,68.85) ; v3(154.24,154.56) v1(155.02,154.56)
  TOP w0.254: v3(187.14,47.93) 187.14,48.63 187.82,49.31 PQ817.2 ; PU808.2 177.23,19.52 176.9,19.85 176.9,21.21 v3(176.46,21.66) ; PR886.2 191.17,39.22 v3(191.17,40.12) PR887.2
  IN1 w0.102: v3(181.97,68.85) 181.97,68.61 181.36,68 181.36,66.6 181.68,66.28 183.18,66.28 184.32,65.14 184.78,65.14 185.2,64.73 185.2,63.64 186.34,62.5 187.55,62.5 187.83,62.22 189.58,62.22 189.99,61.81 189.99,60.02 191.07,58.94 191.07,58.47 192.18,57.37 192.18,53.29 187.14,48.25 v3(187.14,47.93)
  IN2 w0.127: v3(181.97,68.85) 180.79,70.03 180.79,72.43 180.48,72.74 180.48,75.04 184.93,79.49 186.23,79.49 187.48,80.74 187.48,86.42 188.03,86.97 188.03,93.47 190.86,96.29 190.86,104.3 190.65,104.5 190.65,120.41 191.43,121.19 191.43,131.21 193.68,133.46 193.68,139.04 193.3,139.42 193.06,139.42 191.48,141 191.48,145.31 187.96,148.83 181.61,148.83 179.95,150.49 177.42,150.49 176.7,151.21 164.59,151.21 162.94,152.85 156.51,152.85 154.8,154.56 v3(154.24,154.56)
  IN2 w0.254: v3(176.46,21.66) 176.46,29.89 180.57,34 185.05,34 v3(191.17,40.12) 190.63,40.67 190.63,43.83 189.89,44.57 185.57,44.57 184.86,45.28 184.86,47.18 185.61,47.93 v3(187.14,47.93)
  BOTTOM w0.102: R755.1 D32.2 v3(154.24,154.56)
DOCK_DET_R#: length 19.8
  TOP w0.102: v3(153.61,154.28) 153.07,154.82 v1(153.07,155.46) 153.07,158.77 151.45,160.4 151.45,162.85 153.54,164.94 153.54,166.41 v3(155.13,168.01)
  BOTTOM w0.102: D32.1 153.33,154.56 v3(153.61,154.28) ; JDOCK1.142 154.84,168.3 v3(155.13,168.01) 155.34,168.22 JDOCK1.144
DOCK_HP_DET: length 189.7
  TOP w0.102: U46.A7 191.77,67.06 v3(192.09,67.38)
  IN1 w0.102: v3(242.03,69.56) 236.96,69.56 236.16,68.76 236.16,68.25 235.14,67.24 230.19,67.24 229.59,66.64 222.46,66.64 222.24,66.42 221,66.42 220.42,67.01 214.58,67.01 211.77,64.2 204.99,64.2 203.81,65.38 194.83,65.38 193.36,66.86 192.36,66.86 192.09,67.12 v3(192.09,67.38)
  IN3 w0.127: v3(284.41,152.98) 284.52,152.87 284.52,151.29 284.04,150.8 275.78,150.8 275.53,150.55 266.07,150.55 264.86,151.76 258.9,151.76 257.18,150.04 254.37,150.04 253.5,149.17 253.5,137.77 249.96,134.23 248.03,134.23 246.32,132.51 246.32,73.85 v3(242.03,69.56)
  BOTTOM w0.102: Q106.2 285.51,151.88 v3(284.41,152.98) 283.84,153.55 282.76,153.55 v1(281.44,154.86) 280.99,155.31 279.03,155.31 277.05,157.29 275.72,157.29 R1081.2
DOCK_LOM_ACTLED_YEL#: length 123.2
  TOP w0.102: U32.19 255.14,178.87 255.56,178.45 v3(255.72,178.45)
  IN1 w0.102: v3(144.59,171.19) 145.74,172.34 185.15,172.34 185.68,171.81 191.32,171.81 191.53,172.01 198.44,172.01 200.15,170.3 202.82,170.3 203.52,169.6 225.17,169.6 226.91,167.86 232.79,167.86 233.58,168.65 236.6,168.65 238.37,170.41 239.33,170.41 239.79,170.87 241.25,170.87 244.9,174.51 244.9,175.66 244.98,175.75 244.98,175.82 v3(244.99,175.83)
  IN2 w0.127: v3(255.72,178.45) 255.47,178.45 254.56,177.55 254.35,177.55 251.9,177.55 250.04,175.69 245.39,175.69 245.13,175.95 245.1,175.95 244.98,175.84 v3(244.99,175.83)
  BOTTOM w0.102: v3(144.59,171.19) 144.07,170.66 144.07,170.3 144.34,170.03 JDOCK1.100 ; v3(244.99,175.83) v1(244.99,176.64)
DOCK_LOM_SPD10LED_GRN#: length 143.4
  TOP w0.102: U32.40 244.98,179.37 v3(244.86,179.25)
  IN1 w0.102: v3(244.86,179.25) 244.29,179.25 243.52,178.49 243.52,175.12 242.57,174.17 242.57,172.84 241.06,171.33 239.6,171.33 239.14,170.87 238.18,170.87 236.41,169.1 233.39,169.1 232.6,168.32 227.1,168.32 225.36,170.06 203.71,170.06 203.01,170.75 200.34,170.75 198.63,172.47 191.34,172.47 191.14,172.26 185.87,172.26 185.34,172.79 145.17,172.79 143.81,171.44 134.42,171.44 130.3,167.31 127.57,167.31 v3(127.38,167.5)
  BOTTOM w0.102: v3(127.38,167.5) 127.38,167.38 125.8,165.79 124.02,165.79 122.05,163.82 119.53,163.82 118.34,162.63 JDOCK1.3 ; v3(244.86,179.25) v1(245.68,179.25)
