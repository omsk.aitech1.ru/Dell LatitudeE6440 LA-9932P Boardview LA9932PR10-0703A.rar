# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SYS_PWROK: length 213
  TOP w0.102: RH85.2 184.47,129.85 v3(184.53,129.91) ; v3(183.94,64.62) 183.94,64.62 184.37,64.2 U46.B57 ; RH102.1 169.48,119.31 169.48,116.59 170.55,115.53 170.55,112.67 171.4,111.81 178.18,111.81 178.36,111.64 181.53,111.64 v1(183.4,113.51) 183.84,113.95 v3(184.06,113.95)
  IN4 w0.102: v3(184.53,129.91) 184.28,129.66 184.28,128.45 184.6,128.13 185.61,128.13 186.84,126.9 186.84,123.84 185.23,122.23 185.23,115.13 v3(184.06,113.95) 184.06,113.18 185.52,111.72 185.52,108.65 185.75,108.42 185.75,103.57 186.6,102.72 186.6,100.6 187.06,100.14 187.5,100.14 188.23,99.41 188.23,95.92 187.72,95.41 187.72,88.68 v3(187.36,88.32) 187.72,87.96 187.72,80.84 186.11,79.23 185.38,79.23 184.96,78.81 184.38,78.81 180.52,74.95 180.52,66.55 181.74,65.33 183.26,65.33 183.71,64.89 183.71,64.86 v3(183.94,64.62)
  BOTTOM w0.102: v3(187.36,88.32) 184.85,88.32 183.26,86.73 181.1,86.73 179.58,85.21 179.58,81.97 178.79,81.18 174.11,81.18 170.69,77.76 170.69,76.14 163.08,68.53 99.41,68.53 97.94,70 97.94,77.52 98.44,78.02 98.44,78.42 97.96,78.91 RC24.1
SYS_PWROK_R: length 14.3
  TOP w0.102: v3(169.43,120.49) 169.93,120.98 v2(170.08,120.98) 170.87,120.2 RH102.2
  IN4 w0.102: v3(165.73,130.26) 165.73,129.34 167.63,127.43 167.63,123.1 168.33,122.4 168.33,122.15 169.43,121.05 v3(169.43,120.49)
  BOTTOM w0.089: v3(165.73,130.26) 165.88,130.26 UH1.AD7
SYS_PWROK_XDP: length 2.7
  BOTTOM w0.102: RC11.2 RC24.2 95.57,78.91 94.89,78.23 JXDP1.13
SYS_RESET#: length 101.7
  TOP w0.102: v3(215.39,119.37) 219.55,115.22 219.55,114.42 221.3,112.66 221.3,110.35 220.11,109.16 220.11,103.93 223.84,100.19 v2(226.35,100.19) 226.98,100.19 227.68,99.49 231.43,99.49 231.52,99.4 JAPS1.13
  IN1 w0.102: v3(164.83,119.54) 164.84,119.56 166.18,119.56 166.63,119.12 166.63,118.67 168.22,117.07 174.83,117.07 175.51,117.76 178.71,117.76 180.31,116.16 196.47,116.16 197.04,116.73 202,116.73 202.3,117.02 206.19,117.02 206.26,116.94 212.27,116.94 213.04,117.71 214.44,117.71 215.39,118.67 v3(215.39,119.37)
  BOTTOM w0.089: 162.24,126.56 162.24,126.86 162.66,127.27 162.66,127.87 UH1.AM1
  BOTTOM w0.102: UC3.4 163.08,118.24 RH66.2 ; 162.24,126.56 161.91,126.22 161.91,125.64 161.73,125.47 161.73,124.13 161.19,123.59 161.19,121.53 162.12,120.6 C1554.1 162.7,118.81 162.86,118.81 RH66.2 ; RH66.2 163.89,119.05 164.33,119.05 v3(164.83,119.54)
SYSPWR_PRES: length 11.7
  TOP w0.102: U51.A59 203.28,77.54 203.07,77.33 201.44,77.33 200.93,77.84 199.28,77.84 R874.1 197.74,76.3 v1(197.47,76.3) 197.18,76.3 195.99,75.11 194.68,75.11 194.4,75.39 RP16.4
SYSTEM_ID: length 4.1
  TOP w0.102: U51.A10 210.43,72.18 210.31,72.06 v1(210.19,72.06) 209.83,72.06 209.5,71.73 209.5,70.82 C742.1 R871.2
TEMP_ALERT#: length 105.5
  TOP w0.102: v3(186.82,133.24) 187.08,132.98 RPH21.7 ; R738.2 v1(195.66,68.82) 196.15,68.82 197.13,69.8 197.13,71.48 195.96,72.65 193.52,72.65 v3(192.57,73.6)
  IN2 w0.089: v3(173.08,130.32) 173.08,130 173.22,129.85 173.22,128.5 173.63,128.09 174.76,128.09 176,126.85 176.4,126.85 176.63,126.62
  IN2 w0.127: 176.63,126.62 177.23,126.02 177.23,124.58 177.74,124.07 177.74,122.1 178.18,121.66 179.58,121.66 180.33,120.91 v3(180.33,120.39)
  IN3 w0.089: v3(173.08,130.32) 173.08,130.89 173.27,131.08 173.89,131.08 174.36,130.61 175.06,130.61 175.6,130.06 178.75,130.06
  IN3 w0.127: 178.75,130.06 179.24,130.06 179.87,130.7 183.15,130.7 183.49,131.04 185.82,131.04 186.82,132.04 v3(186.82,133.24) ; v3(193.04,117.59) 192.91,117.72 188.22,117.72 185.56,120.39 v3(180.33,120.39)
  IN4 w0.102: v3(193.04,117.59) 193.04,114.04 194.39,112.68 194.39,102.25 193.78,101.64 193.78,96.41 192.24,94.87 192.24,91.84 191.45,91.05 191.45,89.73 191.45,87.2 192.13,86.52 192.13,79.99 190.46,78.33 190.46,74.7 191.57,73.6 v3(192.57,73.6)
  BOTTOM w0.089: v3(173.08,130.32) 172.73,129.97 UH1.H6
TEMP_ALERT#_R: length 8.2
  TOP w0.102: R738.1 193.07,69.29 193.07,70.39 v3(193.23,70.55) ; U46.B11 190.02,68.81 v3(189.8,68.6)
  IN3 w0.127: v3(193.23,70.55) 192.78,70.1 191.3,70.1 v3(189.8,68.6)
  BOTTOM w0.102: v3(189.8,68.6) 189.8,68.71 v1(190.58,69.48)
TESTEN: length 15.7
  TOP w0.089: v3(59.18,137.22) 58.49,137.91 RV49.1 58.88,137.99 58.97,137.9 RV41.1 59.91,138.43 v2(60.72,138.43)
  IN1 w0.089: v3(59.18,137.22) 59.19,137.21 59.69,137.21 60.99,135.91 60.99,132.57 63.62,129.95 64.11,129.95 64.52,129.54 64.52,128.93 v3(64.18,128.6)
  BOTTOM w0.1: UV1.K7 v3(64.18,128.6)
THERMATRIP2#: length 6
  TOP w0.102: Q4.1 217.87,85.46 217.79,85.38 R51.2 C18.1 v1(216.54,83.68) 215.5,83.68 214.61,82.79 U51.B34
THERMATRIP3#: length 190
  TOP w0.102: R52.1 206.69,71.99 v3(206.7,72) 206.33,72.36 206.33,72.86 206.43,72.95 U51.A2 ; v3(94.95,112.65) 92.38,112.65 91.1,113.94 QV7.1 91.1,115.71 CV57.1
  IN1 w0.102: v3(94.95,112.65) 95.84,111.76 95.84,104.36 95.49,104.02 95.49,98.87 95.89,98.48 95.89,88.24 91.54,83.9 91.54,67.87 v3(93.77,65.65)
  BOTTOM w0.102: v3(93.77,65.65) 94.08,65.97 142.41,65.97 151.61,56.77 164.48,56.77 166.24,58.54 171.39,58.54 172.28,59.43 176.84,59.43 177.84,58.42 180.23,58.42 181.26,59.45 184.29,59.45 184.9,60.06 184.9,60.47 185.08,60.65 185.08,61.44 186.47,62.83 187.12,62.83 187.76,63.47 189.6,63.47 190.23,64.1 195.68,64.1 196.17,64.59 206.84,64.59 207.84,65.59 v1(207.84,69.52) 207.84,70.86 v3(206.7,72)
THERMTRIP_VGA: length 44.7
  TOP w0.102: RV104.2 RV77.1 RV47.1 v3(91.75,126.43)
  IN1 w0.089: 84.2,127.18 80.31,127.18 78.91,125.77 67.58,125.77 66.7,124.89 63.94,124.89 60.43,128.4 59.22,128.4 58.68,128.95 58.68,131.15 v3(59.42,131.9)
  IN1 w0.102: 84.2,127.18 86.83,127.18 87.85,126.16 91.48,126.16 v3(91.75,126.43)
  BOTTOM w0.089: UV1.M2 60.96,130.6 59.65,131.9 v3(59.42,131.9)
  BOTTOM w0.102: v3(91.75,126.43) v1(91.75,125.82)
THSEL_STRAP: length 6.9
  TOP w0.102: R1069.1 217.17,80.51 v3(217.11,80.57) ; v3(212.93,80.66) 213.42,80.17 213.81,80.17 213.93,80.29 U51.B29
  BOTTOM w0.102: v3(217.11,80.57) 216.6,80.06 215.14,80.06 215.01,80.19 v1(214.57,80.19) 213.4,80.19 v3(212.93,80.66)
TMDSB_CPU_CLK: length 175.4
  TOP w0.102: C352.2 21.07,194.37 21.07,193.69 v3(21.05,193.66)
  IN1 w0.089: 125.86,111.73 125.87,111.72 125.87,111.63 125.87,111.12 125.87,111.12 125.87,107.89 126.14,107.62 126.6,107.62 126.86,107.36 126.86,106.93 127.18,106.62 127.73,106.62 127.9,106.44 127.9,106.25 127.85,106.2 v3(127.47,106.2)
  IN1 w0.114: 125.86,111.73 125.86,111.96 126.03,112.14 126.03,115.32 122.72,118.63 111.48,118.63 106.83,123.28 101.13,123.28 98.78,125.62 98.78,131.98 98.16,132.6 98.16,135.87 95.42,138.62 95.42,145.21 90.4,150.23 81.81,150.23 79.36,152.68 77.16,152.68 76.79,152.32 76.51,152.03 69.63,152.03 68.33,153.33 55.68,153.33 53.18,155.82 49.84,155.82 39.51,166.15 34.55,166.15 27.63,173.07 27.63,188.07 25.15,190.55 25.15,190.9 25.81,191.55 25.81,191.73 25.58,191.96 25.41,191.96 24.19,190.74 23.82,190.74 23.46,191.1 23.46,191.47 24.62,192.63 24.62,192.81 24.4,193.03 24.22,193.03 23.1,191.91 22.67,191.91 21.26,193.32 21.26,193.45 v3(21.05,193.66)
  BOTTOM w0.089: v3(127.47,106.2) JCPU1.V31
TMDSB_CPU_CLK#: length 175.4
  TOP w0.102: C353.2 21.35,194.36 21.35,193.94 v3(21.63,193.66)
  IN1 w0.089: v3(128.47,106.2) 128.19,106.2 128.1,106.29 128.1,106.53 127.81,106.82 127.26,106.82 127.06,107.02 127.06,107.44 126.68,107.82 126.23,107.82 126.07,107.97 126.07,111.21 126.07,111.63 126.07,111.71 126.09,111.72 126.09,111.73
  IN1 w0.114: v3(21.63,193.66) 21.49,193.52 21.49,193.41 22.76,192.14 23,192.14 24.12,193.26 24.49,193.26 24.85,192.9 24.85,192.53 23.69,191.37 23.69,191.19 23.91,190.97 24.09,190.97 25.31,192.19 25.68,192.19 26.04,191.83 26.04,191.46 25.38,190.8 25.38,190.64 27.86,188.17 27.86,173.16 34.64,166.38 39.61,166.38 49.94,156.05 53.28,156.05 55.77,153.56 68.42,153.56 69.72,152.26 76.42,152.26 76.56,152.41 77.06,152.91 79.45,152.91 81.91,150.45 90.5,150.45 95.65,145.31 95.65,138.71 98.39,135.97 98.39,132.69 99.01,132.07 99.01,125.71 101.22,123.5 106.93,123.5 111.57,118.86 122.82,118.86 126.26,115.42 126.26,112.04 126.09,111.87 126.09,111.73
  BOTTOM w0.089: v3(128.47,106.2) JCPU1.U31
TMDSB_CPU_N0: length 175.4
  TOP w0.102: C350.2 15.97,194.32 15.97,193.82 v3(16.16,193.64)
  IN1 w0.089: v3(128.47,104.2) 128.47,103.82 128.32,103.67 127.88,103.67 126.76,104.8 126.34,104.8 126.09,105.05 126.09,105.4 125.68,105.8 125.34,105.8 125.07,106.07 125.07,106.46 124.74,106.79 124.35,106.79 124.05,107.09 124.05,107.43 123.69,107.8 123.34,107.8 123.06,108.08 123.06,111.11 123,111.17 123,111.7 123.01,111.71 123.01,111.73
  IN1 w0.114: 123.01,111.73 123.01,114.11 120.57,116.55 110.01,116.55 105.25,121.31 100.34,121.31 96.84,124.81 96.84,130.69 95.94,131.59 95.11,131.59 94.55,132.15 94.55,136.5 93.37,137.68 93.37,141.52 92.08,142.82 92.08,145.58 90.41,147.25 85.52,147.25 84.62,148.15 80.41,148.15 79.61,147.35 79.48,147.22 72.33,147.22 70.87,148.67 70.87,149.26 70.54,149.6 69.31,149.6 67.52,151.39 54.52,151.39 52.28,153.63 48.42,153.63 37.84,164.21 33.64,164.21 25.69,172.16 25.69,185.57 18.75,192.51 16.61,192.51 16.11,193.02 16.11,193.59 v3(16.16,193.64)
  BOTTOM w0.089: JCPU1.U29 v3(128.47,104.2)
TMDSB_CPU_N1: length 175.8
  TOP w0.102: C346.2 17.74,194.31 17.74,193.86 v3(17.95,193.65)
  IN1 w0.089: 125.06,111.64 125.09,111.6 125.09,108.02 125.32,107.8 125.69,107.8 126.06,107.43 126.06,107.06 126.32,106.79 126.72,106.79 127.06,106.45 127.06,106.08 127.35,105.79 128.71,105.79 129.3,105.2 v3(129.47,105.2)
  IN1 w0.114: 125.06,111.64 125.06,111.98 125.21,112.13 125.21,115.34 122.51,118.04 111.16,118.04 106.42,122.78 100.92,122.78 98.29,125.41 98.29,131.65 97.66,132.27 97.66,135.61 94.92,138.35 94.92,144.86 90.17,149.62 81.72,149.62 79.15,152.19 77.36,152.19 76.72,151.54 69.42,151.54 68.12,152.83 55.47,152.83 55.18,153.12 52.98,155.33 49.45,155.33 39.12,165.66 34.34,165.66 27.43,172.57 27.42,172.57 27.14,172.86 27.14,187.87 26.42,188.59 26.41,188.59 25.27,189.73 24.13,189.73 20.51,193.35 20.51,193.44 20.51,194.04 20.25,194.3 18.68,194.3 18.42,194.04 18.42,193.48 18.17,193.24 17.9,193.24 17.76,193.38 17.76,193.46 v3(17.95,193.65)
  BOTTOM w0.089: v3(129.47,105.2) JCPU1.T30
TMDSB_CPU_N2: length 175.9
  TOP w0.102: C348.2 19.54,194.33 19.54,193.73 v3(19.73,193.55)
  IN1 w0.089: v3(130.47,103.2) 130.23,103.2 130.06,103.37 130.06,103.62 129.87,103.81 129.3,103.81 129.07,104.04 129.07,104.53 128.81,104.79 127.35,104.79 127.09,105.05 127.09,105.42 126.71,105.8 126.33,105.8 126.07,106.07 126.07,106.45 125.7,106.82 125.31,106.82 125.06,107.07 125.06,107.44 124.71,107.78 124.35,107.78 124.05,108.08 124.05,111.09 124.03,111.11 124.03,111.72 124.04,111.73
  IN1 w0.114: 124.04,111.73 124.13,111.83 124.13,114.18 121,117.31 110.77,117.31 106.03,122.06 100.62,122.06 97.56,125.11 97.56,131.26 96.94,131.89 96.94,135.14 94.1,137.99 94.1,144.62 89.82,148.89 80.13,148.89 80.11,148.88 80.11,148.88 79.18,147.95 72.63,147.95 71.6,148.97 71.6,149.13 71.6,149.13 71.6,149.56 70.77,150.4 69.54,150.4 67.82,152.11 54.82,152.11 52.37,154.56 49.08,154.56 38.71,164.93 33.94,164.93 26.41,172.46 26.41,185.94 25.35,187 25.35,187.14 25.88,187.68 25.88,188.05 25.12,188.81 24.75,188.81 24.3,188.36 23.97,188.36 19.53,192.79 19.53,193.36 v3(19.73,193.55)
  BOTTOM w0.089: JCPU1.T28 130.41,103.2 v3(130.47,103.2)
TMDSB_CPU_P0: length 175.3
  TOP w0.102: v3(15.57,193.64) 15.76,193.83 15.76,194.34 C351.2
  IN1 w0.089: v3(128.34,103.26) 128.14,103.47 127.8,103.47 126.67,104.6 126.26,104.6 125.88,104.97 125.88,105.32 125.6,105.6 125.25,105.6 124.87,105.99 124.87,106.38 124.65,106.59 124.26,106.59 123.85,107 123.85,107.35 123.61,107.59 123.26,107.59 122.86,107.99 122.86,111.02 122.8,111.09 122.8,111.71 122.78,111.72 122.78,111.73
  IN1 w0.114: v3(15.57,193.64) 15.88,193.33 15.88,192.93 16.52,192.29 18.65,192.29 25.46,185.48 25.46,172.07 33.55,163.98 37.75,163.98 48.33,153.4 52.19,153.4 54.43,151.16 67.43,151.16 69.21,149.37 70.44,149.37 70.65,149.17 70.65,148.58 72.23,146.99 79.57,146.99 79.83,147.25 80.51,147.93 84.52,147.93 85.43,147.02 90.32,147.02 91.85,145.49 91.85,142.73 93.14,141.43 93.14,137.59 94.32,136.41 94.32,132.05 95.02,131.36 95.84,131.36 96.61,130.59 96.61,124.72 100.24,121.08 105.16,121.08 109.92,116.32 120.47,116.32 122.78,114.01 122.78,111.73
  BOTTOM w0.089: JCPU1.V29 127.94,103.67 v3(128.34,103.26)
TMDSB_CPU_P1: length 175.7
  TOP w0.102: C347.2 17.53,194.35 17.53,193.82 v3(17.36,193.65)
  IN1 w0.089: 124.83,111.64 124.83,111.56 124.89,111.5 124.89,107.94 125.23,107.59 125.61,107.59 125.86,107.34 125.86,106.97 126.24,106.59 126.64,106.59 126.86,106.37 126.86,105.99 127.26,105.59 128.62,105.59 128.78,105.43 128.78,105.26 128.72,105.2 v3(128.47,105.2)
  IN1 w0.114: v3(17.36,193.65) 17.53,193.49 17.53,193.28 17.8,193.01 18.27,193.01 18.65,193.39 18.65,193.94 18.77,194.07 20.16,194.07 20.28,193.94 20.28,193.44 20.28,193.44 20.28,193.25 24.04,189.5 25.18,189.5 26.32,188.36 26.91,187.77 26.91,172.77 27.33,172.34 34.25,165.43 39.03,165.43 49.36,155.1 52.88,155.1 54.95,153.03 55.38,152.61 68.03,152.61 69.33,151.31 76.81,151.31 77.46,151.96 79.05,151.96 81.63,149.39 90.08,149.39 94.69,144.77 94.69,138.26 97.44,135.52 97.44,132.18 98.06,131.56 98.06,125.32 100.83,122.55 106.33,122.55 111.07,117.81 122.42,117.81 124.98,115.25 124.98,112.23 124.83,112.08 124.83,111.64
  BOTTOM w0.089: v3(128.47,105.2) JCPU1.U30
TMDSB_CPU_P2: length 175.9
  TOP w0.102: v3(19.14,193.55) 19.33,193.74 19.33,194.33 C349.2
  IN1 w0.089: v3(129.47,103.2) 129.47,103.2 129.78,103.2 129.86,103.28 129.86,103.53 129.79,103.61 129.21,103.61 128.87,103.95 128.87,104.44 128.73,104.58 127.27,104.58 126.89,104.96 126.89,105.34 126.62,105.6 126.25,105.6 125.87,105.98 125.87,106.37 125.62,106.62 125.22,106.62 124.85,106.98 124.85,107.35 124.62,107.58 124.26,107.58 123.85,108 123.85,111.01 123.82,111.03 123.82,111.7 123.81,111.71 123.81,111.73
  IN1 w0.114: v3(19.14,193.55) 19.31,193.39 19.31,192.7 23.88,188.13 24.4,188.13 24.85,188.58 25.03,188.58 25.65,187.95 25.65,187.77 25.12,187.24 25.12,186.91 26.18,185.85 26.18,172.37 33.85,164.7 38.62,164.7 48.98,154.34 52.28,154.34 54.73,151.88 67.73,151.88 69.44,150.17 70.67,150.17 71.38,149.46 71.38,149.22 71.38,148.87 72.53,147.72 79.27,147.72 80.21,148.65 80.21,148.65 80.22,148.66 89.73,148.66 93.87,144.52 93.87,137.89 96.71,135.05 96.71,131.79 97.33,131.17 97.33,125.02 100.53,121.83 105.93,121.83 110.68,117.08 120.91,117.08 123.91,114.08 123.91,112.04 123.81,111.95 123.81,111.73
  BOTTOM w0.089: JCPU1.U28 129.41,103.2 v3(129.47,103.2)
TMDSE_CON_CLK: length 9.9
  TOP w0.102: JHDMI1.10 19.35,210.04 19.35,208.86 19.65,208.56 20.52,208.56 20.74,208.78 20.74,208.97 20.84,209.08 21.15,209.08 21.25,208.97 21.25,208.31 v4(21.47,208.09) 21.64,207.92 22.82,207.92 22.84,207.9 23.44,207.9 23.46,207.92 23.61,207.92 23.77,207.76 23.77,207.59 23.45,207.27 L1.3 23.45,206.46 R63.2 CE5.1
TMDSE_CON_CLK#: length 9.9
  TOP w0.102: CE7.1 R62.2 24.3,206.46 L1.2 24.3,207.34 23.98,207.66 23.98,207.85 23.7,208.13 v4(23.14,208.13) 21.76,208.13 21.46,208.43 21.46,209.06 21.24,209.29 20.76,209.29 20.53,209.06 20.53,208.87 20.43,208.77 19.74,208.77 19.56,208.95 19.56,210.07 JHDMI1.12
TMDSE_CON_N0: length 10.2
  TOP w0.102: JHDMI1.9 17.5,211.06 14.67,211.06 13.92,210.32 13.92,210.29 13.46,209.83 v4(13.46,208.71) 13.46,207.71 13.64,207.54 L2.2 13.64,206.46 R68.2 CE16.1
TMDSE_CON_N1: length 12.3
  TOP w0.102: CE18.1 R74.2 17.19,206.46 L3.2 17.19,207.43 16.87,207.75 16.87,208.06 16.97,208.16 17.43,208.16 17.44,208.14 17.99,208.14 18.01,208.16 18.44,208.16 18.69,208.41 18.69,208.84 18.44,209.09 v4(15.56,209.09) 14.8,209.09 14.67,209.21 14.67,209.47 14.8,209.6 16.26,209.6 16.51,209.85 16.51,210.02 JHDMI1.6
TMDSE_CON_N2: length 12.2
  TOP w0.102: CE14.1 R78.2 20.75,206.46 L4.2 20.75,207.43 20.47,207.71 20.47,207.93 v3(20.61,208.07)
  IN1 w0.114: JHDMI1.3 14.99,211.55 14.99,211.44 14.35,210.8 14.35,210.21 15.17,209.39 19.52,209.39 20.42,208.48 20.42,208.27 v3(20.61,208.07)
TMDSE_CON_P0: length 10.2
  TOP w0.102: CE17.1 R64.2 12.79,206.46 L2.3 12.79,207.29 13.25,207.75 13.25,208.42 13.23,208.44 13.23,208.99 13.25,209.01 13.25,209.94 v4(13.57,210.26) 14.58,211.27 17.41,211.27 17.65,211.51 17.65,211.79 JHDMI1.7
TMDSE_CON_P1: length 12.2
  TOP w0.102: JHDMI1.4 16.3,210.09 16.3,209.93 16.17,209.81 14.71,209.81 14.46,209.56 14.46,209.13 14.71,208.88 15.27,208.88 15.29,208.86 15.86,208.86 15.88,208.88 18.35,208.88 18.48,208.75 18.48,208.5 18.35,208.37 v4(17.72,208.37) 16.89,208.37 16.66,208.14 16.66,207.75 16.34,207.43 L3.3 16.34,206.46 R71.2 CE13.1
TMDSE_CON_P2: length 12.2
  TOP w0.102: v3(20.03,208.07) 20.26,207.85 20.26,207.7 19.9,207.34 L4.3 19.9,206.46 R77.2 CE15.1
  IN1 w0.114: v3(20.03,208.07) 20.2,208.24 20.2,208.39 19.43,209.16 15.07,209.16 14.12,210.11 14.12,210.9 14.76,211.53 14.76,211.68 JHDMI1.1
TMDSE_CPU_CLK#_C: length 2.7
  TOP w0.102: C353.1 21.23,196.01 21.23,196.25 21,196.48 20.49,196.48 20.28,196.69 U19.10
TMDSE_CPU_CLK_C: length 2.7
  TOP w0.102: C352.1 21.02,195.84 21.02,196.16 20.91,196.27 20.4,196.27 20.07,196.61 20.07,196.71 19.88,196.9 U19.9
TMDSE_CPU_N0_C: length 2.7
  TOP w0.102: U19.2 17.08,196.84 16.7,196.46 16.17,196.46 16.07,196.35 16.07,195.84 C350.1
TMDSE_CPU_N1_C: length 2.2
  TOP w0.102: U19.5 18.28,196.84 18.19,196.75 18.19,196.42 17.78,196.02 17.78,195.9 C346.1
TMDSE_CPU_N2_C: length 2.2
  TOP w0.102: C348.1 19.49,195.98 19.49,196.07 18.99,196.57 18.99,196.75 19.08,196.84 U19.7
TMDSE_CPU_P0_C: length 2.6
  TOP w0.102: C351.1 15.86,196.01 15.86,196.44 16.09,196.67 16.61,196.67 16.68,196.74 U19.1
TMDSE_CPU_P1_C: length 2.2
  TOP w0.102: C347.1 17.53,195.9 17.53,196.06 17.98,196.51 17.98,196.75 17.88,196.84 U19.4
TMDSE_CPU_P2_C: length 2.2
  TOP w0.102: C349.1 19.28,195.87 19.28,195.98 18.78,196.48 18.78,196.74 18.68,196.84 U19.6
TMDSE_RP_CLK: length 6.6
  TOP w0.102: R63.1 23.45,205.51 L1.4 23.45,204.66 23.77,204.34 23.77,204.04 23.67,203.94 23.65,203.94 23.28,203.57 v4(21.46,203.57) 20.45,203.57 20.07,203.19 20.07,203 19.88,202.81 U19.22
TMDSE_RP_CLK#: length 6.5
  TOP w0.102: R62.1 24.3,205.51 L1.1 24.3,204.66 23.98,204.34 23.98,203.95 v4(23.61,203.58) 23.39,203.36 21.76,203.36 21.74,203.34 21.19,203.34 21.17,203.36 20.54,203.36 20.28,203.11 U19.21
TMDSE_RP_N0: length 6.5
  TOP w0.102: R68.1 13.64,205.51 L2.1 13.64,204.54 13.32,204.22 13.32,204.04 v4(13.53,203.83) 13.89,203.47 14.51,203.47 14.52,203.48 15.1,203.48 15.11,203.47 16.62,203.47 16.99,203.1 16.99,202.87 17.08,202.78 U19.29
TMDSE_RP_N1: length 4.2
  TOP w0.102: U19.26 18.28,203.07 18.18,203.17 18.18,203.53 17.7,204.02 v4(17.4,204.02) 17.09,204.02 16.87,204.24 16.87,204.34 17.19,204.66 L3.1 17.19,205.51 R74.1
TMDSE_RP_N2: length 4.3
  TOP w0.102: R78.1 20.75,205.51 L4.1 20.75,204.66 20.39,204.3 20.39,204.2 19.98,203.79 19.34,203.79 18.99,203.44 18.99,203.03 19.08,202.94 U19.24
TMDSE_RP_P0: length 6.5
  TOP w0.102: R64.1 12.79,205.51 L2.4 12.79,204.54 13.11,204.22 13.11,203.92 13.59,203.44 13.61,203.44 13.8,203.26 v4(14.8,203.26) 16.53,203.26 16.78,203.01 16.78,202.87 16.68,202.78 U19.30
TMDSE_RP_P1: length 4.2
  TOP w0.102: U19.27 17.88,203.06 17.97,203.16 17.97,203.45 17.63,203.79 17.03,203.79 16.66,204.15 16.66,204.31 16.34,204.63 L3.4 16.34,205.51 R71.1
TMDSE_RP_P2: length 4.3
  TOP w0.102: R77.1 19.9,205.51 L4.4 19.9,204.66 20.17,204.38 20.17,204.28 19.91,204.02 v4(19.5,204.02) 19.27,204.02 18.78,203.53 18.78,203.09 18.68,203 U19.25
TOUCH_SCREEN_PD#: length 98.1
  TOP w0.102: U46.B55 183.37,63.67 v3(183.09,63.95) ; RP2.6 179.9,73.48 v3(179.5,73.08)
  IN1 w0.102: v3(183.09,63.95) 182.6,64.44 181.84,64.44 180.56,65.72 180.56,72.72 180.2,73.08 v3(179.5,73.08)
  IN2 w0.127: v3(179.5,73.08) 179.97,73.55 179.97,75.25 183.83,79.11 183.83,81.54 184.61,82.32 184.61,87.77 185.48,88.64 185.48,92.52 184.39,93.6 184.39,95.29 184.39,99.54 185.37,100.51 185.37,106 188.56,109.18 188.56,119.5 190.79,121.73 190.79,143.01 187.58,146.23 v3(187.58,146.36)
  BOTTOM w0.102: Q24.2 187.81,148.18 187.58,147.96 v1(187.58,147.44) v3(187.58,146.36)
TP_CLK: length 11.5
  TOP w0.102: JTP1.2 189.18,107.77 189.55,108.14 189.55,112.45 188.72,113.27 v4(188.72,115.94) 188.72,116.96 R3736.2
TP_DATA: length 12
  TOP w0.102: JTP1.3 188.94,107.27 189.21,107.54 189.28,107.54 189.78,108.04 189.78,112.54 188.95,113.37 v4(188.95,113.78) 188.95,116.93 R3735.2
TP_LAN_JTAG_TCK: length 2
  TOP w0.102: R546.2 235.7,162.08 U31.35
TP_LAN_JTAG_TDI: length 1.2
  TOP w0.102: T142.1 236.03,163.28 U31.32
TP_LAN_JTAG_TDO: length 1.2
  TOP w0.102: T143.1 236.06,162.48 U31.34
TP_LAN_JTAG_TMS: length 1.9
  TOP w0.102: U31.33 235.62,162.88 R545.2
TPM_ID0: length 8.5
  TOP w0.089: 160.21,126.62 160.21,127.18 160.34,127.31 160.34,130.29 v3(160.85,130.8)
  TOP w0.102: RPH16.2 158.88,124.76 159.01,124.89 159.66,124.89 v1(160.16,125.4) 160.21,125.45 160.21,126.62
  BOTTOM w0.089: v3(160.85,130.8) 161.08,130.57 UH1.AT7
TPM_ID1: length 5.5
  TOP w0.102: RPH14.1 162.37,124.09 162.37,124.95 v3(162.32,125)
  BOTTOM w0.089: 162.43,126.48 162.43,126.8 162.84,127.2 162.84,127.63 163.06,127.85 163.07,127.85 163.14,127.92 163.14,128.17 162.94,128.38 162.94,128.84 UH1.AM3
  BOTTOM w0.102: v3(162.32,125) 162.18,125.14 v1(162.18,125.48) 162.18,126.23 162.43,126.48
TRIP_+1.05VSP: length 4.3
  TOP w0.102: PR302.2 179.95,93.09 v1(180.15,92.89)
  TOP w0.254: PU300.2 178.43,95.18 178.75,94.86 178.75,93.41 PR302.2
TS_FDO: length 5.4
  BOTTOM w0.089: UV1.R5 61.88,133.3 59.03,133.3 58.55,133.79 58.11,133.79
  BOTTOM w0.102: RV111.2 58.11,133.79
UG_3V: length 11.2
  IN2 w1.016: 200.09,37.46 200.28,37.65 203.01,37.65 204.41,39.04 206.69,39.04 208.54,40.88
  BOTTOM w0.102: v1(211.27,40.88) 210.95,41.2 v4(210.06,41.2)
  vias: v4(199.55,36.79) v4(199.55,36.16) v4(209.42,41.2)
UG_5V: length 14.3
  TOP w0.102: v1(208.41,50.85) 208.66,50.6 v4(208.66,50.16)
  IN2 w1.016: 200.47,39.68 201.55,39.68 208.35,46.47 208.35,49.27
  vias: v4(199.54,40.08) v4(199.54,39.45) v4(208.03,50.16)
UG_+1.05VSP: length 11.4
  TOP w0.102: v1(160.97,93.4) 161.19,93.62 PQ301.4
  IN2 w1.016: 162.43,93.91 163.32,94.8 172.09,94.8
  vias: v3(161.98,93.02) v3(162.56,93.02) v3(173.34,95.05) v3(173.93,95.05)
UGATE1: length 10.4
  TOP w0.102: v3(129.86,130.75) v2(130.76,130.75)
  IN4 w1.016: 126.62,139.75 130.05,136.32 130.05,131.69
  vias: v3(125.92,140.83) v3(125.92,140.25) v3(129.86,130.17)
UGATE1_VGA: length 23.7
  IN2 w1.016: 16.45,161.92 18.35,163.82 24.58,163.82 26.48,161.92 26.48,159.25 27.37,158.36 27.37,150.99
  BOTTOM w0.102: v3(15.62,160.91) 15.62,160.96 v1(15.11,161.47)
  vias: v3(15.62,160.33) v3(25.59,150.99) v3(26.18,150.99)
UGATE2: length 15.6
  IN2 w1.016: 120.78,141.47 112.59,133.28 112.59,130.17
  BOTTOM w0.102: v1(111.63,129.28) 111.71,129.35 v3(112.52,129.35)
  vias: v3(112.52,128.77) v3(121.65,142.36) v3(122.24,142.36)
UGATE2_VGA: length 11.5
  IN2 w1.016: 19.75,152.39 19.56,152.58 18.02,152.58 16.98,153.62 12.42,153.62 11.11,154.93 10.16,154.93
  BOTTOM w0.102: v3(20.7,152.14) v1(20.7,151.31)
  vias: v3(9.83,155.95) v3(10.42,155.95) v3(21.3,152.14)
UIM_CLK: length 68
  TOP w0.102: v3(227.37,153.63) 227.45,153.71 227.45,154.78 C630.1 227.22,155.49 227.22,156.2 226.89,156.52 JSIM1.3
  IN4 w0.102: v3(256.33,170.64) 256.33,168.71 245.57,157.95 233.86,157.95 230.18,154.27 228,154.27 v3(227.37,153.63)
  BOTTOM w0.102: v3(256.33,170.64) 257.24,170.64 257.65,171.05 257.65,173.4 258.24,173.99 258.24,177.58 261.85,181.19 261.85,190.56 262.36,191.06 JMINI1.12
UIM_DATA: length 67.4
  TOP w0.102: v3(228.06,153.62) 228.06,154.76 C629.1 228.32,155.49 228.17,155.49 227.86,155.79 227.86,156.48 227.59,156.75 JSIM1.7
  IN4 w0.102: v3(228.06,153.62) 230.39,153.62 233.55,156.78 245.33,156.78 256.99,168.44 v3(256.99,171.25)
  BOTTOM w0.102: JMINI1.10 261.56,193.13 261.75,192.94 261.75,191.32 261.24,190.81 261.24,181.44 257.62,177.82 257.62,174.23 256.99,173.6 v3(256.99,171.25)
UIM_RESET: length 73.2
  TOP w0.102: C631.1 225.29,155.57 225.29,156.42 225.49,156.62 JSIM1.2 225.49,158.81 225.03,159.27 223.18,159.27 v3(223.27,159.18)
  IN2 w0.127: v3(263.16,195.76) 262.45,195.05 260.15,195.05 259.44,194.34 259.44,180.81 256.83,178.2 256.83,176.43 254.32,173.92 242.65,173.92 234.46,165.73 231.29,165.73 225.72,160.15 225.72,159.43 225.48,159.18 v3(223.27,159.18)
  BOTTOM w0.102: v1(222.99,159.79) 223.27,159.51 v3(223.27,159.18) ; JMINI1.14 v3(263.16,195.76)
USB3RN1: length 154.8
  TOP w0.102: v3(279.44,184.01) 279.63,184.2 279.63,184.31 279.5,184.44 278.63,184.44 278.33,184.74 278.33,186.63 278.02,186.93 277.64,186.93 277.45,187.12 277.45,187.29 277.14,187.61 L95.4 277.14,188.3 R1605.1
  IN1 w0.089: v3(161.25,139.12) 161.29,139.12 161.41,139.24 161.41,139.49 161.65,139.72 162.31,139.72 162.6,140.02 165.41,140.02 165.99,140.6 165.99,140.74 166.68,141.43 166.68,144.38 166.66,144.39 166.66,144.46 166.65,144.47 166.65,144.48
  IN1 w0.114: v3(279.44,184.01) 279.63,183.81 279.63,183.16 281.31,181.48 281.31,173.8 279.6,172.09 271.29,172.09 270.89,171.69 259.24,171.69 246.99,159.44 245.17,159.44 244.3,158.57 236.44,158.57 236.11,158.9 227.87,158.9 226.39,157.42 219.28,157.42 214.94,153.08 202.66,153.08 202,152.43 186.91,152.43 186.39,151.91 178.68,151.91 173.41,146.64 168.49,146.64 166.65,144.8 166.65,144.48
  BOTTOM w0.089: v3(161.25,139.12) 161.25,138.88 UH1.AR26
USB3RN1_D-: length 22.3
  TOP w0.102: JUSB1.5 274.73,209.06 274.83,208.96 274.83,208.35 275.51,207.67 275.51,206.53 275.78,206.26 275.78,206.24 276.16,205.85 276.19,205.85 v4(277.25,204.79) 277.86,204.18 277.86,194.39 277.44,193.97 277.44,193.15 277.3,193.01 D78.5 D78.6 277.3,191.05 277.41,190.93 277.41,190.55 277.14,190.28 L95.3 277.14,189.38 R1605.2
USB3RN2: length 165.1
  TOP w0.102: R3696.1 284.56,189.25 L108.4 284.56,188.29 284.8,188.05 284.8,187.72 285.16,187.36 286.11,187.36 286.42,187.04 288.15,187.04 288.34,187.24 v3(288.8,187.24)
  IN1 w0.089: 170.7,145.46 170.7,145 170.8,144.9 170.8,140.47 170.08,139.74 166.52,139.74 166.09,139.31 163.04,139.31 162.22,138.49 159.73,138.49 159.5,138.72 159.5,138.98 v3(159.39,139.09)
  IN1 w0.114: 170.7,145.46 170.98,145.74 173.86,145.74 179.08,150.95 186.78,150.95 187.3,151.48 194.4,151.48 194.79,151.08 202.99,151.08 204.02,152.11 215.32,152.11 219.66,156.45 226.83,156.45 228.32,157.95 235.71,157.95 236.04,157.61 244.81,157.61 245.64,158.45 247.34,158.45 257.44,168.54 261.26,168.54 263.46,170.74 271.4,170.74 271.8,171.14 280.02,171.14 282.51,173.63 282.51,181.79 287.03,186.31 287.55,186.31 288.55,187.32 288.72,187.32 v3(288.8,187.24)
  BOTTOM w0.089: v3(159.39,139.09) 159.39,139.01 159.71,138.69 UH1.AW26
USB3RN2_D-: length 12.7
  TOP w0.102: JUSB2.5 290.02,198.63 289.88,198.49 289.07,198.49 287.45,196.87 286.91,196.87 286.89,196.88 286.32,196.88 286.3,196.87 286.15,196.87 285.82,196.54 285.82,196.29 285.31,195.78 285.31,195.56 285.2,195.45 D88.9 D88.1 285.2,193.84 285.33,193.7 285.33,192.73 284.91,192.3 v4(284.91,191.76) 284.91,191.35 284.56,191 L108.3 284.56,190.2 R3696.2
USB3RN3: length 43.8
  TOP w0.089: v3(159.87,141.08) 159.65,141.3 159.65,141.47 159.45,141.67 158.95,141.67 158.89,141.6 158.32,141.6 157.42,142.5 153.72,142.5 153.71,142.51 153.69,142.51
  TOP w0.102: v3(138.37,167.58) 138.55,167.4 139.26,167.4 140.27,166.38 140.27,165.85 145.27,160.86 146.52,160.86 147,160.37 147,159.67 148.09,158.59 148.09,151.88 149.11,150.86 149.11,145.58 152.17,142.51 153.69,142.51
  BOTTOM w0.089: v3(159.87,141.08) 159.87,140.75 UH1.AW31
  BOTTOM w0.102: JDOCK1.84 139.34,168.25 139.51,168.07 139.51,167.86 139.04,167.39 138.55,167.39 v3(138.37,167.58)
USB3RN5: length 143.3
  TOP w0.102: v3(280.72,174.56) 280.53,174.37 280.53,174.23 280.63,174.13 281.01,174.13 281.16,174.28 281.16,174.51 281.31,174.66 L111.4 282.04,174.66 R3722.1
  IN1 w0.089: 168.05,147.11 166.37,145.42 166.37,141.72 165.51,140.86 163.67,140.86 163.3,140.49 161.01,140.49 160.85,140.33 160.85,139.82 160.52,139.49 159.91,139.49 159.7,139.69 159.7,140.04 v3(159.63,140.11)
  IN1 w0.114: v3(280.72,174.56) 280.72,173.95 280.32,173.55 278.43,173.55 278.09,173.89 274.56,173.89 273.25,172.59 270.84,172.59 270.44,172.19 259.04,172.19 248.45,161.6 246.46,161.6 245.4,160.54 239.05,160.54 237.62,159.11 236.59,159.11 236.31,159.39 235.51,159.39 235.12,159.78 234.75,159.78 234.37,159.39 227.6,159.39 226.13,157.91 219.08,157.91 218.91,157.75 218.35,157.75 217.18,156.58 210.67,156.58 207.67,153.58 202.3,153.58 201.65,152.92 195.49,152.92 194.93,153.48 194.48,153.48 193.92,152.92 186.7,152.92 186.18,152.4 178.25,152.4 175.96,150.12 173.9,150.12 172.28,148.49 169.44,148.49 168.05,147.11
  BOTTOM w0.089: v3(159.63,140.11) 159.8,139.94 159.8,139.7 UH1.AW29
USB3RN5_D-: length 12.6
  TOP w0.102: JUSB3.5 290.02,179.46 289.92,179.36 289.22,179.36 288.79,178.93 288.79,174.92 287.97,174.11 286.84,174.11 286.67,174.28 D91.9 D91.1 284.41,174.28 284.03,174.66 L111.3 283.24,174.66 R3722.2
USB3RN6: length 196
  IN4 w0.089: 155.13,144.29 155.14,144.29 155.15,144.28 155.69,144.28 158,141.96 158,140.35 158.65,139.7 161.17,139.7 161.36,139.88 161.36,139.99 v3(161.23,140.12)
  IN4 w0.114: 155.13,144.29 150.61,144.29 148.84,146.06 145.27,146.06 141.49,149.84 140.54,149.84 135.04,155.35 134.57,155.35 133.45,156.47 133.45,157.05 131.96,158.54 121.62,158.54 120.71,157.64 110.98,157.64 110.08,156.74 107.63,156.74 101.49,150.6 90.98,150.6 89.32,152.26 81.5,152.26 80.85,152.91 77.03,152.91 76.38,152.26 66.87,152.26 66.15,152.98 59.96,152.98 59.22,153.72 58.62,153.72 53.31,153.72 46.37,160.66 46.03,160.66 39.82,166.87 36.32,166.87 34.74,168.46 31.12,168.46 19.97,179.61 19.97,183.74 16.23,187.48 3.59,187.48 2.31,186.2 2.31,184.05 2.63,183.73 v3(3.31,183.73)
  BOTTOM w0.089: v3(161.23,140.12) 161.5,139.85 UH1.AR29
  BOTTOM w0.102: v3(3.31,183.73) 3.15,183.89 2.87,183.89 2.73,183.75 JIO1.29
USB3RP1: length 154.7
  TOP w0.102: v3(280.03,184.01) 279.84,184.19 279.84,184.4 279.59,184.65 278.72,184.65 278.56,184.81 v4(278.56,185.07) 278.56,185.35 278.54,185.37 278.54,186.72 278.11,187.14 277.73,187.14 277.67,187.21 277.67,187.29 277.98,187.61 L95.1 277.98,188.3 R1604.1
  IN1 w0.089: 166.88,144.48 166.88,141.34 166.19,140.66 166.19,140.51 165.5,139.82 162.69,139.82 162.39,139.52 161.74,139.52 161.62,139.4 161.62,139.34 v3(161.84,139.12)
  IN1 w0.114: 166.88,144.48 166.88,144.71 168.58,146.41 173.5,146.41 178.77,151.68 186.48,151.68 187,152.2 202.1,152.2 202.75,152.85 215.04,152.85 219.38,157.19 226.48,157.19 227.96,158.67 236.01,158.67 236.34,158.34 244.39,158.34 245.26,159.21 247.08,159.21 259.34,171.47 270.98,171.47 271.38,171.87 279.69,171.87 281.54,173.71 281.54,181.58 279.86,183.25 279.86,183.84 v3(280.03,184.01)
  BOTTOM w0.089: v3(161.84,139.12) 161.84,138.89 UH1.AP26
USB3RP1_D+: length 22.4
  TOP w0.102: JUSB1.6 275.15,209.06 275.05,208.96 275.05,208.44 275.72,207.76 275.72,206.62 v4(276.13,206.21) 277.2,205.14 277.22,205.14 277.61,204.76 277.61,204.73 278.07,204.27 278.07,194.3 277.65,193.88 277.65,193.15 277.8,193.01 D78.4 D78.7 277.8,191.06 277.62,190.89 277.62,190.55 277.98,190.19 L95.2 277.98,189.38 R1604.2
USB3RP2: length 165.1
  TOP w0.102: v3(288.8,187.82) 288.43,187.45 288.25,187.45 288.06,187.25 286.51,187.25 286.2,187.57 285.24,187.57 285.01,187.8 285.01,188.08 285.12,188.18 285.31,188.18 285.41,188.29 L108.1 285.41,189.25 R3691.1
  IN1 w0.089: 170.54,145.62 170.53,145.61 170.53,145.59 170.48,145.55 170.48,145.37 170.49,145.35 170.49,144.92 170.6,144.81 170.6,140.55 169.99,139.94 166.44,139.94 166,139.51 162.96,139.51 162.14,138.69 159.81,138.69 159.7,138.8 159.7,138.89 159.91,139.09 v3(160.03,139.09)
  IN1 w0.114: 170.54,145.62 170.88,145.96 173.76,145.96 178.98,151.18 186.69,151.18 187.21,151.7 194.49,151.7 194.89,151.31 202.9,151.31 203.93,152.34 215.23,152.34 219.57,156.68 226.73,156.68 228.23,158.17 235.81,158.17 236.14,157.84 244.72,157.84 245.55,158.68 247.25,158.68 257.34,168.77 261.16,168.77 263.36,170.97 271.31,170.97 271.71,171.37 279.93,171.37 282.28,173.73 282.28,181.89 286.94,186.54 287.45,186.54 288.46,187.54 288.52,187.54 v3(288.8,187.82)
  BOTTOM w0.089: UH1.AV26 160.3,138.69 160.03,138.97 v3(160.03,139.09)
USB3RP2_D+: length 12.6
  TOP w0.102: JUSB2.6 290.02,198.16 289.9,198.28 289.16,198.28 287.53,196.65 v4(286.6,196.65) 286.23,196.65 286.03,196.45 286.03,196.2 285.52,195.69 285.52,195.61 285.7,195.43 D88.8 D88.2 285.7,193.88 285.54,193.72 285.54,192.64 285.12,192.22 285.12,192.06 285.13,192.05 285.13,191.47 285.12,191.46 285.12,191.28 285.41,190.98 L108.2 285.41,190.2 R3691.2
USB3RP3: length 43.8
  TOP w0.089: v3(159.23,141.09) 159.45,141.3 159.45,141.39 159.37,141.47 159.03,141.47 158.97,141.4 158.24,141.4 157.34,142.31 153.72,142.31 153.71,142.3 153.69,142.3
  TOP w0.102: v3(138.37,167) 138.56,167.19 139.17,167.19 140.06,166.29 140.06,165.76 145.18,160.65 146.43,160.65 146.79,160.28 146.79,159.59 147.88,158.5 147.88,151.79 148.89,150.77 148.89,145.49 152.08,142.3 153.69,142.3
  BOTTOM w0.089: v3(159.23,141.09) 159.23,140.71 UH1.AY31
  BOTTOM w0.102: v3(138.37,167) 138.55,167.18 139.13,167.18 139.72,167.78 139.72,168.27 139.84,168.38 JDOCK1.86
USB3RP5: length 143.1
  TOP w0.102: v3(280.13,174.56) 280.32,174.37 280.32,174.14 280.54,173.92 281.1,173.92 281.11,173.92 281.14,173.92 281.24,173.81 L111.1 282.04,173.81 R3721.1
  IN1 w0.089: v3(160.28,140.1) 160.11,140.1 159.98,139.97 159.98,139.9 159.91,139.83 159.91,139.77 159.99,139.69 160.43,139.69 160.65,139.91 160.65,140.42 160.93,140.69 163.21,140.69 163.58,141.06 165.42,141.06 166.17,141.81 166.17,145.51 167.84,147.18 167.84,147.2 167.89,147.24 167.88,147.24 167.88,147.26 167.89,147.27
  IN1 w0.114: 167.89,147.27 169.35,148.72 172.18,148.72 173.81,150.35 175.87,150.35 178.15,152.63 186.09,152.63 186.61,153.15 193.82,153.15 194.38,153.71 195.02,153.71 195.58,153.15 201.55,153.15 202.21,153.81 207.58,153.81 210.58,156.81 217.08,156.81 218.25,157.98 218.82,157.98 218.98,158.14 226.03,158.14 227.51,159.62 234.27,159.62 234.66,160.01 235.22,160.01 235.6,159.62 236.41,159.62 236.69,159.34 237.52,159.34 238.95,160.77 245.31,160.77 246.37,161.83 248.36,161.83 258.94,172.42 270.34,172.42 270.74,172.82 273.16,172.82 274.46,174.12 278.18,174.12 278.53,173.78 280.23,173.78 280.49,174.04 280.49,174.15 280.13,174.51 v3(280.13,174.56)
  BOTTOM w0.089: UH1.AV29 160.23,139.61 160.09,139.75 160.09,139.91 v3(160.28,140.1)
USB3RP5_D+: length 12.6
  TOP w0.102: JUSB3.6 290.02,179.04 289.92,179.14 289.31,179.14 289,178.84 289,174.84 288.06,173.9 286.79,173.9 286.68,173.78 D91.8 D91.2 284.91,173.78 284.62,174.07 284.38,174.07 284.12,173.81 L111.2 283.24,173.81 R3721.2
USB3RP6: length 195.8
  IN4 w0.089: v3(161.87,140.12) 161.26,139.5 158.56,139.5 157.8,140.26 157.8,141.88 155.61,144.07 155.15,144.07 155.14,144.06 155.13,144.06
  IN4 w0.114: v3(3.31,184.36) 2.91,183.96 2.73,183.96 2.54,184.15 2.54,186.11 3.68,187.25 16.13,187.25 19.74,183.64 19.74,179.52 31.03,168.23 34.64,168.23 36.23,166.64 39.72,166.64 45.93,160.43 46.27,160.43 53.22,153.49 58.71,153.49 59.12,153.49 59.86,152.75 66.06,152.75 66.77,152.03 76.47,152.03 77.12,152.68 80.75,152.68 81.41,152.03 89.23,152.03 90.89,150.37 101.58,150.37 107.72,156.51 110.18,156.51 111.07,157.41 120.81,157.41 121.72,158.31 131.87,158.31 133.22,156.96 133.22,156.37 134.48,155.12 134.94,155.12 140.45,149.62 141.39,149.62 145.18,145.83 148.74,145.83 150.51,144.06 155.13,144.06
  BOTTOM w0.089: v3(161.87,140.12) 161.88,140.11 161.88,139.83 UH1.AP29
  BOTTOM w0.102: v3(3.31,184.36) 3.05,184.1 2.89,184.1 2.73,184.25 JIO1.31
USB3TN1: length 185.1
  TOP w0.102: C1533.1 279.16,186.03 279.53,185.66 279.53,185.53 v3(279.34,185.35)
  IN1 w0.114: v3(279.34,185.35) 279.7,184.99 279.7,184.82 279.6,184.73 279.04,184.73 275.41,181.1 270.84,181.1 268.92,179.18 260.63,179.18 253.13,171.68 244.08,171.68 240.5,168.1 240.5,167.02 239.91,166.42 225.35,166.42 225.06,166.14 223.84,166.14 223.66,165.95 200.31,165.95 198.72,167.54 194.08,167.54 192.15,169.48 186.11,169.48 184.59,171 155.6,171 153.16,168.56 151.17,168.56 150.17,167.56 150.17,159.33 150.02,159.19 149.84,159.19 v3(149.64,159.38)
  BOTTOM w0.089: UH1.BE24 157.18,137.65 157.09,137.57 156.91,137.57 156.7,137.77 155.76,137.77 155.74,137.76 155.73,137.76 155.69,137.72 155.68,137.72 155.67,137.7
  BOTTOM w0.102: 155.67,137.7 155.63,137.66 154.18,137.66 154.02,137.51 150.08,137.51 145.77,141.82 145.77,143.71 146.22,144.16 146.22,153.42 149.18,156.38 149.18,157.55 150.05,158.42 150.05,158.97 v3(149.64,159.38)
USB3TN1_C: length 2
  TOP w0.102: C1533.2 279.4,187.26 279.4,187.57 279.1,187.87 L96.4 279.1,188.62 R1606.1
USB3TN1_D-: length 21.5
  TOP w0.102: 279.36,204.54 280.04,205.22 280.04,206.3 280.02,206.32 280.02,206.87 280.04,206.89 280.04,207.76 280.83,208.56 280.83,208.96 280.73,209.06 JUSB1.8 ; 279.36,204.54 278.94,204.13 278.94,193.15 278.8,193.01 D78.2 D78.8 278.8,191.19 279,190.99 279.14,190.99 279.27,190.85 279.27,190.6 279.1,190.43 L96.3 279.1,189.7 R1606.2 ; 279.36,204.54 v4(279.36,204.54)
USB3TN2: length 194.6
  TOP w0.102: v3(287.15,187.86) 287.15,188.15 286.94,188.36 286.94,188.51 286.49,188.95 C1518.1
  IN1 w0.114: v3(287.15,187.86) 287.38,187.63 287.38,187.5 287.19,187.32 286.02,187.32 284.02,185.32 281.08,185.32 280.32,186.08 278.93,186.08 276.1,183.25 269.11,183.25 267.18,181.32 265.78,181.32 264.77,180.3 260.73,180.3 252.83,172.41 243.66,172.41 238.43,167.17 204.87,167.17 202.95,169.09 194.06,169.09 191.96,171.19 185.43,171.19 184.89,171.72 155.3,171.72 152.86,169.29 150.85,169.29 149.32,167.75 149.32,161.18 148.81,160.68 148.81,158.61 149.34,158.08 150.15,158.08 150.22,158.14 150.71,158.14 150.81,158.04 150.81,157.95 v3(150.57,157.7)
  BOTTOM w0.089: UH1.BD25 157.63,138.03 157.55,137.95 157.43,137.95 157.31,138.07 156.64,138.07 156.57,138.13 155.76,138.13 155.75,138.13 155.69,138.13 155.68,138.12 155.67,138.12
  BOTTOM w0.102: v3(150.57,157.7) 150.94,157.33 150.94,157.23 146.92,153.21 146.92,149.62 147.2,149.33 147.2,143.33 149.59,140.94 149.59,139.48 150.95,138.12 155.67,138.12
USB3TN2_C: length 2
  TOP w0.102: C1518.2 286.77,190.25 286.77,190.45 286.47,190.75 L109.4 286.47,191.55 R3698.1
USB3TN2_D-: length 10.2
  TOP w0.102: R3698.2 286.47,192.5 L109.3 286.47,193.21 286.82,193.56 286.82,193.75 286.7,193.88 D88.4 D88.7 286.7,195.49 286.82,195.61 286.82,195.78 287.08,196.03 287.83,196.03 288.84,195.02 288.84,193.06 289.43,192.46 289.82,192.46 290.02,192.66 JUSB2.8
USB3TN3: length 42.8
  TOP w0.102: v3(140.76,167.7) 141.01,167.45 141.01,166.78 141.39,166.4 143.04,166.4 143.64,165.8 143.64,163.94 146.12,161.47 147.21,161.47 148.7,159.98 148.7,157.89 149.48,157.11 149.48,152.36 v3(149.19,152.07)
  BOTTOM w0.089: UH1.BE32 157.05,141.14 156.91,141.14 156.82,141.05 156.82,140.93 156.74,140.86 156.09,140.86 155.79,141.15 155.73,141.15 155.72,141.16 155.71,141.16
  BOTTOM w0.102: v3(140.76,167.7) 140.97,167.91 140.97,168.07 140.84,168.2 JDOCK1.90 ; v3(149.19,152.07) 149.76,152.64 150.18,152.64 150.45,152.37 150.45,151.35 149.06,149.95 149.06,144.1 151.37,141.78 154.63,141.78 155.25,141.16 155.71,141.16
USB3TN5: length 180.9
  TOP w0.102: C419.1 279.77,172.57 279.36,172.16 279.23,172.16 279.12,172.28 279.12,174 v3(279.53,174.41)
  IN1 w0.114: v3(279.53,174.41) 279.53,175.06 279.24,175.35 277.4,175.35 276.33,176.42 268.83,176.42 268.68,176.27 260.98,176.27 260.64,175.92 258.42,175.92 253.45,170.96 245.47,170.96 240.21,165.7 225.65,165.7 225.36,165.41 224.14,165.41 223.95,165.22 199.19,165.22 198.61,165.8 188.6,165.8 187.47,164.67 180.5,164.67 174.9,170.27 162.92,170.27 160.72,168.07 157.8,168.07 157.61,168.27 156.27,168.27 155.13,167.12 151.39,167.12 150.94,166.68 150.94,162.61 153.06,160.49 153.06,158.77 152.79,158.5 v3(152.4,158.5)
  BOTTOM w0.089: 155.26,138.64 155.28,138.64 155.29,138.64 156.76,138.64 156.81,138.59 156.81,138.5 156.86,138.45 157.05,138.45 UH1.BE26
  BOTTOM w0.102: v3(152.4,158.5) 152.15,158.25 151.99,158.25 151.76,158.03 151.76,156.89 147.77,152.89 147.77,149.93 148.02,149.68 148.02,143.67 150.41,141.28 150.41,140.28 151.54,139.15 153.85,139.15 154.36,138.64 155.26,138.64
USB3TN5_C: length 1.8
  TOP w0.102: R3728.1 282.04,172.63 L112.4 281.5,172.63 281.19,172.32 281.01,172.32 C419.2
USB3TN5_D-: length 8.4
  TOP w0.102: R3728.2 283.24,172.63 L112.3 284.04,172.63 284.17,172.49 284.64,172.49 284.75,172.61 284.75,172.69 284.84,172.78 D91.4 D91.7 286.58,172.78 286.72,172.64 288.22,172.64 288.93,173.36 289.92,173.36 290.02,173.46 JUSB3.8
USB3TN6: length 186.5
  IN4 w0.114: v3(155.88,139.37) 155.53,139.71 155.53,140.93 153.86,142.61 151.26,142.61 149.55,144.32 146.63,144.32 145.82,145.13 145.18,145.13 141.19,149.12 140.24,149.12 138.5,150.86 137.29,150.86 136.82,151.34 136.82,152.05 135.87,153 135.36,153 132.93,155.44 132.93,155.88 132.11,156.7 131.63,156.7 130.51,157.82 121.92,157.82 121.01,156.91 111.28,156.91 110.38,156.02 107.93,156.02 101.79,149.87 89.69,149.87 89.25,150.31 81.88,150.31 80,152.19 77.33,152.19 76.68,151.54 66.57,151.54 65.85,152.26 59.66,152.26 58.92,152.99 53.01,152.99 46.07,159.93 45.73,159.93 39.52,166.14 35.97,166.14 34.42,167.69 30.8,167.69 19.24,179.25 19.24,181.76 17.47,183.53 12.57,183.53 11.39,184.71 4.89,184.71 4.53,185.08 v3(4.53,185.66)
  BOTTOM w0.089: v3(155.88,139.37) 155.94,139.44 156.06,139.44 156.44,139.06 157.25,139.06 157.42,139.22 157.57,139.22 157.65,139.14 UH1.BD27
  BOTTOM w0.102: JIO1.35 2.72,185.25 2.86,185.39 3.28,185.39 3.77,184.9 4.26,184.9 4.45,185.09 4.45,185.58 v3(4.53,185.66)
USB3TP1: length 185.2
  TOP w0.102: C1534.1 279.74,185.8 279.74,185.54 v3(279.93,185.35)
  IN1 w0.114: v3(149.64,158.8) 149.8,158.96 150.12,158.96 150.39,159.24 150.39,167.46 151.26,168.33 153.26,168.33 155.69,170.77 184.5,170.77 186.02,169.25 192.05,169.25 193.99,167.31 198.63,167.31 200.22,165.73 223.76,165.73 223.94,165.91 225.16,165.91 225.44,166.19 240,166.19 240.73,166.92 240.73,168.01 244.18,171.45 253.22,171.45 260.72,178.95 269.01,178.95 270.93,180.87 275.5,180.87 279.13,184.5 279.7,184.5 279.93,184.73 v3(279.93,185.35)
  BOTTOM w0.089: 155.82,137.55 155.84,137.58 156.62,137.58 156.83,137.37 157.63,137.37 UH1.BD23
  BOTTOM w0.102: 155.82,137.55 155.72,137.45 154.27,137.45 154.11,137.3 149.99,137.3 145.56,141.73 145.56,143.8 146.01,144.25 146.01,153.5 148.97,156.47 148.97,157.64 149.84,158.51 149.84,158.6 v3(149.64,158.8)
USB3TP1_C: length 2.1
  TOP w0.102: C1534.2 279.61,187.31 279.61,187.53 279.95,187.87 L96.1 279.95,188.62 R1603.1
USB3TP1_D+: length 21.6
  TOP w0.102: R1603.2 279.95,189.7 L96.2 279.95,190.64 279.85,190.74 279.68,190.74 279.3,191.13 D78.9 D78.1 279.3,193.01 279.15,193.15 279.15,204.04 279.3,204.19 279.33,204.19 279.71,204.57 279.71,204.6 280.25,205.13 v4(280.25,206.59) 280.25,207.67 281.05,208.47 281.05,208.96 281.15,209.06 JUSB1.9
USB3TP2: length 194.7
  TOP w0.102: v3(287.73,187.86) 287.15,188.45 287.15,188.83 C1519.1
  IN1 w0.114: v3(151.15,157.7) 151.04,157.81 151.04,158.13 150.8,158.37 150.12,158.37 150.05,158.3 149.43,158.3 149.04,158.7 149.04,160.58 149.54,161.09 149.54,167.66 150.95,169.06 152.96,169.06 155.39,171.49 184.8,171.49 185.33,170.96 191.86,170.96 193.96,168.86 202.86,168.86 204.77,166.94 238.52,166.94 243.75,172.18 252.92,172.18 260.82,180.08 264.86,180.08 265.88,181.09 267.27,181.09 269.2,183.02 276.19,183.02 279.03,185.85 280.23,185.85 280.99,185.09 284.12,185.09 286.11,187.09 287.29,187.09 287.61,187.41 287.61,187.74 v3(287.73,187.86)
  BOTTOM w0.089: 155.67,138.33 156.65,138.33 156.72,138.27 157.31,138.27 157.47,138.43 157.75,138.43 158.08,138.09 158.08,137.76 UH1.BC24
  BOTTOM w0.102: 155.67,138.33 151.04,138.33 149.8,139.57 149.8,141.03 147.41,143.42 147.41,149.42 147.13,149.7 147.13,153.12 151.15,157.14 v3(151.15,157.7)
USB3TP2_C: length 2
  TOP w0.102: C1519.2 287.28,189.88 286.98,190.17 286.98,190.45 287.32,190.79 L109.1 287.32,191.55 R3697.1
USB3TP2_D+: length 10.1
  TOP w0.102: R3697.2 287.32,192.5 L109.2 287.32,193.27 287.03,193.55 287.03,193.77 287.2,193.93 D88.5 D88.6 287.2,195.45 287.03,195.61 287.03,195.69 287.17,195.82 287.74,195.82 288.63,194.94 288.63,192.97 289.35,192.25 289.9,192.25 290.02,192.13 JUSB2.9
USB3TP3: length 43
  TOP w0.102: v3(141.35,167.7) 141.23,167.58 141.23,166.87 141.48,166.61 143.13,166.61 143.85,165.89 143.85,164.03 146.2,161.68 147.3,161.68 148.91,160.07 148.91,157.98 149.69,157.2 149.69,152.15 v3(149.77,152.07)
  BOTTOM w0.089: UH1.BC32 158.06,140.99 157.59,140.99 157.26,140.66 156,140.66 155.72,140.95 155.71,140.95
  BOTTOM w0.102: v3(149.77,152.07) 149.77,152.36 149.85,152.43 150.09,152.43 150.24,152.28 150.24,151.44 148.84,150.04 148.84,144.01 151.29,141.57 154.54,141.57 155.16,140.95 155.71,140.95 ; v3(141.35,167.7) 141.18,167.86 141.18,168.04 141.34,168.2 JDOCK1.92
USB3TP5: length 180.9
  TOP w0.102: C418.1 279.58,171.95 279.15,171.95 278.91,172.19 v3(278.91,174.41)
  IN1 w0.114: v3(152.4,157.92) 152.76,158.27 152.89,158.27 153.29,158.68 153.29,160.59 151.17,162.71 151.17,166.58 151.48,166.89 155.22,166.89 156.36,168.04 157.51,168.04 157.7,167.85 160.81,167.85 163.01,170.04 174.8,170.04 180.41,164.44 187.57,164.44 188.69,165.57 198.52,165.57 199.1,164.99 224.04,164.99 224.24,165.19 225.46,165.19 225.74,165.47 240.3,165.47 245.56,170.73 253.54,170.73 258.51,175.69 260.73,175.69 261.08,176.04 268.77,176.04 268.92,176.19 276.24,176.19 277.31,175.12 279.14,175.12 279.3,174.96 279.3,174.81 v3(278.91,174.41)
  BOTTOM w0.089: UH1.BC26 157.98,138.67 157.97,138.67 157.5,138.67 157.32,138.85 157.06,138.85 157.04,138.84 155.29,138.84 155.28,138.85 155.26,138.85
  BOTTOM w0.102: v3(152.4,157.92) 152.28,158.04 152.07,158.04 151.97,157.94 151.97,156.8 147.98,152.81 147.98,150.02 148.23,149.76 148.23,143.76 150.62,141.37 150.62,140.36 151.63,139.36 153.94,139.36 154.45,138.85 155.26,138.85
USB3TP5_C: length 1.8
  TOP w0.102: C418.2 281.03,172.11 281.19,172.11 281.52,171.78 L112.1 282.04,171.78 R3727.1
USB3TP5_D+: length 8.5
  TOP w0.102: JUSB3.9 290.02,173.04 289.92,173.14 289.02,173.14 288.3,172.43 286.74,172.43 286.59,172.28 D91.6 D91.5 284.32,172.28 284.13,172.09 284.13,171.96 283.94,171.78 L112.2 283.24,171.78 R3727.2
USB3TP6: length 186.4
  IN4 w0.114: v3(3.94,185.66) 4.3,185.3 4.3,184.98 4.8,184.48 11.29,184.48 12.47,183.3 17.38,183.3 19.01,181.66 19.01,179.16 30.7,167.46 34.32,167.46 35.87,165.92 39.42,165.92 45.63,159.71 45.97,159.71 52.92,152.76 58.82,152.76 59.56,152.03 65.76,152.03 66.47,151.31 76.77,151.31 77.42,151.96 79.9,151.96 81.78,150.08 89.16,150.08 89.59,149.64 101.88,149.64 108.02,155.79 110.48,155.79 111.37,156.68 121.11,156.68 122.02,157.59 130.42,157.59 131.54,156.47 132.01,156.47 132.7,155.79 132.7,155.34 135.27,152.77 135.78,152.77 136.59,151.96 136.59,151.24 137.2,150.63 138.41,150.63 140.15,148.89 141.09,148.89 145.09,144.9 145.73,144.9 146.53,144.09 149.46,144.09 151.17,142.38 153.76,142.38 155.3,140.84 v3(155.3,139.36)
  BOTTOM w0.089: UH1.BE28 157.05,139.25 156.52,139.25 156.03,139.75 155.69,139.75 v3(155.3,139.36)
  BOTTOM w0.102: v3(3.94,185.66) 4.24,185.37 4.24,185.18 4.17,185.11 3.85,185.11 3.37,185.6 2.86,185.6 2.71,185.75 JIO1.37
USB30_EN: length 6.4
  TOP w0.102: 166.82,54.74 166.82,54.28 167.01,54.09 Q123.5 ; 166.82,54.74 Q123.6 ; 166.82,54.74 166.82,55.02 166.41,55.43 164.52,55.43 R515.2 162.96,55.06 v1(162.8,55.21)
USB30_SMI#: length 118.2
  TOP w0.102: RP19.2 168.19,63.52 168,63.32 168,62.07 v3(167.97,62.04) ; Q123.3 165.88,53.44 v3(166.18,53.14)
  IN1 w0.102: v3(172.72,78.67) 172.72,77.32 170.47,75.07 170.47,63.74 168.77,62.04 v3(167.97,62.04) 167.06,61.13 167.06,54.02 v3(166.18,53.14) ; v3(186.5,108.89) 186.31,109.08 v3(175.45,109.08)
  IN2 w0.089: 177.22,136.4 176.69,136.93 v3(176.69,137.07)
  IN2 w0.127: 177.22,136.4 177.29,136.32 178.82,136.32 180.48,134.66 180.48,129.16 183.11,126.52 185.74,126.52 187.92,124.34 187.92,114.38 185.68,112.13 185.68,109.72 v3(186.5,108.89) ; v3(172.72,78.67) 172.72,79.1 173.68,80.06 175.31,80.06 177.46,82.22 177.46,84.48 178.06,85.08 178.06,86.83 177.8,87.09 177.8,89.25 177.61,89.44 177.61,90.95 178.8,92.14 178.8,94.79 178.87,94.85 178.87,104.11 175.45,107.52 v3(175.45,109.08)
  BOTTOM w0.089: v3(176.69,137.07) 176.51,137.24 175.65,137.24 175.31,136.9 174.94,136.9 UH1.C22
  BOTTOM w0.102: v3(172.72,78.67) 172.28,78.67 v1(171.64,78.03)
USB_MCARD1_DET#: length 52.5
  TOP w0.102: RP20.8 208.96,145.39 v3(209.09,145.25) 209.09,145.21 v1(208.4,144.52)
  IN3 w0.089: 179.38,131.97 179.14,131.97 178.98,131.81 178.28,131.81 177.89,131.42 v3(177.83,131.42)
  IN3 w0.127: 179.38,131.97 182.44,131.97 185.04,134.57 190.27,134.57 191.49,133.35 202.43,133.35 202.67,133.59 v3(204.48,133.59)
  BOTTOM w0.089: UH1.A10 175.93,131.94 176.94,131.94 176.99,131.9 177.22,131.9
  BOTTOM w0.102: v3(177.83,131.42) 177.35,131.9 177.22,131.9 ; v3(204.48,133.59) 204.48,136.15 210.12,141.79 210.12,144.68 209.55,145.25 v3(209.09,145.25) 209.09,145.58 211.34,147.83 JMINI2.40
USB_OC0#: length 214.1
  TOP w0.089: 169.65,126.62 169.65,126.62 v3(170.02,127) 170.3,127 170.76,127.45 RPH3.2
  TOP w0.102: U91.5 287.31,179.93 287.44,179.8 287.44,179.44 v3(287.29,179.29) ; v3(283.62,195.21) 283.61,195.22 U48.5 ; 169.65,126.62 169.65,125.78 170.12,125.31 170.12,122.41 v3(168.8,121.09) 168.8,120.87 168.99,120.68 168.99,120.26 168.87,120.14 R3773.2
  IN1 w0.102: v3(168.8,121.09) 169.63,121.09 170.73,119.99 172.61,119.99 172.95,119.65 172.95,118.38 173.19,118.14 174.6,118.14 175.13,118.67 179.09,118.67 180.69,117.07 195.23,117.07 196.81,118.65 199.38,118.65 199.65,118.38 207.41,118.38 207.52,118.5 210.42,118.5 v3(210.82,118.09) 211.23,118.5 213.82,118.5 215.86,120.54 215.86,135.9 216.22,136.26 217.63,136.26 224.69,143.32 231.1,143.32 232.12,144.33 237.16,144.33 237.97,145.14 249.07,145.14 254.35,150.42 263.03,150.42 264.61,152 264.61,153.53 266.39,155.31 267.27,155.31 267.92,155.96 267.92,161.23 271.54,164.85 271.54,165.2 271.97,165.62 280.16,165.62 281.74,167.2 281.74,170.93 287.29,176.48 v3(287.29,179.29) 285.74,179.29 284.86,180.16 284.86,183.25 287.22,185.61 288.08,185.61 289.36,186.9 289.36,187.99 288.44,188.9 288.44,190.39 v3(283.62,195.21)
  BOTTOM w0.089: v3(170.02,127) 170.18,127.16 170.18,127.57 169.84,127.92 169.84,128.16 170.1,128.43 170.1,128.69 170.15,128.74 UH1.P3
  BOTTOM w0.102: RH3.1 v1(215.6,109.91) 215.6,110.66 215.37,110.88 215.37,112.92 210.82,117.47 v3(210.82,118.09)
USB_OC1#: length 180.7
  TOP w0.102: U93.5 281.35,167.48 v3(281.19,167.33) ; RPH9.1 167.27,125.77 168.84,124.21 v3(168.84,123.27) 168.64,123.08 168.64,121.55 168.11,121.02 168.11,120.28 167.96,120.13 R3773.1
  IN1 w0.102: v3(281.19,167.33) 279.72,165.85 272.07,165.85 271.88,165.85 271.32,165.29 271.32,164.95 267.69,161.32 267.69,156.68 267.17,156.16 266.91,156.16 264.38,153.63 264.38,152.09 262.93,150.65 254.26,150.65 248.97,145.37 237.87,145.37 237.07,144.56 232.02,144.56 231.01,143.55 224.6,143.55 217.54,136.49 216.13,136.49 215.63,136 215.63,120.69 213.67,118.72 211.35,118.72 v3(210.77,119.31) 200.98,119.31 200.51,118.84 199.84,118.84 199.57,119.1 196.62,119.1 195.69,118.18 190.96,118.18 190.31,117.53 180.88,117.53 178.65,119.76 176.64,119.76 175.61,120.79 173.03,120.79 172.69,120.44 170.66,120.44 168.53,122.57 168.53,122.96 v3(168.84,123.27)
  BOTTOM w0.089: UH1.V1 168.52,127.09 168.62,126.99 168.75,126.85 168.75,125.55 v1(168.86,125.44) 168.86,125.12 168.75,125
  BOTTOM w0.102: 168.75,125 168.75,123.36 v3(168.84,123.27) ; RH4.1 216.21,107.62 216.21,112.4 211.14,117.47 211.14,117.78 211.18,117.82 211.18,117.82 211.33,117.98 211.33,118.74 v3(210.77,119.31)
