# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LPC_LDRQ0#: length 1.7
  TOP w0.089: v3(173.68,136.56) 173.64,136.56 173.21,136.13 T87.1
  BOTTOM w0.089: v3(173.68,136.56) 174.44,136.56 UH1.D21
LPC_LDRQ1#: length 98.3
  TOP w0.102: U46.A22 187.12,73.71 187.2,73.8 187.2,74.19 187.62,74.61 v3(187.64,74.61)
  IN2 w0.127: v3(195.9,138.67) 195.9,137.02 196.5,136.43 196.5,128.89 193.46,125.85 193.46,110.1 192.89,109.53 192.89,94.5 190.06,91.67 190.06,86.13 189.51,85.57 189.51,81.43 189.65,81.29 189.65,75.51 188.76,74.61 v3(187.64,74.61)
  IN3 w0.127: v3(195.9,138.67) 195.21,139.37 190.85,139.37 189.37,140.85 182.51,140.85 182.09,140.42 176.5,140.42 175.15,139.07 175.15,137.85 174.45,137.15 173.7,137.15 v3(173.12,136.58)
  BOTTOM w0.089: v3(173.12,136.58) 173.12,136.22 UH1.G20
  BOTTOM w0.102: v3(187.64,74.61) 187.61,74.61 187.09,74.09 v1(187.09,73.62)
LPC_LFRAME#: length 242.8
  TOP w0.102: v3(214.76,110.16) 214.76,109.8 213.31,108.34 U39.22 ; v3(212.41,81.57) 212.68,81.29 U51.B31 ; U46.A21 v3(187.62,74.03)
  IN2 w0.127: v3(212.41,81.57) 212.6,81.76 212.6,83.05 211.65,84 210.11,84 209.64,84.47 209.64,86.77 212.19,89.32 212.19,90.08 212.42,90.31 212.42,107.11 214.16,108.85 214.16,109.56 v3(214.76,110.16) 213.86,111.06 213.86,113.98 208.7,119.14 208.7,123.03 208.07,123.66 208.07,126.76 206.59,128.23 206.59,133.94 205.68,134.86 205.68,135.97 v3(206.01,136.3)
  IN3 w0.127: v3(177.87,136.83) 178.73,137.7 204.61,137.7 v3(206.01,136.3) ; v3(262.12,166.58) 261.14,165.6 255.49,165.6 254.32,164.43 254.32,161.7 251.44,158.82 251.44,156.3 249.39,154.26 249.39,146.69 247.17,144.47 247.17,141.77 238.1,132.69 238.1,124.5 232.78,119.18 229.6,119.18 227.12,116.7 222.6,116.7 219.09,113.2 219.09,110.9 218.35,110.16 v3(214.76,110.16) ; v3(212.41,81.57) 207.63,81.57 207.46,81.4 205.04,81.4 203.86,80.22 202.27,80.22 201.46,79.4 201.46,77.59 199.55,75.68 197.99,75.68 197.45,76.23 195.75,76.23 195.37,75.85 190.2,75.85 188.38,74.03 v3(187.62,74.03)
  BOTTOM w0.089: UH1.B21 175.8,136.56 175.88,136.48 176.99,136.48 177.04,136.53 177.22,136.53
  BOTTOM w0.102: v3(212.41,81.57) v1(211.77,81.57) ; v3(262.12,166.58) 262.93,167.39 262.93,168.5 267.78,173.34 267.78,176.03 268.56,176.81 268.56,179.29 270.6,181.33 275.12,181.33 276.74,182.95 JMINI3.8 ; 177.22,136.53 177.56,136.53 v3(177.87,136.83)
LX_PCIE: length 2.2
  BOTTOM w0.102: v1(109.81,134.15) 109.81,134.97 108.8,135.97
M_CLK_DDR0: length 61.4
  IN4 w0.102: v3(128.47,78.2) 128.64,78.03 128.77,78.03 128.9,78.16 128.9,78.36 128.56,78.7 128.23,78.7 128.07,78.54 128.07,75.41 128.71,74.76 128.71,61.94 128.46,61.69 128.46,61.19 128.71,60.94 128.71,60.31 128.5,60.1 127.74,60.1 127.62,59.97 127.62,59.72 127.74,59.59 128.46,59.59 128.71,59.34 128.71,58.91 128.46,58.65 127.74,58.65 127.62,58.53 127.62,58.27 127.74,58.14 128.46,58.14 128.71,57.89 128.71,57.46 128.46,57.2 127.74,57.2 127.62,57.08 127.62,56.82 127.74,56.7 128.46,56.7 128.71,56.45 128.71,53.83 128.5,53.62 127.74,53.62 127.62,53.5 127.62,53.09 127.74,52.96 128.46,52.96 128.71,52.71 128.71,52.28 128.46,52.02 127.72,52.02 127.62,51.92 127.62,51.62 127.72,51.51 128.46,51.51 128.71,51.26 128.71,50.83 128.46,50.57 127.72,50.57 127.62,50.47 127.62,50.17 127.72,50.07 128.24,50.07 128.49,49.81 128.49,49.38 128.24,49.13 127.44,49.13 127.31,49 127.31,48.75 127.44,48.62 127.73,48.62 127.98,48.37 127.98,47.93 127.73,47.68 127.43,47.68 127.31,47.56 127.31,46.8 124.02,43.5 124.02,38.49 124.17,38.34 124.33,38.34 124.44,38.45 v3(124.44,38.71)
  BOTTOM w0.089: v3(128.47,78.2) JCPU1.V4
  BOTTOM w0.102: v3(124.44,38.71) 124.44,38.62 124.08,38.26 123.86,38.26 123.54,37.93 123.54,36.99 123.84,36.69 JDIMM1.101
M_CLK_DDR1: length 60.4
  IN4 w0.102: v3(128.47,77.2) 128.83,76.84 128.83,74.93 129.22,74.54 129.22,48.93 129.12,48.83 128.74,48.83 128.49,48.57 128.49,47.25 124.53,43.29 124.53,39.96 125.03,39.46 125.03,39 125.52,38.51 125.52,37.17 125.42,37.07 125.13,37.07 124.91,36.84 124.91,36.35 125.13,36.13 125.42,36.13 125.52,36.02 125.52,35.72 125.42,35.62 124.45,35.62 124.19,35.36 124.19,34.93 124.45,34.68 125.42,34.68 125.52,34.58 125.52,34.27 125.42,34.17 125.01,34.17 124.75,33.92 124.75,33.48 125.01,33.23 125.52,33.23 125.64,33.1 125.64,32.85 125.52,32.72 125.01,32.72 124.76,32.47 124.76,32.04 125.01,31.78 125.43,31.78 125.55,31.66 125.55,30.41 125.43,30.28 125.11,30.28 125.05,30.34 v3(125.05,30.51)
  BOTTOM w0.089: v3(128.47,77.2) JCPU1.V3
  BOTTOM w0.102: JDIMM1.102 124.14,28.3 124.29,28.45 124.37,28.53 124.37,29.65 125.05,30.32 v3(125.05,30.51)
M_CLK_DDR2: length 80
  IN1 w0.102: v3(124.36,19.07) 124.36,19.33 124.32,19.37 123.62,19.37 123.36,19.62 123.36,21.18 123.62,21.44 124.41,21.44 124.54,21.56 124.54,22.21 124.41,22.34 122.34,22.34 122.09,22.59 122.09,23.27 122.34,23.52 123.88,23.52 124.01,23.65 124.01,25.99 123.88,26.11 122.32,26.11 122.07,26.37 122.07,26.98 122.32,27.23 123.88,27.23 124.01,27.36 124.01,27.74 123.88,27.87 122.75,27.87 122.53,28.08 122.53,40.75 122.78,41.01 123.89,41.01 124.02,41.13 124.02,41.39 123.89,41.51 123.2,41.51 122.93,41.78 122.93,54.65 126.44,58.15 126.44,75.54 126.06,75.91 125.06,75.91 124.83,76.14 124.83,78.4 125.49,79.06 v3(125.49,79.16)
  BOTTOM w0.089: v3(125.49,79.16) 125.06,78.73 JCPU1.AA4
  BOTTOM w0.102: JDIMM2.101 123.84,22.15 123.84,21.03 123.6,20.79 123.6,19.65 123.89,19.36 124.12,19.36 124.36,19.11 v3(124.36,19.07)
M_CLK_DDR3: length 78.9
  IN1 w0.102: v3(124.36,16.78) 124.56,16.98 124.91,16.98 125.48,17.54 125.48,24 124.95,24.53 124.95,28.51 123.87,29.59 123.87,34.01 123.6,34.28 123.47,34.41 123.47,35.81 123.57,35.91 123.79,35.91 124.04,36.17 124.04,36.6 123.79,36.85 123.57,36.85 123.47,36.95 123.47,39.94 123.6,40.07 124.66,40.07 124.96,40.36 124.96,42.22 124.73,42.45 124.16,42.45 124.03,42.57 124.03,42.83 124.16,42.95 124.73,42.95 124.96,43.18 124.96,43.67 124.73,43.89 124,43.89 123.87,44.02 123.87,44.27 124,44.4 124.73,44.4 124.96,44.63 124.96,45.11 124.73,45.34 124,45.34 123.87,45.47 123.87,45.72 124,45.85 124.73,45.85 124.96,46.08 124.96,46.56 124.73,46.79 124,46.79 123.87,46.92 123.87,47.17 124,47.3 124.56,47.3 124.82,47.55 124.82,47.98 124.56,48.24 124,48.24 123.87,48.36 123.87,54.26 127.38,57.76 127.38,75.75 126.11,77.02 126.11,77.42 125.81,77.72 125.69,77.72 125.5,77.91 v3(125.5,78.19)
  BOTTOM w0.089: JCPU1.AA3 125.04,77.73 v3(125.5,78.19)
  BOTTOM w0.102: JDIMM2.102 124.14,14.97 124.33,15.16 124.33,15.38 124.78,15.83 124.78,16.88 124.69,16.97 124.55,16.97 v3(124.36,16.78)
M_CLK_DDR#0: length 61.4
  IN4 w0.102: v3(129.47,78.2) 129.37,78.2 128.65,78.92 128.14,78.92 127.85,78.63 127.85,75.32 128.49,74.67 128.49,62.03 128.25,61.78 128.25,61.1 128.49,60.85 128.49,60.4 128.41,60.32 127.65,60.32 127.4,60.06 127.4,59.63 127.65,59.38 128.37,59.38 128.49,59.25 128.49,59 128.37,58.87 127.65,58.87 127.4,58.62 127.4,58.18 127.65,57.93 128.37,57.93 128.49,57.8 128.49,57.55 128.37,57.42 127.65,57.42 127.4,57.17 127.4,56.73 127.65,56.48 128.37,56.48 128.49,56.36 128.49,53.92 128.41,53.84 127.65,53.84 127.4,53.59 127.4,53 127.65,52.75 128.37,52.75 128.49,52.62 128.49,52.37 128.37,52.24 127.63,52.24 127.4,52.01 127.4,51.53 127.63,51.3 128.37,51.3 128.49,51.17 128.49,50.92 128.37,50.79 127.63,50.79 127.4,50.56 127.4,50.08 127.63,49.85 128.15,49.85 128.28,49.72 128.28,49.47 128.15,49.34 127.35,49.34 127.1,49.09 127.1,48.66 127.35,48.4 127.64,48.4 127.76,48.28 127.76,48.02 127.64,47.9 127.35,47.9 127.1,47.65 127.1,46.88 123.81,43.59 123.81,38.4 124.08,38.12 124.27,38.12 v3(124.44,37.95)
  BOTTOM w0.089: v3(129.47,78.2) JCPU1.U4
  BOTTOM w0.102: JDIMM1.103 124.44,36.41 123.76,37.09 123.76,37.84 123.95,38.03 124.36,38.03 v3(124.44,37.95)
M_CLK_DDR#1: length 60.4
  IN4 w0.102: v3(125.05,29.75) 125.05,29.95 125.16,30.06 125.52,30.06 125.77,30.32 125.77,31.74 125.52,32 125.1,32 124.98,32.12 124.98,32.38 125.1,32.51 125.61,32.51 125.86,32.76 125.86,33.19 125.61,33.45 125.1,33.45 124.97,33.57 124.97,33.83 125.1,33.95 125.5,33.95 125.73,34.18 125.73,34.67 125.5,34.89 124.54,34.89 124.41,35.02 124.41,35.27 124.54,35.4 125.5,35.4 125.73,35.63 125.73,36.11 125.5,36.34 125.22,36.34 125.12,36.44 125.12,36.75 125.22,36.85 125.5,36.85 125.73,37.08 125.73,38.6 125.24,39.09 125.24,39.55 124.75,40.05 124.75,43.2 128.7,47.16 128.7,48.48 128.83,48.61 129.21,48.61 129.43,48.84 129.43,74.63 129.05,75.02 129.05,77.22 129.11,77.29 v3(129.47,77.29)
  BOTTOM w0.089: v3(129.47,77.29) 129.48,77.29 129.04,77.73 JCPU1.U3
  BOTTOM w0.102: JDIMM1.104 124.74,28.38 124.6,28.52 124.6,29.55 124.8,29.75 v3(125.05,29.75)
M_CLK_DDR#2: length 80
  IN1 w0.102: v3(126.45,79.21) 126.37,79.21 125.85,78.69 125.42,78.69 125.05,78.31 125.05,76.23 125.15,76.13 126.15,76.13 126.65,75.62 126.65,58.06 123.15,54.56 123.15,41.87 123.29,41.73 123.98,41.73 124.23,41.48 124.23,41.04 123.98,40.79 122.87,40.79 122.75,40.66 122.75,28.17 122.84,28.08 123.97,28.08 124.22,27.83 124.22,27.27 123.97,27.02 122.41,27.02 122.28,26.89 122.28,26.46 122.41,26.33 123.97,26.33 124.22,26.08 124.22,23.56 123.97,23.31 122.43,23.31 122.3,23.18 122.3,22.68 122.43,22.56 124.5,22.56 124.75,22.3 124.75,21.47 124.5,21.22 123.71,21.22 123.58,21.09 123.58,19.71 123.71,19.59 124.26,19.59 124.36,19.7 v3(124.36,19.83)
  BOTTOM w0.089: JCPU1.Y4 125.97,78.73 v3(126.45,79.21)
  BOTTOM w0.102: v3(124.36,19.83) 124.12,19.59 123.98,19.59 123.83,19.75 123.83,20.69 124.13,21 124.3,21 124.44,21.14 JDIMM2.103
M_CLK_DDR#3: length 78.9
  IN1 w0.102: v3(124.36,17.55) 124.36,17.3 124.47,17.19 124.82,17.19 125.26,17.63 125.26,23.91 124.73,24.44 124.73,28.42 123.66,29.5 123.66,33.92 123.51,34.06 123.25,34.32 123.25,35.9 123.48,36.13 123.7,36.13 123.83,36.26 123.83,36.51 123.7,36.64 123.48,36.64 123.25,36.87 123.25,40.03 123.51,40.28 124.57,40.28 124.74,40.45 124.74,42.13 124.64,42.23 124.07,42.23 123.82,42.48 123.82,42.92 124.07,43.17 124.64,43.17 124.74,43.27 124.74,43.58 124.64,43.68 123.91,43.68 123.66,43.93 123.66,44.36 123.91,44.62 124.64,44.62 124.74,44.72 124.74,45.02 124.64,45.12 123.91,45.12 123.66,45.38 123.66,45.81 123.91,46.06 124.64,46.06 124.74,46.17 124.74,46.47 124.64,46.57 123.91,46.57 123.66,46.83 123.66,47.26 123.91,47.51 124.47,47.51 124.6,47.64 124.6,47.89 124.47,48.02 123.91,48.02 123.66,48.27 123.66,54.35 127.16,57.85 127.16,75.67 125.89,76.93 125.89,77.33 125.72,77.51 125.6,77.51 125.58,77.52 125.54,77.52 125.45,77.42 v3(125.45,77.15)
  BOTTOM w0.089: v3(125.45,77.15) 125.94,77.65 JCPU1.Y3
  BOTTOM w0.102: v3(124.36,17.55) 124.71,17.2 124.78,17.2 125.01,16.97 125.01,15.74 124.55,15.29 124.55,15.14 124.74,14.95 JDIMM2.104
M_ODT0: length 67.1
  IN4 w0.165: v3(134.47,82.17) 135.03,81.61 135.03,75.05 135.3,74.79 135.92,74.79 136.47,74.24 136.47,45.14 132.15,40.82 132.15,35.12 132.02,35 131.36,35 131.24,34.87 131.24,34.46 131.36,34.34 132.02,34.34 132.15,34.21 132.15,33.61 132.02,33.48 130.09,33.48 129.97,33.36 129.97,32.95 130.09,32.82 132.02,32.82 132.15,32.7 132.15,32.25 132.02,32.12 130.09,32.12 129.97,31.99 129.97,31.5 129.51,31.05 129.51,30.71 v3(128.94,30.13)
  BOTTOM w0.089: JCPU1.M8 133.94,82.7 v3(134.47,82.17)
  BOTTOM w0.165: JDIMM1.116 128.34,29.53 v3(128.94,30.13)
M_ODT1: length 66.1
  IN4 w0.165: v3(135.47,81.17) 135.98,80.66 135.98,75.11 136.97,74.12 136.97,44.94 132.65,40.62 132.65,32.27 132.78,32.14 133.16,32.14 133.29,32.01 133.29,31.6 133.16,31.48 130.94,31.48 130.81,31.35 130.81,30.94 130.94,30.82 133.25,30.82 133.38,30.69 133.38,30.09 133.25,29.96 130.33,29.96 130.21,30.09 v3(130.21,30.13)
  BOTTOM w0.089: JCPU1.L7 134.94,81.7 v3(135.47,81.17)
  BOTTOM w0.165: v3(130.21,30.13) 129.54,29.46 JDIMM1.120
M_ODT2: length 80.3
  IN1 w0.089: v3(131.47,78.2) 130.85,77.57 130.85,75.85 131.92,74.77 131.92,73.63
  IN1 w0.165: 131.92,73.63 131.92,65.84 132.02,65.74 132.72,65.74 133.24,65.22 133.24,52.25 133.08,52.08 132.18,52.08 132.02,51.92 132.02,51.58 132.18,51.42 133.08,51.42 133.24,51.25 133.24,50.92 133.08,50.76 132.18,50.76 132.02,50.59 132.02,50.26 132.18,50.1 133.08,50.1 133.24,49.93 133.24,49.6 133.08,49.44 132.18,49.44 132.02,49.27 132.02,48.94 132.18,48.78 133.08,48.78 133.24,48.61 133.24,48.28 133.08,48.12 132.18,48.12 132.02,47.95 132.02,47.62 132.18,47.46 133.08,47.46 133.24,47.29 133.24,46.96 133.08,46.8 132.18,46.8 132.02,46.63 132.02,46.3 132.18,46.14 133.08,46.14 133.24,45.97 133.24,45.64 133.08,45.48 132.18,45.48 132.02,45.31 132.02,42 131.22,41.2 131.22,24.03 129.73,22.55 129.73,21.75 129.73,21.29 129.25,20.81 129.25,18.5 v3(128.68,17.93)
  BOTTOM w0.089: v3(131.47,78.2) JCPU1.R4
  BOTTOM w0.165: JDIMM2.116 128.34,15.01 128.54,15.2 128.86,15.2 129.29,15.63 129.29,17.31 v3(128.68,17.93)
M_ODT3: length 79.6
  IN1 w0.089: 132.91,73.63 132.91,74.32 131.47,75.76 v3(131.47,77.2)
  IN1 w0.165: v3(130.81,17.93) 130.37,17.93 130.24,18.05 130.24,20.4 130.72,20.88 130.72,21.33 130.72,22.14 132.21,23.62 132.21,40.79 133.4,41.98 133.42,41.98 134.24,42.8 134.24,44.52 134.3,44.59 135.09,44.59 135.26,44.75 135.26,45.08 135.09,45.25 134.36,45.25 134.24,45.37 134.24,45.78 134.36,45.91 135.09,45.91 135.26,46.07 135.26,46.4 135.09,46.57 134.36,46.57 134.24,46.7 134.24,47.1 134.36,47.23 135.09,47.23 135.26,47.39 135.26,47.72 135.09,47.89 134.36,47.89 134.24,48.02 134.24,48.42 134.36,48.55 135.09,48.55 135.26,48.71 135.26,49.04 135.09,49.21 134.87,49.21 134.71,49.38 134.71,49.82 134.87,49.99 135.15,49.99 135.33,50.16 135.33,50.47 135.15,50.65 134.87,50.65 134.71,50.81 134.71,51.14 134.87,51.31 135.15,51.31 135.33,51.48 135.33,51.79 135.15,51.97 134.87,51.97 134.71,52.13 134.71,52.46 134.87,52.63 135.15,52.63 135.33,52.8 135.33,53.11 135.15,53.29 134.87,53.29 134.71,53.45 134.71,53.78 134.87,53.95 135.15,53.95 135.33,54.12 135.33,54.44 135.15,54.61 134.87,54.61 134.71,54.77 134.71,55.13 134.87,55.3 135.2,55.3 135.33,55.43 135.33,55.83 135.2,55.96 134.87,55.96 134.71,56.13 134.71,56.46 134.87,56.62 135.2,56.62 135.33,56.75 135.33,57.15 135.2,57.28 134.87,57.28 134.71,57.45 134.71,62.94 134.29,63.35 134.29,65.57 132.91,66.95 132.91,73.63
  BOTTOM w0.089: v3(131.47,77.2) JCPU1.R3
  BOTTOM w0.165: JDIMM2.120 129.54,15.18 129.79,15.43 129.79,16.9 v3(130.81,17.93)
MAA0_0: length 33.7
  TOP w0.089: UV4.H4 v3(81,104.06)
  IN4 w0.127: v3(81,104.06) 81,104.06 80.78,104.06 80.39,104.46 79.94,104.46 79.81,104.59 79.81,109.85 79.01,110.65 78.83,110.65 78.32,110.13 78.14,110.13 77.94,110.33 77.94,110.51 78.45,111.02 78.45,111.2 78.26,111.4 78.08,111.4 77.56,110.89 77.38,110.89 77.18,111.08 77.18,111.26 77.7,111.78 77.7,111.96 75.73,113.92 75.73,119.27 75.13,119.88 75.13,121.84 74.61,122.35 74.61,123.42 73.51,124.52 73.51,126.05 73.33,126.22 73.33,127.83 72.77,128.39 v3(72.51,128.39)
  BOTTOM w0.089: v3(72.51,128.39) 72.51,128.47 UV1.K17 ; UV4.H4 v3(81,104.06)
MAA0_1: length 32.8
  TOP w0.089: UV4.H5 v3(81.8,104.06)
  IN4 w0.127: v3(81.8,104.06) 81.8,104.06 81.4,104.47 80.82,104.47 80.6,104.69 80.6,109.86 76.37,114.09 76.37,114.43 76.5,114.56 76.97,114.56 77.1,114.69 77.1,114.96 76.97,115.09 76.5,115.09 76.37,115.22 76.37,115.5 76.5,115.63 76.97,115.63 77.1,115.75 77.1,116.03 76.97,116.16 76.5,116.16 76.37,116.29 76.37,119.59 76.25,119.71 76.25,121.86 75.91,122.2 75.55,122.2 74.96,122.79 74.96,123.61 73.75,124.82 73.75,126.39 74.26,126.9 74.26,127.8 74.39,127.92 v3(74.98,127.92)
  BOTTOM w0.089: v3(74.98,127.92) 74.71,128.2 UV1.J20 ; UV4.H5 v3(81.8,104.06)
MAA0_2: length 31
  TOP w0.089: UV4.H11 v3(86.6,103.26)
  IN4 w0.127: v3(76.16,126.95) 76.16,126.4 76.66,125.9 76.66,124.8 77.83,123.62 77.83,121.27 79.29,119.82 79.29,116.89 81,115.18 81,114.14 83.5,111.64 83.5,110.2 84.29,109.41 84.29,103.98 85.4,102.87 86.21,102.87 v3(86.6,103.26)
  BOTTOM w0.089: UV4.H11 v3(86.6,103.26)
  BOTTOM w0.13: v3(76.16,126.95) UV1.H23
MAA0_3: length 34
  TOP w0.089: UV4.H10 v3(86.6,104.06)
  IN4 w0.127: v3(86.6,104.06) 86.6,104.06 86.21,103.67 85.37,103.67 84.73,104.31 84.73,109.59 83.94,110.37 83.94,111.82 82.94,112.81 82.94,112.99 83.45,113.5 83.45,113.68 83.25,113.88 83.07,113.88 82.56,113.37 82.38,113.37 82.19,113.57 82.19,113.75 82.89,114.45 82.89,114.63 82.69,114.83 82.51,114.83 81.81,114.13 81.63,114.13 81.43,114.32 81.43,114.5 82.13,115.2 82.13,115.38 80.78,116.73 80.06,116.73 79.72,117.07 79.72,119.91 78.16,121.47 78.16,123.92 77.01,125.07 v3(77.01,126.2)
  BOTTOM w0.089: UV4.H10 v3(86.6,104.06)
  BOTTOM w0.13: UV1.G23 v3(77.01,126.2)
MAA0_4: length 36.3
  TOP w0.089: UV4.K11 v3(86.6,101.66)
  IN4 w0.127: v3(77.81,127.05) 77.81,127.05 78.42,127.65 79.75,127.65 81.09,126.31 81.09,124.07 82.17,122.99 82.17,122.23 82.49,121.91 82.74,121.91 83.55,121.11 83.55,117.54 87.38,113.71 87.38,113.06 88.74,111.7 88.74,108.04 89.03,107.75 89.03,102.35 88.42,101.74 88.21,101.74 87.67,101.21 87.25,101.21 86.8,101.66 86.61,101.66 v3(86.6,101.66)
  BOTTOM w0.089: UV4.K11 v3(86.6,101.66) ; v3(77.81,127.05) 77.38,126.62 UV1.G24
MAA0_5: length 39
  TOP w0.089: UV4.K10 v3(85.8,101.66)
  IN4 w0.127: v3(85.8,101.66) 85.8,101.67 86.2,101.27 86.81,101.27 87.1,100.98 87.77,100.98 88.25,101.46 88.78,101.46 89.35,102.04 89.35,112.36 83.98,117.72 83.98,121.81 81.51,124.29 81.51,126.39 79.95,127.94 77.9,127.94 v3(77.01,127.05)
  BOTTOM w0.089: UV1.H24 77.36,127.4 v3(77.01,127.05) ; UV4.K10 v3(85.8,101.66)
MAA0_6: length 35.6
  TOP w0.089: UV4.K5 v3(81.8,101.66)
  IN4 w0.089: v3(81.8,101.66) 81.38,101.24 78.16,101.24
  IN4 w0.127: v3(72.58,127.47) 72.07,126.96 72.07,126.19 72.14,126.12 72.14,124.83 72.58,124.39 72.58,123.8 73.01,123.37 73.01,122.47 72.91,122.37 72.91,114.3 75.48,111.72 75.48,102.85 77.09,101.24 78.16,101.24
  BOTTOM w0.089: v3(72.58,127.47) 73.18,128.07 UV1.J19 ; UV4.K5 v3(81.8,101.66)
MAA0_7: length 35.5
  TOP w0.089: UV4.K4 v3(81.8,102.46)
  IN4 w0.127: v3(81.8,102.46) 81.81,102.46 83.17,102.46 83.86,103.15 83.86,109.23 83.07,110.02 83.07,111.46 80.57,113.96 80.57,115 78.86,116.71 78.86,119.72 77.41,121.17 77.41,122.22 76.93,122.7 76.93,124 76.21,124.72 76.21,125.72 75.69,126.23 75.69,128.77 75.25,129.21 74.35,129.21 v3(73.83,128.69)
  BOTTOM w0.089: UV1.K19 73.52,129 v3(73.83,128.69) ; UV4.K4 v3(81.8,102.46)
MAA0_8: length 32.3
  TOP w0.089: UV4.J5 v3(81.8,103.26)
  IN4 w0.127: v3(74.98,126.66) 74.96,126.64 74.96,124.95 76.28,123.62 76.28,122.47 76.8,121.95 76.8,120.58 77.96,119.41 77.96,115.35 80.54,112.77 80.54,112.59 80.06,112.11 80.06,111.93 80.25,111.74 80.43,111.74 80.91,112.22 81.09,112.22 81.29,112.02 81.29,111.84 80.81,111.36 80.81,111.18 81.01,110.98 81.19,110.98 81.67,111.46 81.85,111.46 82.21,111.1 82.21,109.66 83,108.87 83,104.13 82.13,103.26 81.81,103.26 v3(81.8,103.26)
  BOTTOM w0.089: UV4.J5 v3(81.8,103.26) ; v3(74.98,126.66) 74.92,126.6 UV1.G20
MAA1_0: length 31.2
  TOP w0.089: UV3.K4 v3(67.46,103.26)
  IN4 w0.089: v3(71.43,127.05) 71.03,126.65 71.03,125.92
  IN4 w0.127: v3(67.46,103.26) 67.86,103.65 67.86,104.21 68.51,104.87 70.18,104.87 70.92,105.6 70.92,110.65 71.91,111.64 71.91,119.34 72.42,119.85 72.42,122.13 71.76,122.8 71.76,124.39 71.6,124.54 71.6,125.5 71.52,125.59 71.38,125.72 71.23,125.72 71.03,125.92
  BOTTOM w0.089: UV3.K4 v3(67.46,103.26)
  BOTTOM w0.13: UV1.J14 70.01,127.77 70.93,127.77 71.09,127.61 v3(71.43,127.05)
MAA1_1: length 32.4
  TOP w0.089: UV3.K5 v3(66.66,104.06)
  IN4 w0.089: 70.81,126.18 70.81,127 71.31,127.5 71.58,127.5 71.83,127.75 71.83,128.9 71.61,129.12 70.31,129.12 v3(70.18,129)
  IN4 w0.127: v3(66.66,104.06) 67.11,104.51 67.67,104.51 68.83,105.67 70.22,105.67 70.49,105.93 70.49,110.82 71.48,111.82 71.48,120.44 71.49,120.44 71.49,124.24 70.75,124.97 70.75,126.12 70.81,126.18
  BOTTOM w0.089: UV3.K5 v3(66.66,104.06)
  BOTTOM w0.13: UV1.K14 v3(70.18,129)
MAA1_2: length 33.6
  TOP w0.089: UV3.K11 v3(61.86,104.06)
  IN4 w0.127: v3(67.76,127.95) 68.26,127.44 68.26,126.17 68.01,125.91 67.51,125.91 67.3,125.69 67.3,119.24 67.16,119.1 67.16,115.93 64.88,113.65 64.88,113.01 65.01,112.88 66.54,112.88 66.67,112.75 66.67,112.47 66.54,112.35 65.01,112.35 64.88,112.22 64.88,111.94 65.01,111.81 65.47,111.81 65.6,111.69 65.6,111.41 65.47,111.28 65.01,111.28 64.88,111.15 64.88,110.68 63.06,108.86 63.06,104.64 62.89,104.47 62.44,104.47 62.03,104.06 v3(61.86,104.06)
  BOTTOM w0.089: UV3.K11 v3(61.86,104.06)
  BOTTOM w0.13: UV1.J11 v3(67.76,127.95)
MAA1_3: length 33.8
  TOP w0.089: UV3.K10 v3(62.66,104.06)
  IN4 w0.127: v3(62.66,104.06) 62.26,103.65 62.26,103.03 62.43,102.85 63.36,102.85 63.49,102.99 63.49,108.68 67.1,112.29 67.1,113.35 66.97,113.48 66.33,113.48 66.21,113.6 66.21,114.19 66.33,114.31 67.78,114.31 68.02,114.56 68.02,119.29 67.53,119.79 67.53,121.99 68.23,122.69 68.23,125.75 68.36,125.89 68.52,126.05 68.52,126.66 v3(68.93,127.07)
  BOTTOM w0.089: v3(68.93,127.07) 68.93,127.47 68.38,128.02 UV1.J13 ; UV3.K10 v3(62.66,104.06)
MAA1_4: length 37.1
  TOP w0.089: UV3.H11 v3(61.86,101.66)
  IN4 w0.127: v3(61.86,101.66) 61.86,101.48 61.04,100.66 59.8,100.66 59.5,100.96 59.5,101.97 58.8,102.67 58.8,104.65 59.06,104.91 59.06,112.02 63.56,116.52 63.56,123.47 63.37,123.66 63.37,126.39 63.84,126.86 63.84,127.57 64.4,128.13 66.22,128.13 v3(66.56,127.8)
  BOTTOM w0.089: UV3.H11 v3(61.86,101.66)
  BOTTOM w0.13: UV1.H11 v3(66.56,127.8)
MAA1_5: length 36.6
  TOP w0.089: UV3.H10 v3(61.86,102.46)
  IN4 w0.127: v3(66.56,127) 65.8,127.75 64.56,127.75 64.22,127.41 64.22,126.7 63.71,126.19 63.71,123.8 63.99,123.52 63.99,116.34 60.09,112.44 60.09,110.54 59.87,110.33 59.87,105.11 59.13,104.37 59.13,102.85 59.86,102.12 59.86,101.11 59.95,101.02 61.02,101.02 61.47,101.46 61.47,102.07 v3(61.86,102.46)
  BOTTOM w0.089: UV3.H10 v3(61.86,102.46)
  BOTTOM w0.13: UV1.G11 v3(66.56,127)
MAA1_6: length 30.6
  TOP w0.089: UV3.H5 v3(65.86,102.46)
  IN4 w0.089: v3(70.21,128.2) 69.61,127.6 69.61,126.05 68.97,125.41
  IN4 w0.127: v3(65.86,102.46) 65.56,102.46 64.8,103.22 64.8,108.15 69.35,112.7 69.35,122.23 68.97,122.61 68.97,125.41
  BOTTOM w0.089: UV3.H5 v3(65.86,102.46)
  BOTTOM w0.13: v3(70.21,128.2) UV1.J16
MAA1_7: length 33.8
  TOP w0.089: UV3.H4 v3(66.66,102.46)
  IN4 w0.089: v3(69.08,128.72) 69.6,128.21 69.6,127.88 69.41,127.69 69.41,126.16 68.71,125.46
  IN4 w0.127: 68.71,125.46 68.71,122.36 68.89,122.18 68.89,112.86 64.38,108.35 64.38,103.07 65.41,102.04 66.24,102.04 v3(66.66,102.46)
  BOTTOM w0.089: UV3.H4 v3(66.66,102.46)
  BOTTOM w0.13: v3(69.08,128.72) 69.08,129.15 69.73,129.8 UV1.L15
MAA1_8: length 30.9
  TOP w0.089: UV3.J5 v3(65.86,103.26)
  IN4 w0.127: v3(65.86,103.26) 65.94,103.34 65.94,105.12 66.27,105.44 66.27,106.67 66.45,106.85 68.58,106.85 68.74,107.02 68.74,108.46 68.61,108.58 67.31,108.58 67.18,108.71 67.18,108.99 67.31,109.12 68.61,109.12 68.74,109.24 68.74,110.87 70.21,112.35 70.21,120.79 70.21,120.8 v3(70.21,126.55)
  BOTTOM w0.089: UV3.J5 v3(65.86,103.26)
  BOTTOM w0.13: UV1.G14 v3(70.21,126.55)
MASK_BASE_LEDS#: length 81.3
  TOP w0.102: v3(228.5,105.25) 228.82,105.56 Q100.2 ; Q84.2 224.72,112.41 v3(224.98,112.68) ; Q74.2 225.76,109.72 v3(226.11,110.07) 227.09,111.05 228.46,111.05 U58.4
  IN2 w0.127: v3(228.5,105.25) 229.67,106.42 229.67,108.89 228.49,110.07 v3(226.11,110.07) 224.98,111.2 v3(224.98,112.68) ; v3(223.9,159.82) v3(225.27,159.82)
  IN4 w0.102: v3(227.48,141.38) 227.28,141.18 227.28,116.42 225.66,114.8 225.66,113.35 v3(224.98,112.68)
  BOTTOM w0.102: Q83.2 224.72,164.58 223.9,163.77 v3(223.9,159.82) 224.08,159.64 224.08,156.71 224.44,156.35 224.44,154.49 225.11,153.81 225.11,151.52 225.68,150.95 225.68,149.91 226.42,149.18 v1(226.42,148.77) 226.42,142.45 v3(227.48,141.38) ; v3(225.27,159.82) 225.27,162.87 226.32,163.91 226.32,164.4 226.49,164.58 Q83.5
MASK_SATA_LED#: length 78.4
  TOP w0.102: v3(226.07,109.3) 226.49,109.72 Q74.5 ; U46.B9 189.81,67.81 189.74,67.74 v3(189.74,67.75)
  IN1 w0.102: v3(226.07,109.3) 224.5,109.3 222.06,106.86 209.55,106.86 208.05,108.36 202.53,108.36 v3(201.68,109.21)
  IN2 w0.127: v3(189.74,67.75) 190.1,67.75 190.54,68.18 192.84,68.18 193.64,68.98 194.23,68.98 195.38,70.13 195.38,76.24 195.92,76.78 195.92,79.33 196.2,79.61 196.2,83.45 197.13,84.38 197.13,88.03 198.14,89.03 198.14,92.45 202.44,96.75 202.44,100.13 202.12,100.45 202.12,108.77 v3(201.68,109.21)
  BOTTOM w0.102: v3(189.74,67.75) v1(190.63,67.75)
MCARD_MISC_PWREN: length 178.7
  TOP w0.102: v3(181.92,63.92) 182.37,63.47 U46.B53 ; v3(260.48,152.54) 260.78,152.84 260.78,156.77 260.78,162.74 261.63,163.59 261.63,166.9 v2(266.05,171.32) 267.08,172.35 267.08,173.35 266.77,173.66 266.14,173.66 R733.1 265.75,175 265.65,175.09 U145.5
  IN3 w0.127: v3(181.92,63.92) 181.92,64.04 182.32,64.44 182.88,64.44 183.48,65.04 187.97,65.04 188.39,64.62 188.39,63.76 188.69,63.45 190.28,63.45 190.92,64.1 195.22,64.1 195.9,64.78 203.49,64.78 205.03,63.24 207.4,63.24 208.19,64.02 215.93,64.02 217.63,65.73 223.26,65.73 232.82,75.29 232.82,104.16 244.62,115.95 244.62,131.92 247.81,135.12 249.3,135.12 252.99,138.81 252.99,149.38 254.16,150.55 256.69,150.55 258.79,152.65 260.37,152.65 v3(260.48,152.54)
MCARD_PCIE_SATA#: length 157.5
  TOP w0.089: v3(162,127.39) 163.32,126.06 163.32,125.32 163.64,125
  TOP w0.102: 163.64,125 RH226.1 163.14,123.58 163.14,122.17 RH224.2 ; U46.B3 190.46,64.8 189.91,64.8 v3(189.8,64.91)
  IN2 w0.127: v3(189.8,64.91) 190.32,64.91 190.88,65.47 199.46,65.47 201.68,67.69 201.68,70.09 202.78,71.19 202.78,74.58 200.73,76.63 200.73,83.58 203.73,86.59 203.73,89.4 203.33,89.8 203.33,92.65 208.75,98.07 208.75,106.67 207.27,108.14 207.27,111.33 207.58,111.64 207.58,114.55 206.29,115.84 206.29,122.85 v3(205.43,123.71)
  IN3 w0.127: v3(162,127.39) 162.7,128.09 170.71,128.09 171.18,127.63 172.15,127.63 172.43,127.34 172.43,126.55 172.63,126.34 174.31,126.34 174.76,126.8 175.72,126.8 176,126.52 182.12,126.52 182.82,125.82 190.15,125.82 192.28,123.69 203.85,123.69 204.03,123.51 205.22,123.51 v3(205.43,123.71)
  BOTTOM w0.089: UH1.AN2 162.31,128.35 162.31,127.7 v3(162,127.39)
  BOTTOM w0.102: RH16.1 199.56,104.6 198.96,105.2 198.96,114.37 200.75,116.16 200.75,121.9 202.08,123.24 v1(204.17,123.24) 204.95,123.24 v3(205.43,123.71)
MCARD_WWAN_PWREN: length 174.4
  TOP w0.102: v3(182.56,67.77) 182.02,68.31 U46.B42 ; U145.3 264.85,175.24 264.8,175.19 264.8,174.49 264.86,174.42 R726.1 263.72,172.91 v2(263.72,170.88) 263.72,170.26 261.3,167.85 261.3,163.59 260.55,162.84 260.55,156.68 260.55,153.81 v3(260.38,153.63)
  IN3 w0.127: v3(182.56,67.77) 183.35,66.98 187.45,66.98 188.85,65.58 190.08,65.58 191.19,66.69 192.95,66.69 193.43,67.17 194.52,67.17 194.89,66.8 199.72,66.8 199.81,66.89 203.27,66.89 205.59,64.58 206.84,64.58 207.56,65.29 215.25,65.29 218.31,68.35 221.72,68.35 224.04,70.68 224.04,71.9 224.41,72.27 225.17,72.27 230.74,77.83 230.74,89.8 231.71,90.77 231.71,104.49 238.53,111.31 239.06,111.83 240.46,113.23 243.6,116.38 243.6,132.34 247.91,136.65 249.76,136.65 252.23,139.13 252.23,150 253.55,151.32 256.38,151.32 258.6,153.53 260.28,153.53 v3(260.38,153.63)
ME_FWP: length 87.7
  TOP w0.102: v3(193.16,73.59) 193.76,72.99 196.01,72.99 197.38,71.62 197.38,69.69 195.86,68.16 194.18,68.16 193.57,67.55 R793.1 193.3,67.79 191.87,67.79 191.64,67.56 U46.A8
  IN4 w0.102: v3(194,132.11) 194,131.81 194.4,131.41 194.4,125.42 193.97,124.99 193.97,120.74 193.54,120.31 193.54,113.86 194.62,112.78 194.62,102.16 194.01,101.55 194.01,96.32 192.47,94.78 192.47,91.75 191.68,90.96 191.68,87.29 192.36,86.62 192.36,79.87 190.69,78.21 190.69,74.91 191.56,74.04 192.7,74.04 193.15,73.59 v3(193.16,73.59)
  BOTTOM w0.102: v3(194,132.11) 193.53,132.58 v1(193.11,132.58) 192.52,132.58 190.15,134.95 186.74,134.95 186.18,135.51 RH45.1
ME_RESET#: length 3.4
  BOTTOM w0.102: v1(158.52,119.66) 158.83,119.36 RH93.2 RH70.1 158.96,117.59 UC3.2
ME_SUS_PWR_ACK: length 105.2
  TOP w0.102: v3(208.9,71.45) 209.43,71.99 U51.A8
  IN1 w0.102: v3(176.22,121.14) 176.22,121.14 176.32,121.04 176.32,120.41 176.74,119.99 178.75,119.99 180.98,117.76 183.09,117.76 184.62,119.28 192.56,119.28 193.38,118.46 195.65,118.46 196.89,119.7 209.09,119.7 209.19,119.6 210.48,119.6 210.66,119.78 213.08,119.78 v3(213.23,119.62)
  IN4 w0.102: v3(213.23,119.62) 213.81,119.05 215.02,119.05 218.57,115.5 218.57,101.11 219.47,100.21 219.47,91.25 219.75,90.97 219.75,78.83 219.02,78.11 219.02,76.96 215.77,73.71 212,73.71 210.95,72.67 210.95,71.87 210.19,71.11 209.55,71.11 209.21,71.45 v3(208.9,71.45)
  BOTTOM w0.102: v3(176.22,121.14) 176.22,121.14 176.28,121.21 v1(176.28,121.66) RH107.1 RH75.2
ME_SUS_PWR_ACK_R: length 9.3
  BOTTOM w0.089: UH1.J4 172.18,128.9 171.89,128.62 171.89,128.35 172.08,128.17 172.08,127.81 172.52,127.37 172.52,126.89 172.66,126.75 172.66,126.62
  BOTTOM w0.102: 172.66,126.62 v1(172.66,126.24) 173.54,125.37 175.83,125.37 176.28,124.92 RH107.2 RH91.1
MEC_XTAL1: length 8.6
  TOP w0.102: U51.A61 v1(202.87,76.54) 201.66,76.54 C743.1 200.93,75.81 200.22,75.81 199.96,75.56 199.96,74.54 199.71,74.29 199.71,72.82 199.52,72.63 Y6.1
MEC_XTAL2: length 3.5
  TOP w0.102: Y6.2 200.51,72.63 200.19,72.95 200.19,73.95 C741.1 R1068.2
MEC_XTAL2_R: length 3.2
  TOP w0.102: U51.A62 202.31,76.04 R1068.1
MEM_SMBCLK: length 44
  TOP w0.089: v3(170.23,131.1) 170.38,131.1 170.82,130.66 170.82,129.96 171.06,129.72 171.96,129.72 172.25,129.43 172.25,128.85 172.68,128.41 172.68,126.77 172.74,126.71 172.74,126.64 172.75,126.63 172.75,126.62
  TOP w0.102: v3(171.64,113.49) 171.46,113.32 171.46,112.76 171.7,112.52 174.95,112.52 175.71,113.28 175.71,116.39 176.09,116.77 177.31,116.77 177.8,116.27 QH4.6 ; 172.75,126.62 172.75,126.35 173.46,125.64 173.46,125.24 173.62,125.09 RPH12.3
  IN4 w0.089: 169.64,126.61 169.64,126.63 169.64,126.63 169.64,126.7 169.63,126.71 169.63,126.77 168.8,127.6 168.8,130.03 168.85,130.08 168.85,130.93 168.98,131.05 170.18,131.05 v3(170.23,131.1)
  IN4 w0.102: 169.64,126.61 169.64,124.52 170.09,124.07 170.09,122.03 170.77,121.36 170.77,119.78 170.17,119.18 170.17,117.72 168.39,115.94 168.39,115.2 169.2,114.39 171.23,114.39 171.49,114.13 171.49,113.65 v3(171.64,113.49)
  BOTTOM w0.089: v3(170.23,131.1) 170.2,131.13 170.2,131.29 UH1.R10
MEM_SMBDATA: length 41.9
  TOP w0.089: v3(169.22,132.17) 169.63,131.76 169.63,131.16 170.09,130.71 170.38,130.71 170.6,130.49 170.6,129.87 170.97,129.5 171.87,129.5 172.03,129.34 172.03,128.76 172.47,128.33 172.47,126.67 172.52,126.62
  TOP w0.102: QH4.3 176.26,114.97 175.93,114.64 175.93,113.19 175.05,112.3 171.6,112.3 171.23,112.67 171.23,113.32 v3(171.06,113.49) ; RPH12.4 173.12,125.1 173.23,125.21 173.23,125.55 172.52,126.26 172.52,126.62
  IN4 w0.089: v3(169.22,132.17) 168.78,131.73 168.78,131.17 168.63,131.02 168.63,130.17 168.59,130.12 168.59,127.51 169.41,126.68 169.41,126.61
  IN4 w0.102: v3(171.06,113.49) 171.26,113.7 171.26,114.04 171.13,114.16 169.1,114.16 168.16,115.1 168.16,116.04 169.94,117.81 169.94,119.27 170.54,119.87 170.54,121.26 169.86,121.93 169.86,123.97 169.41,124.42 169.41,126.61
  BOTTOM w0.089: UH1.U11 169.03,132.36 v3(169.22,132.17)
MIIC_SCL0: length 3.9
  TOP w0.102: R106.2 196.92,167.49 R105.1 197.82,167.49 198.1,167.21 v1(198.55,167.21) 199.11,167.21 199.22,167.1 U27.48
MIIC_SDA0: length 2.9
  TOP w0.102: R107.1 R108.2 199.62,168.08 U27.47
MINI1CLK_REQ#: length 190.3
  TOP w0.102: v3(189.89,132.07) 189.47,131.65 188.2,131.65 188.08,131.78 RPH21.5
  IN2 w0.127: v3(188.81,121.48) 190.16,122.82 190.16,131.8 v3(189.89,132.07)
  IN3 w0.089: 167.83,125 167.71,125.13 167.71,125.66 v3(166.82,126.55)
  IN3 w0.127: v3(250.51,158.8) 250.51,156.6 246.56,152.64 245.45,152.64 242.98,150.17 242.98,142.65 242.04,141.71 242.04,137.73 237.29,132.98 237.29,124.83 232.4,119.94 227.73,119.94 226.89,119.1 222.78,119.1 222.61,119.27 219.39,119.27 218.81,118.69 209.92,118.69 208.73,119.88 207.71,119.88 206.57,121.02 205.31,121.02 204.17,119.88 192.13,119.88 190.53,121.48 v3(188.81,121.48) 188.65,121.31 178.65,121.31 177.57,122.39 177.57,123.11 176.95,123.74 176.33,123.74 175.93,123.33 174.55,123.33 173.98,123.91 170.25,123.91 169.3,124.85 167.98,124.85 167.83,125
  BOTTOM w0.089: v1(166.23,125.15) 166.23,125.96 v3(166.82,126.55) 167.02,126.75 167.02,127.92 UH1.AB1
  BOTTOM w0.102: v3(250.51,158.8) 250.51,165.76 254.02,169.27 256.81,169.27 258.85,171.31 258.85,174.74 259.18,175.06 259.18,177.65 263.03,181.51 263.03,185.02 265.37,187.35 265.37,197.2 264.31,198.25 262.15,198.25 260.36,200.05 JMINI1.7
MINI2CLK_REQ#: length 99.3
  IN2 w0.127: v3(204.14,115.67) 204.14,119.44 204.5,119.8 204.5,121.38 203.4,122.48 203.4,142.29 200.93,144.76 199.12,144.76 197.65,146.24 197.65,147.42 197.14,147.93 197.14,149.49 194.59,152.04 v3(194.59,153.02)
  IN3 w0.127: v3(204.14,115.67) 203.77,115.31 199.27,115.31 198.69,114.72 187.63,114.72 185.49,116.85 181.23,116.85 180.47,117.62 175.67,117.62 175.42,117.37 172.93,117.37 172.35,117.95 169.84,117.95 167.7,120.09 v3(167.7,120.52)
  BOTTOM w0.102: RPH8.2 167.39,120.76 167.63,120.52 v3(167.7,120.52) 167.87,120.69 167.87,121.06 168.56,121.75 168.56,122.51 168.43,122.64 168.43,124.02 167.9,124.55 167.9,125.21 167.4,125.71 167.4,128.41 UH1.AA2 ; JMINI2.7 196.2,159.3 194.61,157.71 194.61,153.04 v3(194.59,153.02)
MINI3CLK_REQ#: length 168
  TOP w0.089: v3(169.71,127.51) 169.79,127.43 170.12,127.43 170.26,127.57 RPH3.1
  IN3 w0.127: v3(169.71,127.51) 170.81,127.51 172.23,126.09 174.41,126.09 174.87,126.55 175.62,126.55 175.9,126.27 182.01,126.27 182.71,125.57 190.04,125.57 192.37,123.24 207.89,123.24 208.8,122.33 211.89,122.33 212.25,121.97 213.13,121.97 214.05,121.05 232.79,121.05 236.78,125.04 236.78,134.03 238.06,135.31 238.89,135.31 241.53,137.94 241.53,149.09 245.34,152.9 246.37,152.9 250.09,156.62 250.09,159.2 253.3,162.42 253.3,165.1 254.56,166.36 259.7,166.36 260.84,167.5 264.38,167.5 v3(264.79,167.1)
  BOTTOM w0.089: UH1.T3 169.33,128.47 169.66,128.15 169.66,127.84 169.66,127.56 v3(169.71,127.51)
  BOTTOM w0.102: v3(264.79,167.1) 264.79,168.07 268.92,172.2 268.92,175.56 269.71,176.35 269.71,178.65 271.13,180.06 274.82,180.06 275.61,179.27 278.49,179.27 279.09,179.87 279.09,181.13 281.31,183.35 JMINI3.7
MMICLK_REQ#: length 232.9
  TOP w0.102: U38.17 185.79,23.18 185.93,23.04 v3(185.93,22.11)
  IN2 w0.127: v3(185.93,22.11) 186.46,21.58 188.22,21.58 192.86,26.23 195.79,26.23 196.35,26.8 217.75,26.8 218.7,27.74 218.7,32.44 220.48,34.22 221.16,34.22 221.49,34.56 221.49,53.9 219.14,56.25 219.14,61.01 216.09,64.06 216.09,73.9 217.78,75.59 217.78,99.09 219.55,100.86 219.55,108.62 221.55,110.62 221.55,116.53 v3(220.32,117.76)
  IN3 w0.127: v3(155.56,128.3) 158.7,128.3 160.68,126.32 162.21,126.32 163.4,127.51 164.61,127.51 164.87,127.24 164.87,126.83 v3(164.65,126.6) 164.65,126.27 165,125.92 165,124.79 165.47,124.32 169.11,124.32 170.09,123.35 173.72,123.35 174.02,123.05 174.02,122.43 174.21,122.24 177.01,122.24 178.44,120.81 185.5,120.81 188.14,118.16 196.72,118.16 196.82,118.06 v3(198.69,118.06) 208.51,118.06 210.08,116.49 214.56,116.49 215.22,117.15 219.71,117.15 v3(220.32,117.76)
  BOTTOM w0.089: v1(164.85,125.34) 164.85,125.55 164.72,125.68 164.72,126.08 164.65,126.15 v3(164.65,126.6) 164.85,126.81 164.85,127.72 164.96,127.83 164.96,128.16 165.17,128.37 165.17,128.85 UH1.AF3
  BOTTOM w0.102: RPH20.5 153.84,127.47 154.09,127.73 154.99,127.73 v3(155.56,128.3) ; RH22.1 200.51,101.55 197.87,104.19 197.87,117.24 v3(198.69,118.06)
MOD_MD: length 18
  TOP w0.102: 168.02,53.76 168.02,55.34 v1(166.95,56.41) 166.64,56.72 166.64,57.95 166.95,58.26 RP18.7 ; 168.02,53.76 167.7,53.44 Q123.4 ; 168.02,53.76 168.4,53.38 169.42,53.38 169.6,53.21 Q76.4 169.6,52.05 169.29,51.74 168.2,51.74 167.63,51.17 167.63,47.92 167.01,47.3 165.86,47.3 JSATA2.11
MOD_SATA_PCIE#_DET: length 48.9
  TOP w0.102: U46.A42 179.79,67.06 v3(179.7,66.97) ; RP18.6 166.96,58.76 v1(165.1,56.9) 164.34,56.14 161.62,56.14 v3(161.1,55.62) 161.1,54.82 163.56,52.36 ; 163.56,52.36 163.26,52.07 163.26,50.19 163.92,49.53 165.79,49.53 166.71,48.61 JSATA2.31 ; 163.56,52.36 164.15,52.36 164.78,53 164.78,53.9 164.97,54.09 Q123.2
  IN3 w0.127: v3(179.7,66.97) 179.7,66.09 177.91,64.29 177.91,60.47 175.38,57.94 166.68,57.94 164.8,56.06 162.23,56.06 161.79,55.62 v3(161.1,55.62)
MODC_EN: length 53.4
  TOP w0.102: v3(189.74,66.89) 189.83,66.81 U46.B7 ; U37.3 174.35,40.19 174.37,40.17 R512.1 174.84,39.22 174.84,38.79 175.63,38 v1(176.82,38) v3(177.96,38) ; v3(176.29,53.36) 174.91,53.36 174.48,53.8 170.41,53.8 170.25,53.97 Q76.2
  IN4 w0.102: v3(189.74,66.89) 190.34,66.29 190.34,64.87 189.86,64.39 189.86,63.72 188.43,62.3 188.43,60.89 188.19,60.65 187.6,60.65 186.88,59.93 186.88,58.73 182.13,53.98 176.91,53.98 v3(176.29,53.36) 175.27,52.34 175.27,44.83 176.76,43.34 176.76,42.34 177.96,41.15 v3(177.96,38)
MODC_EN#: length 4.7
  TOP w0.102: 170.9,53.28 170.51,53.28 170.25,53.01 Q76.5 ; 170.9,53.28 R517.2 173.09,53.28 v1(173.23,53.14) ; 170.9,53.28 Q76.6
MODULE_BATT_PRES#: length 105
  TOP w0.102: U46.B15 v3(189.78,70.81)
  TOP w0.254: PR727.2 230.72,142.43 v3(230.37,142.79)
  IN1 w0.102: v3(222.84,142.69) 222.84,142.32 220.23,139.72 220.11,139.72 217.18,136.79 201.26,136.79 v3(201.13,136.67)
  IN2 w0.127: v3(201.13,136.67) 200.37,135.91 200.37,127.38 197.96,124.97 197.96,118 197.52,117.57 197.52,101.64 195.94,100.05 195.94,93.14 195.1,92.31 195.1,85.33 192.51,82.73 192.51,79.97 191.94,79.4 191.94,74.67 191.35,74.08 191.31,74.08 189.78,72.55 v3(189.78,70.81) ; v3(222.84,142.69) 230.27,142.69 v3(230.37,142.79)
  BOTTOM w0.102: v3(230.37,142.79) v1(230.37,141.95)
MSCLK: length 126.8
  TOP w0.102: v3(210.17,82.15) 209.68,82.64 U51.B43 ; RP12.1 236.27,75.12 236.67,74.73 237.78,74.73 238.22,75.17 v3(238.35,75.17) JDEG2.6
  IN1 w0.102: v3(210.17,82.15) 210.43,82.15 210.69,82.41 210.69,83.01 210.91,83.23 216.8,83.23 218.24,81.79 222.03,81.79 223.74,80.09 232.11,80.09 237.42,74.78 237.96,74.78 v3(238.35,75.17)
  IN4 w0.102: v3(210.17,82.15) 209.49,81.46 205.4,81.46 205.21,81.65 205.21,84.14 204.8,84.55 204.8,88.81 199.34,94.27 199.34,114.66 200.5,115.81 200.5,118.42 199.67,119.24 199.67,121.3 200.27,121.9 200.27,124.68 199.67,125.28 199.67,143.05 v3(199,143.72)
  BOTTOM w0.102: JMINI2.19 203.74,157.06 203.36,156.68 202.58,156.68 201.49,155.58 201.49,150.33 199.42,148.26 199.42,144.74 v1(199,144.33) 199,144.13 199,144.13 v3(199,143.72)
MSDATA: length 122.7
  TOP w0.102: v3(210.46,85.63) 209.93,85.09 U51.A40 ; R850.2 v3(237.35,77.9) 239.71,77.9 240.16,77.46 240.16,76 239.83,75.67 JDEG2.7 ; v3(212.98,89.36) 213.39,89.77 RP17.6
  IN1 w0.102: v3(201.35,89.19) 203.75,89.19 204.6,88.34 211.96,88.34 v3(212.98,89.36) ; v3(237.35,77.9) 237.1,77.9 234.82,80.18 233.77,80.18 232.89,81.05 224.14,81.05 222.36,82.83 218.83,82.83 217.18,84.48 211.24,84.48 210.91,84.81 210.91,85.18 v3(210.46,85.63)
  IN2 w0.127: v3(210.46,85.63) 210.9,86.06 210.9,87.28 v3(212.98,89.36)
  IN4 w0.102: v3(197.82,144.77) 197.82,144.05 199.19,142.67 199.19,125.08 199.79,124.48 199.79,122.1 199.19,121.5 199.19,119.04 200.01,118.22 200.01,116.01 198.86,114.86 198.86,94.07 200.2,92.72 200.2,90.34 v3(201.35,89.19)
  BOTTOM w0.102: v3(197.82,144.77) 197.3,145.29 197.3,146.9 R706.2 196.8,148.08 v1(197.09,148.38) 197.09,149.41 197.67,149.99 JMINI2.14
MULTIO_0: length 4.1
  TOP w0.102: R1700.2 185.99,20.46 v1(185.99,21.03) 185.99,21.42 186.37,21.81 186.37,22.28 186.16,22.49 186.16,22.95 186.19,22.98 U38.18
NB_LAN_TX0+: length 23.7
  TOP w0.267: T156.24 250.83,187.43 v3(251.25,187.84)
  IN4 w0.191: v3(251.25,187.84) 251.12,187.97 250.74,187.97 250.37,188.34 250.37,191.68 249.11,192.93 249.11,201.89 250.94,203.72 250.94,207.39 250.73,207.6 JLOM1.1
NB_LAN_TX0-: length 23.6
  TOP w0.267: v3(251.25,188.43) 250.97,188.7 T156.23
  IN4 w0.191: v3(251.25,188.43) 251.12,188.3 250.88,188.3 250.7,188.48 250.7,191.81 249.44,193.07 249.44,201.75 251.27,203.58 JLOM1.2
NB_LAN_TX1+: length 19.5
  TOP w0.267: v3(251.25,192.86) 250.9,192.51 T156.20
  IN4 w0.191: v3(251.25,192.86) 251.12,192.99 250.66,192.99 250.24,193.4 250.24,201.42 253.99,205.17 253.99,206.49 252.88,207.6 JLOM1.3
NB_LAN_TX1-: length 19.5
  TOP w0.267: v3(251.25,193.44) 250.91,193.78 T156.19
  IN4 w0.191: v3(251.25,193.44) 251.12,193.32 250.79,193.32 250.57,193.54 250.57,201.29 254.32,205.03 254.32,206.3 255.35,207.33 JLOM1.6
NB_LAN_TX2+: length 17.9
  TOP w0.267: T156.18 250.96,195.05 v3(251.25,195.34)
  IN1 w0.191: JLOM1.4 253.31,205.7 251.06,203.44 250.56,203.44 249.32,202.2 249.32,200.44 250.18,199.57 250.18,195.84 250.68,195.34 v3(251.25,195.34)
NB_LAN_TX2-: length 17.8
  TOP w0.267: v3(251.25,195.98) 250.91,196.32 T156.17
  IN1 w0.191: v3(251.25,195.98) 250.93,195.67 250.82,195.67 250.51,195.97 250.51,199.71 249.65,200.57 249.65,202.06 250.7,203.11 251.2,203.11 253.64,205.56 253.64,206.45 253.87,206.68 254.19,206.68 254.38,206.49 254.57,206.49 254.83,206.75 254.83,207.1 JLOM1.5
NB_LAN_TX3+: length 13.5
  TOP w0.267: T156.14 250.91,200.13 v3(251.25,200.46)
  IN1 w0.191: JLOM1.7 257.13,207.6 257.23,207.5 257.23,207.2 252.34,202.31 251.12,202.31 250.45,201.64 250.45,200.95 250.81,200.59 251.12,200.59 v3(251.25,200.46)
NB_LAN_TX3-: length 13.3
  TOP w0.267: v3(251.25,201.05) 250.89,201.4 T156.13
  IN1 w0.191: v3(251.25,201.05) 251.12,200.92 250.95,200.92 250.78,201.09 250.78,201.5 251.26,201.98 252.48,201.98 257.56,207.06 257.56,207.64 257.39,207.8 JLOM1.8
NB_PSID: length 6.6
  TOP w0.102: v3(12.97,184.65) v2(12.27,184.65)
  BOTTOM w0.508: PJPDC1.5 v3(12.97,184.65) 12.1,183.79 PL4.2
NB_PSID_TS5A63157: length 3.7
  TOP w0.102: PR11.1 219.32,124.77 v1(218.99,125.1)
  TOP w0.254: PR11.1 220.16,124.75 PR12.2 221.11,123.89 221.28,123.72 PU1.3
NTC: length 4
  BOTTOM w0.102: PR525.2 127.89,147.17 v1(127.89,146.76)
  BOTTOM w0.203: PR525.2 127.35,147.68 126.73,147.06 126.42,147.06 125.7,146.34 PU500.6
NTC_VGA: length 31.1
  TOP w0.203: v3(23.09,145.09) 22.98,145.2 PU600.5
  IN1 w0.254: v3(14.78,159.81) 12.51,157.53 12.51,144.96 14.86,142.61 20.61,142.61 v3(23.09,145.09)
  BOTTOM w0.102: v3(23.09,145.09) 23.12,145.11 23.12,145.41 v1(22.73,145.79)
  BOTTOM w0.254: v3(14.78,159.81) PH600.2
OP_5V: length 4.8
  TOP w0.102: PR745.2 221.44,139.26 v1(221.3,139.12)
  TOP w0.254: PU701.8 222.9,142.04 222.01,141.15 PC725.1 PR745.2
OZ_LDO_EN: length 4
  TOP w0.102: R894.2 184.94,20.3 v1(184.94,21.81) 184.55,22.2 184.55,22.94 184.59,22.98 U38.14
OZ_PE_REXT: length 3.3
  TOP w0.102: U38.4 182.39,27.66 181.93,28.12 181.8,28.12 R677.2 181.12,28.81 v1(181.12,29.4)
P33ALW: length 3.3
  TOP w0.254: PR868.1 42.74,146.61 v1(43.02,146.33) 43.22,146.12 PU800.18
P33ALW2: length 2
  TOP w0.254: PR862.2 42.75,138.31 42.32,138.73 PU800.9
PANEL_BKEN_CVT: length 31.5
  TOP w0.102: v3(200.72,167.19) 200.72,166.65 200.82,166.55 U27.44 ; U54.1 217.9,157.39 v1(218.09,157.2) 218.09,156.85 v3(217.9,156.66) 217.5,156.26 R1139.1
  IN2 w0.127: v3(200.72,167.19) 200.72,166.77 200.94,166.56 208.85,166.56 209.56,165.85 217.62,165.85 218.89,164.57 218.89,162.54 217.9,161.54 v3(217.9,156.66)
PANEL_BKEN_EC: length 125.5
  TOP w0.102: U46.A35 v3(179.69,70.56) ; v3(201.12,136.05) 202.06,136.98 203.98,136.98 205.3,135.66 207.4,135.66 212.45,140.72 214.85,140.72 216.99,142.86 v1(216.99,146.48) 216.99,147.27 217.34,147.61 217.34,151.08 215.82,152.59 215.05,152.59 214.56,153.09 214.56,153.65 214.89,153.98 214.89,155.9 216.03,157.04 216.03,158.89 215.69,159.24 214.9,159.24 214.57,159.57 214.57,160.65 214.87,160.95 D10.3
  IN2 w0.127: v3(179.69,70.56) 179.69,70.53 181.82,68.4 182.84,68.4 183.19,68.76 187.9,68.76 188.41,69.28 189.93,69.28 190.95,70.29 190.95,71.21 191.64,71.91 191.64,73.98 192.22,74.55 192.22,79.21 192.76,79.75 192.76,82.63 195.35,85.22 195.35,92.18 196.24,93.07 196.24,100 197.78,101.54 197.78,117.41 198.21,117.85 198.21,124.84 200.66,127.3 200.66,135.59 v3(201.12,136.05)
PANEL_BKEN_PCH: length 67.1
  TOP w0.102: v3(217.43,140.72) v1(217.43,141.6) 217.43,142.23 217.79,142.6 217.79,151.45 218.2,151.85 218.2,154.98 218.43,155.21 218.43,157.42 217.81,158.04 U54.2
  IN3 w0.089: 178.31,142.28 175.54,142.28 175.15,142.67 172.3,142.67 v3(171.95,143.02)
  IN3 w0.127: 178.31,142.28 182.03,142.28 182.87,141.44 194.59,141.44 195.85,140.19 200.36,140.19 201.65,138.89 210.72,138.89 212.55,140.72 v3(217.43,140.72)
  BOTTOM w0.089: v3(171.95,143.02) 171.95,142.67 UH1.K36
PANEL_HDD_LED: length 62.2
  TOP w0.102: Q81.3 221.33,114.57 222.07,115.31 v3(223.31,115.31)
  BOTTOM w0.102: v3(223.31,115.31) 224.41,116.41 224.41,119.46 223.61,120.26 223.61,147.35 v1(222.13,148.83) 221.88,149.08 221.88,153.29 222.61,154.02 222.61,159.13 219.36,162.38 219.36,166.75 219,167.11 218.39,167.11 218.15,167.35 218.15,169.4 218.04,169.51 JLVDS1.8
PBAT_PRES#: length 297.9
  TOP w0.102: v3(182.57,68.82) 182.08,69.31 U46.B40
  TOP w0.254: PD7.1 165.55,163.87 164.23,162.55 PR6.2 164.83,161.71 v3(164.85,161.72) ; PU804.1 229.73,83.76 229.59,83.91 229.59,84.29 v3(229.55,84.32) ; v3(111.06,154.61) 111.32,154.36 111.32,152.77 111.51,152.58 111.89,152.58 112.13,152.34 PQ812.1 ; v3(70.04,154.3) 70.04,154.35 71.26,155.57 71.83,155.57 v1(72.47,156.21) 72.76,156.5 72.76,160.7 72.91,160.85 PRP2.1
  IN1 w0.254: v3(110.34,157.65) 111.06,156.92 v3(111.06,154.61) 110.73,154.28 103.63,154.28 101.92,152.57 91.91,152.57 91.41,153.06 81.87,153.06 80.13,154.8 70.5,154.8 70.04,154.34 v3(70.04,154.3) ; v3(191.05,85.26) 191.54,85.75 196.22,85.75 198.25,87.79 222.62,87.79 223.08,87.33 226.54,87.33 v3(229.55,84.32)
  IN2 w0.254: v3(191.05,85.26) 191.35,85.56 191.35,91.25 194.1,94 194.1,100.91 194.97,101.78 194.97,102.51 195.68,103.23 195.68,118.38 196.09,118.79 196.09,125.75 198.48,128.14 198.48,141.53 196.62,143.39 196.62,147.1 196.19,147.53 196.19,149.1 194.24,151.05 192.31,151.05 187.04,156.32 182.26,156.32 173.77,164.81 171.76,164.81 168.67,161.72 v3(164.85,161.72) 164.76,161.64 164.76,160.61 162.63,158.48 154.26,158.48 151.27,161.47 145.18,161.47 142.32,158.61 138.45,158.61 136.83,157 133.74,157 132.76,157.98 131.05,157.98 130.47,157.41 128.67,157.41 127.53,156.26 121.52,156.26 120.14,157.65 v3(110.34,157.65)
  IN4 w0.102: v3(191.05,85.26) 191.67,84.64 191.67,80.3 189.86,78.49 189.86,77.32 188.69,76.14 188.69,73.29 187.96,72.56 187.96,70.66 186.12,68.82 v3(182.57,68.82)
PBAT_SMBCLK: length 203.7
  TOP w0.102: v3(73.02,154.3) 73,154.3 72.98,154.33 72.94,154.37 72.84,154.47 72.84,154.47 72.75,154.56 72.75,155.23 73.32,155.81 73.32,160.36 73.79,160.83 73.79,161.67 73.91,161.79 PRP2.3 ; v3(197.21,80.44) 197,80.65 196.69,80.65 196.47,80.43 196.47,79.12 195.18,77.83 194.42,77.83 193.89,78.36 193.89,78.87 193.38,79.38 191.56,79.38 190.62,80.32 190.62,80.48 190.41,80.69 190.32,80.69 190.18,80.55 RP14.7 ; v3(202.64,78.58) 203.11,79.04 U51.A56
  IN1 w0.102: v3(137.48,142.52) 137.38,142.62 137.38,144.49 135.47,146.4 132.06,146.4 131.63,146.83 129.12,146.83 128.11,147.84 123.26,147.84 122.07,149.03 121.25,149.03 118.53,151.76 115.45,151.76 113.23,153.98 103.76,153.98 102.05,152.26 91.78,152.26 91.29,152.76 81.59,152.76 80.03,154.31 76.44,154.31 75.8,153.67 73.15,153.67 72.84,153.98 72.84,154.12 v3(73.02,154.3) ; v3(197.21,80.44) 197.88,79.77 201.45,79.77 v3(202.64,78.58)
  BOTTOM w0.102: v3(197.21,80.44) 196.67,80.98 196.67,82.53 198.27,84.13 198.27,89.84 197.31,90.81 187.44,90.81 184.1,94.15 184.1,96.86 173.99,106.97 170.11,106.97 165.29,111.8 155.64,111.8 145.18,122.27 145.18,129.45 140.15,134.48 140.15,140.9 138.03,143.02 137.39,143.02 137.3,142.93 137.3,142.7 v3(137.48,142.52)
PBAT_SMBDAT: length 207.9
  TOP w0.102: v3(206.36,79.82) 206.36,79.74 205.91,79.29 U51.B59 ; RP14.8 190.2,81.05 190.33,80.92 190.5,80.92 190.84,80.58 190.84,80.42 191.66,79.61 193.48,79.61 194.12,78.96 194.12,78.45 194.51,78.06 195.09,78.06 196.24,79.21 196.24,80.52 196.6,80.88 197.02,80.88 v3(197.19,81.05) ; PRP2.2 73.41,161.79 73.56,161.64 73.56,160.92 73.09,160.45 73.09,155.9 72.52,155.33 72.52,154.42 72.4,154.3 v3(72.44,154.3)
  IN1 w0.102: v3(206.36,79.82) 205.91,79.38 205.4,79.38 205.06,79.03 202.62,79.03 201.61,80.04 198.21,80.04 v3(197.19,81.05) ; v3(72.44,154.3) 72.61,154.13 72.61,153.88 73.05,153.44 75.89,153.44 76.54,154.09 79.94,154.09 81.49,152.53 91.19,152.53 91.69,152.03 102.14,152.03 103.86,153.75 113.13,153.75 115.36,151.53 118.44,151.53 121.16,148.8 121.97,148.8 123.17,147.61 128.02,147.61 129.03,146.6 131.54,146.6 131.97,146.17 135.38,146.17 137.15,144.4 137.15,142.78 v3(136.89,142.52)
  BOTTOM w0.102: v3(197.19,81.05) 197.13,80.99 196.99,80.99 196.9,81.07 196.9,82.44 198.5,84.04 198.5,89.94 197.4,91.04 187.54,91.04 184.33,94.25 184.33,96.96 174.08,107.2 170.2,107.2 165.38,112.03 155.74,112.03 145.4,122.36 145.4,129.55 140.37,134.58 140.37,140.99 138.12,143.25 137.3,143.25 137.07,143.02 137.07,142.7 v3(136.89,142.52)
PCH_ALW_ON: length 67
  TOP w0.102: U51.A23 215.45,78.04 215.98,77.51 216.58,77.51 v3(216.98,77.9) ; v3(222.7,77.21) 223.39,76.51 v2(223.39,75.8) 223.39,75.24 223.08,74.92 RP9.6 ; U146.3 221.08,127.27 221.17,127.18 v3(222,127.18)
  IN1 w0.102: v3(216.98,77.9) 217.48,77.9 218.09,78.51 222.02,78.51 222.7,77.84 v3(222.7,77.21)
  IN4 w0.102: v3(222,127.18) 222.84,126.34 222.84,123.82 222.21,123.2 222.21,111.03 223.41,109.83 223.41,105.77 222.25,104.61 222.25,97.65 221.24,96.64 221.24,82.98 222.7,81.52 v3(222.7,77.21)
PCH_AZ_BITCLK: length 4.1
  BOTTOM w0.089: 178.31,138.53 177.97,138.53 177.67,138.24 175.4,138.24 UH1.B25
  BOTTOM w0.102: RPH10.8 178.31,138.53
PCH_AZ_CODEC_BITCLK: length 99.9
  TOP w0.102: R1076.1 266,156.84 266.13,156.71 v3(266.38,156.71) 266.38,156.75 v1(266.78,157.14) 267.24,157.14 267.57,157.47 U74.6
  IN1 w0.102: v3(266.38,156.71) 265,156.71 264.38,156.08 264.38,155.46 264.12,155.21 263.93,155.21 263.69,154.97 263.69,154.63 263.69,154.44 262.98,153.73 262.98,153.29 261.85,152.16 261.43,152.16 260.88,151.61 253.86,151.61 248.57,146.33 237.47,146.33 236.67,145.53 231.62,145.53 230.61,144.52 223.18,144.52 220.75,142.09 218.45,142.09 217.62,141.25 216.49,141.25 214.94,139.7 207.04,139.7 206.55,139.21 201.21,139.21 200.75,139.66 199.52,139.66 196.45,136.59 183.79,136.59 181.42,138.96 v3(181.42,139.3)
  BOTTOM w0.102: v3(181.42,139.3) 180.66,138.53 RPH10.1
PCH_AZ_CODEC_RST#: length 97
  TOP w0.102: U74.11 267.57,154.97 267.47,154.87 R39.1 265.77,154.37 263.93,154.37 v1(263.3,155.01) 262.73,155.01 v3(262.7,155.03)
  IN1 w0.102: v3(262.7,155.03) 262.7,154.93 262.28,154.5 258.72,154.5 257.6,153.38 254.26,153.38 248.5,147.63 237.4,147.63 236.36,146.58 223.2,146.58 220.15,143.54 217.85,143.54 217.02,142.7 215.89,142.7 214.34,141.15 204.01,141.15 203.49,140.63 199.12,140.63 196.16,137.67 184.33,137.67 182.7,139.3 v3(182.69,139.3)
  BOTTOM w0.102: v3(182.69,139.3) 182.69,138.82 181.4,137.54 RPH10.3
PCH_AZ_CODEC_SDIN0: length 104.3
  TOP w0.102: R1096.1 v3(264.86,155.88)
  IN1 w0.089: 177.22,136.13 171.64,136.13 v3(171.21,136.57)
  IN1 w0.102: 177.22,136.13 177.65,136.13 177.95,136.44 178.51,136.44 178.84,136.11 196.65,136.11 199.27,138.72 206.75,138.72 207.24,139.22 215.14,139.22 216.24,140.32 217.59,140.32 218.88,141.61 220.95,141.61 223.38,144.03 230.81,144.03 231.82,145.05 236.87,145.05 237.67,145.85 248.77,145.85 254.06,151.13 261.13,151.13 261.67,151.68 262.05,151.68 263.46,153.09 263.46,153.53 264.86,154.93 v3(264.86,155.88)
  BOTTOM w0.089: UH1.L22 171.48,136.84 v3(171.21,136.57)
