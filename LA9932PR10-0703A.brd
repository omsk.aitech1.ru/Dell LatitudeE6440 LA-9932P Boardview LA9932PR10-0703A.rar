# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N23050532: length 2.2
  TOP w0.089: T36.1 140.99,94.68 v3(141.47,94.2)
  BOTTOM w0.089: JCPU1.E20 v3(141.47,94.2)
N23050534: length 1.5
  TOP w0.089: T35.1 141.96,95.69 v3(141.47,95.2)
  BOTTOM w0.089: JCPU1.E21 v3(141.47,95.2)
N23050555: length 1.4
  TOP w0.089: T30.1 141,92.72 v3(141.47,93.2)
  BOTTOM w0.089: v3(141.47,93.2) 141,92.73 JCPU1.E18
N23050586: length 1.6
  TOP w0.089: T14.1 142.43,97.16 v3(142.47,97.2)
  BOTTOM w0.089: JCPU1.D23 v3(142.47,97.2)
N23050714: length 3.3
  TOP w0.089: T26.1 126.85,104.82 v3(126.47,105.2)
  BOTTOM w0.089: v3(126.47,105.2) JCPU1.W30
N23050732: length 1.4
  TOP w0.089: T28.1 126.93,105.74 v3(126.47,106.2)
  BOTTOM w0.089: JCPU1.W31 v3(126.47,106.2)
N23050736: length 1.3
  TOP w0.089: v3(126.47,104.2) 126.53,104.26 T10.1
  BOTTOM w0.089: v3(126.47,104.2) JCPU1.W29
N23050738: length 1.3
  TOP w0.089: T15.1 126.14,102.87 v3(126.47,103.2)
  BOTTOM w0.089: JCPU1.W28 v3(126.47,103.2)
N23050778: length 1.3
  TOP w0.089: T32.1 132,84.2 v3(132.47,84.2)
  BOTTOM w0.089: v3(132.47,84.2) JCPU1.P10
N23050780: length 1.3
  TOP w0.089: v3(129.47,84.2) 129.4,84.13 T31.1
  BOTTOM w0.089: v3(129.47,84.2) JCPU1.U10
N23050887: length 1.6
  TOP w0.089: T23.1 113.97,99.7 v3(114.47,100.2)
  BOTTOM w0.102: v3(114.47,100.2) JCPU1.AL25
N23050901: length 4.8
  BOTTOM w0.089: 108.74,74.53 JCPU1.AT1
  BOTTOM w0.102: 108.74,74.53 107.67,73.46 T11.1
N23050918: length 2.5
  TOP w0.089: v3(113.47,100.2) 112.87,99.6 T24.1
  BOTTOM w0.089: JCPU1.AM26 113.94,100.67 v3(113.47,100.2)
N23050938: length 5.4
  TOP w0.102: v3(110.47,108.2) 110.07,107.8 106.59,107.8 T19.1
  BOTTOM w0.089: v3(110.47,108.2) JCPU1.AR33
N23050940: length 4.9
  TOP w0.089: T22.1 109.74,100.82
  TOP w0.102: v3(113.47,101.2) 113.09,100.82 109.74,100.82
  BOTTOM w0.089: JCPU1.AM27 113.94,101.67 v3(113.47,101.2)
N23050958: length 1.3
  TOP w0.089: v3(144.47,98.2) 144.47,98.2 T7.1
  BOTTOM w0.089: JCPU1.B23 144,97.73 v3(144.47,98.2)
N23050968: length 1.4
  TOP w0.089: v3(143.47,98.2) 143.19,97.92 T12.1
  BOTTOM w0.089: v3(143.47,98.2) 143,97.73 JCPU1.C23
N23050970: length 1.3
  TOP w0.089: T13.1 142.45,99.22 v3(142.47,99.2)
  BOTTOM w0.089: JCPU1.D24 142,98.73 v3(142.47,99.2)
N23051071: length 2.1
  TOP w0.089: v3(114.47,105.2) 114.96,105.69 T16.1
  BOTTOM w0.102: v3(114.47,105.2) JCPU1.AL30
N23051073: length 1.7
  TOP w0.089: v3(114.47,104.2) 115,103.67 T17.1
  BOTTOM w0.102: v3(114.47,104.2) JCPU1.AL29
N23051091: length 1.5
  TOP w0.089: v3(121.47,84.2) 120.97,84.7 T6.1
  BOTTOM w0.089: JCPU1.AD10 121.94,84.67 v3(121.47,84.2)
N25368131: length 7.3
  BOTTOM w0.102: v1(94.08,105.37) 94.08,104.68 93.02,103.61 92.21,103.61 RV107.2 91,104.07 90.17,103.24 89.22,103.24 88.84,102.86 UV5.J13
N25669355: length 4.4
  BOTTOM w0.089: 58.22,102.65 58.26,102.61 58.87,102.61 58.93,102.54 59.55,102.54 UV6.J13
  BOTTOM w0.102: 58.22,102.65 57.56,103.31 57.56,103.98 57.15,104.38 RV117.2
N29179028: length 5
  TOP w0.102: R802.2 191.95,75.28 191.95,74.9 191.65,74.6 v1(190.9,74.6) 190.73,74.44 190.73,73.68 189.87,72.82 U46.B18
N30639296: length 2.3
  TOP w0.102: QC1.1 103.49,53.27 RC15.1
N31479955: length 6.8
  TOP w0.102: v3(189.23,75.68) 189.41,75.86 R804.1 ; U46.B19 189.37,72.13 189.27,72.03 v3(189.27,71.74)
  IN4 w0.102: v3(189.27,71.74) 189.27,75.64 v3(189.23,75.68)
  BOTTOM w0.102: v3(189.27,71.74) v1(190.11,71.74)
N35502990: length 4.4
  TOP w0.102: v1(85.16,37.33) 84.65,37.33 83.69,36.38 R508.2 ; Q29.5 83.31,35.61 83.62,35.92 R508.2 ; R508.2 83.51,36.26 Q29.6
N35569138: length 4.8
  TOP w0.102: Y3.1 247.84,165.03 246.68,165.03 246.35,164.71 R1144.1 245.06,163.82 C470.2
N45129141: length 5.1
  TOP w0.102: v1(212.6,162.55) 213.11,163.06 213.11,164.01 212.85,164.27 Q22.1 213.36,164.84 214,164.2 214,163.87 R423.2
N46595644: length 9.3
  TOP w0.102: U46.B14 190.46,70.3 189.38,70.3 189.17,70.51 v3(189.17,70.58) ; T122.1 193.04,74.72 191.97,73.65 191.97,72.75 v3(192.6,72.13)
  IN3 w0.127: v3(189.17,70.58) 189.17,70.41 189.42,70.16 190.37,70.16 192.34,72.13 v3(192.6,72.13)
N48324044: length 2.1
  TOP w0.102: R1167.2 260.22,205.64 JLOM1.13
N48324090: length 2.3
  TOP w0.102: JLOM1.11 259.34,205.35 R1653.2
N48705646: length 268.6
  TOP w0.254: v3(213.02,127.37) v1(213.02,125.14) 213.02,124.16 213.41,123.76 PR13.2 215.25,123.76 215.52,124.03 PQ1.1 218.29,124.03 218.43,123.89 PR10.1
  IN2 w0.508: v3(213.02,127.37) 211.66,128.72 211.66,135.46 210.63,136.49 208.47,136.49 205.44,139.52 205.44,142.36 201.58,146.22 200.56,146.22 199.42,147.36 199.42,148.57 195.84,152.15 195.84,153.36 194.77,154.42 190.91,154.42 187.62,157.71 183.18,157.71 174.53,166.36 171.33,166.36 168.19,163.22 164.23,163.22 161.15,160.14 157.52,160.14 156.21,161.45 156.21,162.21 154.79,163.63 151.39,163.63 150.46,164.56 147.07,164.56 145.02,162.51 141.84,162.51 139.92,160.58 137.69,160.58 136.36,159.25 133.98,159.25 133.61,158.87 130.68,158.87 130.1,158.3 128.31,158.3 v3(127.16,157.15)
  IN3 w0.508: v3(12.1,181.5) 15.26,184.65 18.44,184.65 21.97,181.12 21.97,176.96 24.77,174.16 24.77,171.05 33.27,162.55 39.76,162.55 45.25,157.07 45.25,156.17 50.3,151.12 57.83,151.12 58.24,150.71 58.24,150.71 58.5,150.45 67.7,150.45 71.28,146.87 78.97,146.87 81.32,149.22 85.6,149.22 86.1,149.72 102.58,149.72 108.71,155.85 125.86,155.85 v3(127.16,157.15)
  BOTTOM w0.508: PL4.1 v3(12.1,181.5)
N48705653: length 4.2
  TOP w0.102: v1(219.27,122.02) PR10.2
  TOP w0.254: PQ1.3 217.76,122.75 217.98,122.98 PR10.2 PR12.1
N48705663: length 5
  TOP w0.254: PQ2.2 v1(215.71,120.08) 215.31,120.08 214.86,120.54 214.86,121.31 PR15.2 214.25,122.79 PR13.1
N48705665: length 9.1
  TOP w0.102: v1(219.39,117.97) 218.95,118.42 PQ2.1
  TOP w0.254: PQ1.2 215.83,121.22 216.22,120.83 218.38,120.83 218.95,120.26 PQ2.1 219.41,119.43 219.72,119.12 PR14.2 PR16.1
N48711348: length 1.4
  BOTTOM w0.102: v1(119.74,140.22) 119.57,140.39 PC522.1
N49342732: length 2.7
  TOP w0.102: v1(224.45,105.95) 224.82,106.31 Q79.1 R3671.1
N50215889: length 2.6
  TOP w0.102: Q81.1 222.33,111.65 222.65,111.33 R938.1 v1(223.72,110.61)
N50225127: length 3.5
  TOP w0.102: Q84.3 223.3,111.76 222.63,112.42 Q81.2 v1(222.63,114.58)
N50261142: length 9.9
  TOP w0.102: Q84.4 225.61,110.55 Q74.1 224.39,110.37 223.26,109.24 221.92,109.24 D59.2 D62.2 221.76,106.04 R932.2 v1(221.77,104.83)
N51922312: length 2
  TOP w0.102: PC612.1 25.91,140.12 v1(26.35,139.68)
  TOP w0.254: PC612.1 25.9,140.58 PR639.2
N51922366: length 8.5
  TOP w0.102: PR607.2 v1(16.27,142.48) ; 17.11,144.71 PC600.2
  TOP w0.203: PU600.38 20.06,147.71 19.65,147.3 19.65,146.33 19.06,145.75 18.57,145.75 18.07,145.25 17.65,145.25 PC600.2
  TOP w0.254: 17.11,144.71 PR600.2 PR607.2
N51922430: length 7.2
  TOP w0.102: v1(21.6,139.5) PR633.1
  TOP w0.203: 22.58,144.93 PU600.4
  TOP w0.254: PR633.1 21.61,140.58 22.67,141.64 22.67,144.83 22.58,144.93
N51922457: length 5.6
  TOP w0.203: PR645.1 30.32,148.95 29.72,148.35 28.86,148.35 28.19,149.02 PC617.1 27.62,148.77 v1(26.86,148.77) 26.73,148.91 PU600.16
N51922465: length 5.2
  TOP w0.203: PU600.3 22.18,144.63 22.26,144.55
  TOP w0.254: 22.26,144.55 v1(22.26,142.4) 22.26,141.89 21.85,141.47 PR632.1
N51922471: length 0.9
  TOP w0.254: PR642.1 25.03,142.33 PC614.2
N51922497: length 8
  TOP w0.102: PC610.1 22.23,155.58 v2(22.65,156)
  TOP w0.203: 23.56,153.09 23.56,151.88 ; 23.56,151.88 23.38,151.7 PU600.25 ; 23.56,151.88 23.78,151.66 PU600.24
  TOP w0.254: PC608.1 23.51,153.99 PR635.1 ; PC610.1 23.1,153.99 PR635.1 ; PR635.1 23.31,153.62 23.56,153.37 23.56,153.09
N51922603: length 3.5
  TOP w0.203: PU600.1 21.38,145.55 v1(20.98,145.15)
  TOP w0.254: v1(20.98,145.15) 20.59,145.15 20.16,144.72 PR627.2 PR629.2
N51922671: length 11.6
  TOP w0.254: PR648.2 31.75,146.17 v3(31.62,146.04)
  BOTTOM w0.254: v3(31.62,146.04) 31.62,146.58 v1(31.35,146.85) 30.61,147.6 30.61,150.83 28.64,152.8 28.64,155.43 PH601.1
N51924346: length 6.8
  TOP w0.102: v1(30.42,151.06) 30.32,150.96 30.32,150.27
  TOP w0.203: PR643.1 30.32,150.27 29.69,150.9 28.86,150.9 28.19,150.23 PC618.1 27.31,149.66 27.31,149.47 27.09,149.25 26.37,149.25 26.31,149.31 PU600.17
N51924378: length 30
  TOP w0.254: PR634.1 21.29,142.1 v3(21.71,142.1)
  IN1 w0.254: v3(14.8,160.39) 14.7,160.29 14.58,160.29 12.11,157.81 12.11,144.79 14.69,142.21 21.6,142.21 v3(21.71,142.1)
  BOTTOM w0.102: v3(21.71,142.1) 22.26,141.54 v1(22.26,141.53)
  BOTTOM w0.254: v3(14.8,160.39) 14.47,160.72 PH600.1
N53085144: length 2.7
  TOP w0.102: PC206.2 173.89,90.88 174.44,90.88 v1(174.91,91.35)
N53085275: length 3
  TOP w0.203: PR205.2 179.64,87.82 179.64,87.56 v1(179.45,87.37) 179.08,86.99 PU200.9
N57652826: length 5.3
  BOTTOM w0.089: 108.74,109.23 109.23,109.73 JCPU1.AT35
  BOTTOM w0.102: T52.1 105.06,108.96 108.46,108.96 108.74,109.23
N57659725: length 7.7
  BOTTOM w0.089: 108.74,110.29 110.38,110.29 JCPU1.AR35
  BOTTOM w0.102: 108.74,110.29 106.21,110.29 105.63,109.71 104.36,109.71 T53.1
N57663191: length 3.9
  TOP w0.102: T54.1 108.33,106.75 110.02,106.75 v3(110.47,107.2)
  BOTTOM w0.089: v3(110.47,107.2) JCPU1.AR32
N57663201: length 1.5
  TOP w0.089: v3(114.47,101.2) 114.95,100.72 T55.1
  BOTTOM w0.102: v3(114.47,101.2) JCPU1.AL26
N60687816: length 3.7
  TOP w0.102: U8.1 172.91,115.62 C289.1 ; v1(174.26,114.04) 173.29,115 C289.1 ; C289.1 R1629.2
N61506560: length 4.4
  TOP w0.102: PR722.1 49.54,159.07 v1(48.71,158.23)
  TOP w0.254: PU700.11 50.5,161.03 50.61,160.92 50.61,160.39 49.85,159.63 PR722.1
N63746311: length 12.1
  TOP w0.102: R884.1 206.26,66.11 v3(206.31,66.16) ; v3(205.91,74.92) 206.18,74.66 U51.B2
  IN4 w0.102: v3(205.91,74.92) 206.25,74.58 206.25,68.32 206.31,68.26 206.76,67.81 206.76,66.47 206.44,66.16 v3(206.31,66.16)
  BOTTOM w0.102: v1(205.34,66.79) 205.97,66.16 v3(206.31,66.16)
N63746359: length 8
  TOP w0.102: v3(209.91,71.55) 210.01,71.55 210.38,71.19 R888.1 ; U51.B8 209.18,74.54 209.11,74.61 209.11,75.1 v3(208.71,75.5)
  IN2 w0.127: v3(208.71,75.5) 209.11,75.1 209.11,74.41 209.49,74.03 209.49,71.97 v3(209.91,71.55)
  BOTTOM w0.102: v1(209.43,70.72) 209.43,70.97 209.91,71.45 v3(209.91,71.55)
N67887850: length 11.1
  TOP w0.102: R1137.1 R429.2 212.73,154.98 212.93,155.18 U56.2 214.53,155.18 214.64,155.07 214.64,154.69 214.49,154.53 U56.1 213.55,154.53 213.43,154.41 213.43,152.9 213.62,152.71 D9.1 214.1,152.42 v1(214.7,151.82)
N70862806: length 1.5
  TOP w0.102: D59.1 223.98,109.07 Q74.3
N70877887: length 3.4
  TOP w0.102: Q74.6 Q75.2 230.36,110.37 v1(230.62,110.63)
N70882773: length 2.8
  TOP w0.102: Q100.1 227.74,106.21 Q79.2 227.19,104.71 v1(227.45,104.45)
N72304780: length 2.3
  TOP w0.089: T86.1 158.04,126.7 v3(158.44,127.1)
  BOTTOM w0.089: v3(158.44,127.1) 158.92,127.1 159.2,127.38 159.2,127.56 159.44,127.8 159.56,127.92 UH1.AY1
N79099120: length 15.2
  TOP w0.254: PQ702.2 31.43,167.78 28.28,167.78 v1(27.74,168.32) 27,169.07 PC700.2 ; PQ702.2 33.67,167.63 36.2,167.63 36.69,167.13 PQ701.2 ; PQ702.2 32.63,165.28 33.01,164.9 PR702.2
N79099356: length 10.4
  TOP w0.102: PR709.1 146.69,162.36 v1(146.69,162.23)
  TOP w0.254: PR706.2 146.19,166.48 PQ703.1 148.21,166.48 148.4,166.3 148.4,165.82 148.67,165.55 148.67,164.73 148.53,164.58 PQ703.3 146.07,164.58 PR707.2 145.61,163.44 PR709.1
N79099544: length 3
  TOP w0.102: PR717.2 50.88,167.31 v1(51.37,167.31)
  TOP w0.254: PR717.2 50.42,165.67 50.5,165.59 PU700.5
N79100287: length 13.2
  TOP w0.254: PR701.2 28.51,171.82 28.26,171.57 28.26,169.79 28.89,169.15 32.74,169.15 33.28,169.69 v1(35.56,169.69) 36.64,169.69 PQ701.1
N79100289: length 9.3
  TOP w0.254: PQ702.1 33.49,168.77 v4(30.48,168.77) 28.74,168.77 27.88,169.63 27.88,171.57 27.62,171.82 26.7,171.82
N79100387: length 4.2
  TOP w0.102: PR700.1 25.03,176.69 26.51,176.69 v1(26.87,177.05)
  TOP w0.254: PQ700.4 PR700.1
N79108660: length 6.4
  TOP w0.254: PQ709.1 224.23,137.4 226.71,137.4 v1(227.27,137.97) 227.9,138.6 PR730.2
N79108839: length 12.5
  TOP w0.254: PU701.7 221.82,143.31 PR735.2 PR740.1 222.04,142.1 v3(222.33,142.4) ; PR737.1 PR734.2 221.5,148.41 v3(221.35,148.57)
  BOTTOM w0.254: v3(221.35,148.57) v1(221.35,144.26) 221.35,143.37 v3(222.33,142.4)
N79108872: length 6.5
  TOP w0.102: PC727.1 233.06,145.11 v1(233.22,145.28)
  TOP w0.254: PU701.3 229.99,144.58 230.38,144.19 230.38,143.59 230.66,143.31 PR725.1 PR728.2 PC727.1
N79108988: length 9.5
  TOP w0.254: PR734.1 220.59,148.92 220.94,149.28 v2(221.51,149.28) 221.96,149.28 222.51,148.73 222.51,147.86 223,147.36 PC729.1 PR738.1 PR732.2 225.2,147.02 225.2,146.36 224.69,145.85 PU701.5
N79109000: length 6.5
  TOP w0.102: v1(219.65,144.64) 219.89,144.4 221.05,144.4 PR733.2
  TOP w0.254: PU701.6 222.76,144.58 222.12,143.94 PR733.2 PR739.1 PC730.1
N81870153: length 6.6
  TOP w0.102: U19.13 21.85,198.89 22.06,198.68 22.06,198.39 22.29,198.16 22.29,197.7 22.45,197.54 23.04,197.54 23.23,197.35 23.46,197.35 23.98,196.83 24.47,196.83 24.81,197.16 R65.2 v1(25.07,196.09)
N81907121: length 2.6
  TOP w0.102: U19.23 19.48,203.11 v3(19.62,203.26)
  BOTTOM w0.102: v1(20.19,203.76) 19.69,203.26 v3(19.62,203.26) 19.5,203.13 19.5,202.7 R72.2
N81942445: length 1.8
  TOP w0.102: U19.18 22.68,200.89 R76.1
N85751870: length 1.5
  TOP w0.102: v1(173.36,91.56) 173.04,91.87 PR301.2
N89358580: length 1.3
  TOP w0.089: v3(136.47,102.2) 136.92,102.65 T50.1
  BOTTOM w0.089: v3(136.47,102.2) JCPU1.J27
N90453832: length 2
  TOP w0.102: R100.2 197.17,165.66 197.91,164.92 U27.2
N90453843: length 6.6
  TOP w0.102: U27.12 198.45,159.26 v1(198.67,159.04)
  TOP w0.203: 197.84,159.62 197.84,160.77 197.99,160.92 U27.12
  TOP w0.254: R101.2 195.88,157.66 197.84,159.62
N91483552: length 9
  BOTTOM w0.102: JLVDS1.10 217.04,169.54 216.83,169.33 216.83,168.49 214.7,166.36 R3762.1 214.7,163.26 v1(213.84,162.41)
N91583193: length 3.7
  TOP w0.254: U74.31 v1(276.49,157.47) 277.16,157.47 278.16,156.47 C969.1
N91583219: length 3.8
  TOP w0.254: C962.1 277.62,160.39 v1(276.49,160.39) 274.96,160.39 274.58,160.77 U74.37
N91583239: length 4.9
  TOP w0.102: v1(276.29,150.31) 276.29,150.69 R1642.1
  TOP w0.254: R1642.1 275.08,151.99 274.62,152.45 274.04,152.45 273.29,153.2 U74.22
N91583289: length 4.7
  BOTTOM w0.102: Q106.3 285.73,152.53 v1(285.54,152.34)
  BOTTOM w0.254: Q106.3 286.83,152.53 287.25,152.11 287.25,151.11 286.88,150.74 286.5,150.74 R1080.2
N91583291: length 2.9
  BOTTOM w0.102: v1(290.22,150.74) 289.65,150.17 R1079.2
  BOTTOM w0.254: R1079.2 289,150.97 288.74,151.23 Q106.6
N91583293: length 1.9
  TOP w0.102: R1076.2 264.67,156.95 C977.1 v1(262.97,156.95)
N91814876: length 2
  TOP w0.089: v3(77.78,128.6) v1(77.38,129)
  TOP w0.254: RV36.2 77.82,128.64 v3(77.78,128.6)
  BOTTOM w0.254: v3(77.78,128.6) UV1.K25
N92289874: length 3.7
  TOP w0.102: v3(137.9,153.42) 138.22,153.1 v1(138.22,152.77) 138.22,152.62 138.04,152.44 R61.2
  BOTTOM w0.102: v3(137.9,153.42) 137.82,153.49 U6.8
N106528709: length 2.4
  TOP w0.102: R1702.1 190.91,23.99 v1(190.57,24.34) 190.41,24.49 190.25,24.49 189.87,24.86 U38.26
N111614398: length 2.5
  TOP w0.089: RV25.2 67.74,130.79 v1(68.01,130.52)
  TOP w0.254: v3(66.31,130.62) 66.47,130.79 RV25.2
  BOTTOM w0.3: v3(66.31,130.62) 66.18,130.75 UV1.N10
N112194115: length 12.1
  TOP w0.102: R887.1 200.98,80.9 199.48,80.9 199.24,80.66 v3(199.24,80.46) ; U51.B57 205.97,80.29 206.33,80.65 206.33,80.95 v3(206.32,80.95)
  BOTTOM w0.102: v3(206.32,80.95) 205.83,80.46 v1(204.92,80.46) 204.42,79.96 199.73,79.96 v3(199.24,80.46)
N114027505: length 1.5
  TOP w0.508: v3(76.46,137.73) 76.19,137.47 RV298.1
  BOTTOM w0.305: UV1.AA22 76.32,137.6 v3(76.46,137.73)
N114027546: length 3.7
  TOP w0.089: v3(76.48,136.62) 76.48,136.55 77.22,135.82 77.47,135.82 v1(78.17,135.12)
  TOP w0.508: RV296.1 76.45,136.59 v3(76.48,136.62)
  BOTTOM w0.254: UV1.Y22 76.46,136.6 v3(76.48,136.62)
N115146002: length 7
  TOP w0.102: U51.B1 205.68,73.89 204.1,72.32 v1(203.2,72.32) 202.88,72.32 201.75,71.19 200.51,71.19 R1070.1
N116042141: length 1.3
  TOP w0.102: U46.A44 179.42,66.06 T146.1
N116870152: length 3.8
  BOTTOM w0.102: v1(50.04,169.84) 50.53,169.34 PR736.2
  BOTTOM w0.254: PR744.1 PR736.2 49.85,168.65 49.74,168.53 PU703.4
N116874102: length 3.8
  BOTTOM w0.102: PU703.6 49.73,167.23 50.23,166.74 v1(50.36,166.74)
  BOTTOM w0.254: PU703.6 48.37,167.23 47.94,166.8 47.94,166.12 PR710.2
N117654516: length 7.5
  TOP w0.254: v3(273.17,151.08) 272.63,150.55 R1086.2
  BOTTOM w0.254: Q324.1 276.87,151.06 276.18,150.36 v1(274.51,150.36) 273.89,150.36 v3(273.17,151.08)
N118052171: length 5.2
  TOP w0.102: U54.4 214.87,158.69 214.7,158.87 214.7,159.12 214.19,159.62 v1(214.19,160.07) 214.19,161.92 214.52,162.25 D10.2
N118416346: length 3.1
  TOP w0.254: U74.35 275.4,159.47 275.52,159.59 276.36,159.59 277.15,158.8 C962.2
N119819670: length 6.1
  BOTTOM w0.102: R1166.2 v1(246.25,203.95) 246.51,203.95 248.01,205.45 JLOM1.10
N121245733: length 2.6
  BOTTOM w0.102: R704.2 269.43,192.51 v3(269.43,192.51) 269.56,192.64 JMINI1.22
N122052446: length 2.9
  TOP w0.102: U39.9 v1(212.01,114.73) 212.01,115.72 R657.1
N123100505: length 2.6
  TOP w0.203: PU100.19 197.85,40.12 197.46,40.5 197.25,40.5 v1(197.02,40.73)
  TOP w0.254: PR111.2 197,41.44 197,40.74 v1(197.02,40.73)
N124735836: length 2.9
  TOP w0.102: v1(219.78,86.54) 218.66,87.66 Q4.2 218.52,88.7 R55.2
N126014010: length 15.6
  TOP w0.102: Q330.5 281.18,152.9 281.29,152.78 281.29,152.34 281.2,152.25 Q330.6 280.93,151.76 280.53,151.36 280.53,150.79 279.35,149.61 v1(278.68,149.61) 269.18,149.61 R1703.2
N126032191: length 6.9
  BOTTOM w0.102: v1(195.66,146.88) R431.2 194.12,146.88 193.8,146.56 Q32.2 191.38,146.56 190.88,147.06 Q24.1
N126094999: length 10.2
  TOP w0.102: RV77.2 88.71,124.46 v1(88.71,123.69) 88.71,123.31 88.97,123.05 RV56.1 90.17,122.85 QV4.1 88.9,120.64 88.9,119.19 RV58.1 RV60.2
N126095070: length 5.4
  TOP w0.102: RV55.1 92.64,123.94 RV53.2 92.64,125.72 RV47.2 92.66,127.05 D71.2 93.22,127.06 v1(93.92,126.36)
N126095126: length 8.1
  TOP w0.102: QV3.2 95.33,120.63 94.11,121.85 92.39,121.85 v1(92.14,122.1) 91.75,122.49 CV52.1 RV56.2 RV61.2 RV55.2
N126095150: length 5.7
  TOP w0.102: RV57.2 91.94,118.76 RV59.1 92.01,119.64 v1(92.01,120.7) 92.01,120.96 91.89,121.08 90.11,121.08 89.52,120.5 QV4.2
N126095152: length 2.5
  TOP w0.102: RV59.2 92.85,119.81 93.3,120.26 v1(93.3,120.64) 93.3,121.03 93.54,121.28 QV3.1
N126095187: length 3.6
  TOP w0.102: v1(87.95,115.24) 88.46,115.24 89.11,115.89 QV7.2 89.25,117 CV53.1 89.28,117.03 RV58.2
N126163800: length 2.2
  TOP w0.089: T131.1 82.99,122.36 v3(82.68,122.36)
  BOTTOM w0.254: UV1.A32 82.18,123.36 82.68,122.86 v3(82.68,122.36)
N126163802: length 3.1
  BOTTOM w0.089: 58.11,145.02 60.56,145.02 UV1.AM1
  BOTTOM w0.102: 58.11,145.02 T132.1
N126163816: length 3.5
  BOTTOM w0.089: UV1.AM32 82.57,145.39 83.5,145.39 83.82,145.71
  BOTTOM w0.102: 83.82,145.71 84.16,146.04 84.97,146.04 T133.1
N126182567: length 3.2
  TOP w0.089: 58.11,124.96 RV178.2 58.5,125.05 CV343.1
  TOP w0.102: 58.11,124.96 57.55,124.96 RV179.1 56.48,124.97 v1(56.28,124.77)
N126184618: length 1.8
  TOP w0.102: T147.1 186.97,74.45 186.97,73.89 186.62,73.54 U46.A23
N126244783: length 2.3
  TOP w0.102: C445.1 264.85,179.07 v1(264.69,178.92) 264.69,178.49 264.85,178.33 U145.12
N126244789: length 2.6
  TOP w0.102: U145.10 265.65,178.33 v1(266.21,178.88) 266.21,179.45 C450.1
N126984883: length 2.2
  TOP w0.102: C437.1 224.02,70.63 224.25,70.4 v1(224.6,70.4) 224.83,70.4 225.08,70.65 U36.12
N126984889: length 2.1
  TOP w0.102: U36.10 225.1,71.45 224.88,71.67 v3(224.7,71.67) 224.23,71.67 224.11,71.54 C435.1
N126986648: length 1.6
  TOP w0.102: C438.1 174.25,44 174.35,43.89 U37.12
N126986654: length 1.6
  TOP w0.102: C436.1 175.15,44.85 U37.10
N126989335: length 2.3
  TOP w0.102: C444.1 246.31,152.91 246.31,152.28 v1(246.2,152.17) 246.09,152.06 246.09,151.44 246.11,151.42 U57.12
N126989341: length 2.3
  TOP w0.102: C448.1 246.97,152.69 247.09,152.57 v3(247.09,151.77) 246.91,151.58 U57.10
N211306270: length 2.6
  TOP w0.102: v3(107.76,130.1) v2(107.76,129.36)
  TOP w0.254: v3(107.76,130.1) 108.02,130.36 PC666.1
  BOTTOM w0.254: PU602.7 107.94,130.28 v3(107.76,130.1)
N211347431: length 5.9
  TOP w0.102: PD813.2 v1(178.83,38.77)
  TOP w0.254: PD813.2 181.8,37.77 181.08,37.05 PQ814.1

## Copper pours and planes (outline as drawn)
1.5VSP_LX on TOP (solid shape): 199.33,58.43 199.33,56.25 199.78,55.8 200.43,55.8 200.55,55.68 200.55,55.03 200.47,54.95 199.81,54.95 199.33,54.47 199.33,53.2 199.07,52.95 197.04,52.95 196.79,53.2 196.79,57.46 197.93,58.6 199.16,58.6
1.5VSP_VIN on TOP (solid shape): 205.07,58.95 205.07,58.17 205.62,58.17 205.62,57.92 205.07,57.92 205.07,57.37 205.62,57.37 205.62,57.12 205.08,57.12 205.08,56.48 204.12,55.51 204.08,55.51 204.08,55.48 203.52,54.92 202.82,54.92 202.69,55.04 202.69,58.98 202.88,59.17 204.85,59.17
1.35V_B+ on TOP (solid shape): 167.39,92.64 167.39,91.43 168.03,90.79 168.89,90.79 168.89,90.79 168.91,90.79 168.91,91.31 169.36,91.31 169.36,90.79 169.39,90.79 169.39,90.79 170.09,90.79 170.09,90.79 170.11,90.79 170.11,91.31 170.56,91.31 170.56,90.79 170.59,90.79 170.59,90.79 171.21,90.79 171.39,90.6 171.39,89.14 170.75,88.51 170.75,87.02 170.69,86.96 167.47,86.96 166.88,87.56 162.52,87.56 162.27,87.81 162.27,92.05 162.61,92.38 165.17,92.38 166.05,93.27 166.75,93.27
+0.9V_LAN on TOP (solid shape): 236.54,170.27 237.65,170.27 237.74,170.19 237.75,170.17 237.75,170.15 237.75,169.44 237.52,169.21 235.53,169.21 235.29,169.45 235.29,170.49 235.44,170.64 236.17,170.64
+0.9V_LAN on TOP (solid shape): 238.12,161.37 238.12,160.43 237.93,160.24 237.73,160.24 236.92,159.44 236.67,159.44 236.54,159.57 236.54,160.05 237.4,160.91 237.4,161.12 237.72,161.44 238.05,161.44
+0.9V_LAN on TOP (solid shape): 245.87,169.13 245.87,167.79 245.78,167.69 245.72,167.69 245.4,167.54 245.35,167.2 245.35,167.17 245.33,167.14 245.26,167.07 244.21,167.07 244.11,167.17 244.11,168.53 244.74,169.16 245.84,169.16
+0.9V_LAN on TOP (solid shape): 242.13,161.38 242.13,160.46 242.43,160.15 242.92,160.15 243.04,160.03 243.04,159.72 242.89,159.57 242.89,158.38 242.7,158.19 241.15,158.19 241.1,158.24 241.1,158.98 241.34,159.22 241.63,159.22 241.87,159.46 241.87,159.51 241.87,159.52 241.94,159.74 241.87,159.96 241.52,160.32 241.52,161.37 241.58,161.44 242.07,161.44
+0.9V_LAN on BOTTOM (solid shape): 245.34,169.67 245.34,164.61 244.9,164.16 244.56,164.16 244.55,164.17 244.41,164.19 244.26,164.15 244.25,164.15 243.26,164.15 243.14,164.27 243.14,166.29 243.13,166.3 243.13,166.89 242.95,167.07 242.14,167.07 241.87,166.81 241.34,166.81 241.34,166.82 241.3,166.86 241.3,167.25 241.19,167.36 241.19,167.44 241,167.63 241,167.87 241.1,167.97 241.39,167.97 241.54,167.82 241.95,167.82 242.19,168.06 242.19,168.11 242.2,168.13 242.2,168.7 242.19,168.71 242.19,168.74 241.95,168.98 240.72,168.98 240.25,168.51 238.32,168.51 237.33,169.5 236.16,169.5 236.15,169.49 235.39,169.49 235.27,169.62 235.27,170.4 236.52,171.64 243.37,171.64
+0.9V_LAN on IN3 (solid shape): 245.31,167.52 245.31,165.14 244.32,164.15 244.21,164.15 243.73,163.67 243.73,161.94 244.18,161.49 244.18,159.94 244.1,159.86 244.01,159.84 243.94,159.9 243.36,160.01 243.47,159.43 243.53,159.36 243.51,159.27 243.27,159.03 241.25,159.03 241.18,159.06 241.15,159.14 241.14,159.24 241.11,159.33 241.1,159.4 241.14,159.46 241.15,159.47 241.21,159.49 241.28,159.47 241.86,159.74 241.28,160.01 241.21,159.99 241.15,160.01 240.7,160.02 240.61,159.57 240.62,159.5 240.58,159.44 240.47,159.31 240.44,159.14 240.41,159.06 240.34,159.03 236.83,159.03 236.51,159.36 236.51,160.72 236.57,160.74 236.63,160.72 237.21,160.99 236.63,161.26 236.57,161.24 236.51,161.26 236.51,161.38 236.68,161.55 240.93,161.55 241.63,162.25 241.63,166.45 242.93,167.74 245.09,167.74
+0.675V_DDR_VTT on TOP (solid shape): 170.18,80.89 170.18,80.06 170.05,79.94 168.28,79.94 168.09,80.13 168.09,80.38 168.72,81.02 170.05,81.02
+0.675V_DDR_VTT on TOP (solid shape): 176.34,82.59 176.34,81.59 176.15,81.4 174.5,81.4 174.25,81.65 174.25,81.91 174.25,82.07 174.77,82.07 174.77,82.5 174.25,82.5 174.25,83.11 174.25,83.11 174.25,83.32 174.42,83.5 175.43,83.5
+0.675V_DDR_VTT on TOP (solid shape): 155.85,36.81 156.64,36.81 156.79,36.65 156.79,32.36 156.59,32.15 156.56,32.08 156.49,32.05 155.69,31.25 156.49,30.45 156.56,30.42 156.59,30.35 156.59,28.21 156.58,28.2 156.54,28.01 156.58,27.81 156.59,27.8 156.59,18.95 156.56,18.88 156.49,18.85 155.69,18.05 156.49,17.25 156.56,17.22 156.59,17.15 156.59,15.27 156.25,14.93 154.26,14.93 154.09,15.11 154.09,19.37 154.36,19.64 154.36,20.38 154.52,20.78 154.19,21.05 154.12,21.08 154.09,21.15 154.09,29.3 154.05,29.34 154.05,35.9 154.04,35.9 154.04,36.77 154.08,36.81 155.85,36.81
+0.675V_DDR_VTT on BOTTOM (solid shape): 155.72,28.36 155.72,26.37 155.46,26.11 154.65,26.11 154.56,26.19 154.56,28.34 154.72,28.51 155.58,28.51
+0.675V_DDR_VTT on BOTTOM (solid shape): 156.75,36.25 156.75,34.59 156.33,34.17 154.33,34.17 154.24,34.26 154.24,36.41 154.4,36.57 156.43,36.57
+0.675V_DDR_VTT on BOTTOM (solid shape): 156.14,23.37 156.14,21.78 155.68,21.32 154.34,21.32 154.25,21.41 154.25,23.32 154.43,23.5 156.01,23.5
+0.675V_DDR_VTT on BOTTOM (solid shape): 155.65,15.72 155.65,14.7 155.64,14.69 155.64,13.13 155.42,12.91 154.63,12.91 154.54,13 154.54,13.77 154.55,13.78 154.55,15.75 154.7,15.9 155.47,15.9
+0.675V_DDR_VTT on IN4 (solid shape): 157.89,36.31 157.89,35.25 157.69,35.04 156.4,35.04 156.2,35.24 156.2,36.29 156.32,36.42 157.79,36.42
+0.675V_DDR_VTT on IN4 (solid shape): 169.14,81 169.14,80.73 167.64,79.24 167.51,79.24 167.07,79.68 167.07,80.06 168.23,81.23 168.91,81.23
+0.675V_P on TOP (solid shape): 175.64,85.84 175.64,85.65 175.01,85.02 175.01,84.57 175.13,84.45 175.51,84.45 175.78,84.44 175.8,84.45 176.04,84.45 176.21,84.62 176.21,85.4 176.28,85.46 176.34,85.46 176.4,85.4 176.4,84.32 176.38,84.29 176.36,84.29 176.15,84.16 176.08,83.92 176.07,83.9 176.06,83.88 175.98,83.79 175.96,83.79 175.85,83.73 175.76,83.63 174.32,83.63 174.08,83.39 174.08,82.38 174.64,82.38 174.64,82.2 174.08,82.2 174.08,81.37 173.79,81.08 172.34,81.08 172.21,81.21 172.21,84.4 172.33,84.52 173.37,84.52 174.75,85.91 175.58,85.91
+1.2V_LDO on TOP (solid shape): 190.97,32.62 190.97,32.28 190.87,32.18 189.91,32.18 189.6,32.5 188.84,32.5 188.62,32.29 188.62,31.74 188.52,31.64 187.47,31.64 187.22,31.88 187.22,33.99 187.33,34.1 189.49,34.1
+1.2V_LDO_OZ on TOP (solid shape): 191.4,31.51 192.12,31.51 192.24,31.38 192.24,30.81 191.84,30.4 191.84,29.76 192.09,29.5 192.09,26.81 192,26.73 191.26,26.73 191.15,26.84 191.15,28.9 189.98,30.07 189.98,31.83 190.14,31.98 190.92,31.98
+1.2V_LDO_OZ on IN3 (solid shape): 183.2,30.28 184.4,30.28 184.42,30.27 184.59,30.23 184.76,30.27 184.77,30.28 184.98,30.28 185.23,30.18 185.48,30.28 189.3,30.28 189.95,30.94 191.08,30.94 191.16,30.85 191.16,30.04 190.12,29 190.12,26.74 190.55,26.31 190.55,25.28 190.43,25.16 189.7,25.16 189.69,25.16 189.37,25.16 189.01,25.52 189.01,28.95 188.73,29.23 182.88,29.23 182.47,29.64 181.7,29.64 181.09,30.25 181.09,31.19 181.28,31.38 182.1,31.38
+1.5V_CARD on TOP (solid shape): 233.79,61.36 233.79,58.83 233.68,58.73 233.11,58.73 232.79,58.41 232.71,58.41 232.41,58.41 232.16,58.16 231.65,58.16 231.46,58.35 231.46,59.49 231.46,59.49 231.46,59.74 233.11,61.39 233.12,61.39 233.2,61.47 233.67,61.47
+1.5V_CARD on TOP (solid shape): 223.55,33.4 223.56,33.37 223.66,33.08 223.94,32.98 223.95,32.98 223.97,32.97 224.14,32.8 225.35,32.8 225.45,32.71 225.45,32.12 225.34,32.02 224.3,32.02 224.17,31.9 223.77,31.9 223.66,32.01 223.66,32.27 223.66,32.4 223.56,32.5 223.12,32.5 222.98,32.64 222.98,33.39 223.02,33.43 223.52,33.43
+1.5V_CARD on IN2 (solid shape): 225.64,32.71 225.64,31.98 225.41,31.74 223.89,31.74 223.6,32.03 223.6,32.86 223.68,32.94 225.41,32.94
+1.5V_CARD on IN2 (solid shape): 235.02,60.51 235.02,59.74 234.82,59.55 234.63,59.55 234.48,59.7 234.44,59.75 234.32,59.87 233.94,59.87 232.26,58.19 231.39,58.19 231.18,58.4 230.71,58.4 230.56,58.25 230.18,58.25 229.68,58.75 229.68,59.23 230,59.55 230.11,59.67 232.24,59.67 233.43,60.85 234.67,60.85
+1.05V_M on TOP (solid shape): 168.54,118.89 168.54,117.54 168.4,117.39 167,117.39 166.87,117.53 166.87,118.91 167.18,119.23 168.2,119.23
+1.05V_M on TOP (solid shape): 164.64,108.91 164.64,107.17 164.11,106.64 162.96,106.64 161.79,105.47 161.19,105.47 161.19,105.46 161.16,105.46 161.16,104.95 160.71,104.95 160.71,105.46 160.69,105.46 160.69,105.47 159.99,105.47 159.99,105.46 159.96,105.46 159.96,104.95 159.51,104.95 159.51,105.46 159.49,105.46 159.49,105.47 158.87,105.47 158.87,105.47 158.28,105.47 157.9,105.85 157.9,108.91 158.22,109.22 164.33,109.22
+1.05V_M on BOTTOM (solid shape): 169.14,137.65 169.14,137.57 168.87,137.31 168.87,137.13 169.14,136.86 169.14,136.68 169.07,136.6 169.07,136.17 169.59,135.65 169.59,135.44 169.8,135.22 169.8,135.11 169.68,134.99 166.91,134.99 166.8,135.1 166.8,135.24 166.91,135.35 166.95,135.35 167.43,135.83 167.43,136.84 167.56,136.96 167.59,136.99 168.06,137.47 168.06,137.57 168.24,137.75 168.41,137.75 168.44,137.73 168.51,137.66 168.76,137.66 168.9,137.79 169,137.79
+1.05V_M on IN3 (solid shape): outline of 139 points within 166.98,134.31 171.46,137.48
+1.05V_M on VCC: 158.09,102.99 157.1,103.98 157.1,108.07 161.71,108.07 164.15,110.5 164.15,123.96 166.31,126.12 166.31,132.09 167.58,133.36 167.58,138.38 168.57,139.37 175.41,139.37 176.09,138.7 176.09,113.32 165.76,102.99
+1.05V_MP on TOP (solid shape): 164.16,106.15 164.16,104.88 164.02,104.74 163.15,104.74 162.92,104.51 162.92,103.24 162.69,103.01 161.82,103.01 161.61,102.8 161.61,102.8 160.05,101.23 160.05,100.69 159.75,100.4 157.1,100.4 156.66,100.84 156.66,102.23 157.85,103.42 157.85,105 158.18,105.34 159.39,105.34 159.39,104.82 160.09,104.82 160.09,105.34 160.59,105.34 160.59,104.82 161.29,104.82 161.29,105.34 161.96,105.34 162.98,106.35 163.96,106.35
+1.05V_MP on BOTTOM (solid shape): 161.56,104.29 161.56,102.48 160.41,101.33 160.41,94.29 160.01,93.89 156.2,93.89 155.76,94.34 155.76,97.61 154.87,98.51 154.87,102.18 157.2,104.51 161.33,104.51
+1.05V_RUN on TOP (solid shape): 153.98,97.3 153.98,96.03 153.85,95.91 151.64,95.91 151.49,96.07 151.49,97.37 151.61,97.5 153.78,97.5
+1.5V_RUN on TOP (solid shape): 27.11,202.45 27.11,200.92 27.03,200.84 25.23,200.84 25.07,201 25.07,201.41 25.09,201.43 25.61,201.43 25.63,201.45 25.63,201.91 25.62,201.92 25.11,201.92 25.08,201.96 25.08,202.5 25.19,202.61 26.95,202.61
+1.5V_RUN on TOP (solid shape): 202.01,63.94 202.01,62.63 201.03,61.65 198.95,61.65 198.79,61.81 197.89,61.81 197.89,61.8 197.89,61.26 197.63,61.26 197.63,61.81 197.09,61.81 197.09,61.26 196.83,61.26 196.83,61.81 196.36,61.81 196.09,62.08 196.09,63.45 197.32,64.68 201.27,64.68
+1.5V_RUN on TOP (solid shape): 156.82,137.25 156.82,136.77 156.44,136.39 151.61,136.39 151.13,135.91 151.13,135.31 151.39,135.05 153.29,135.05 153.61,134.74 153.61,133.22 153.76,133.07 154.35,133.07 154.53,133.25 154.53,133.46 154.62,133.54 155.28,133.54 155.32,133.5 155.32,132.03 155.2,131.9 151.38,131.9 150.93,132.35 150.93,133.58 150.18,134.33 150.18,136.65 150.89,137.36 156.7,137.36
+1.05V_RUN on TOP (solid shape): 161.44,116.58 161.45,116.56 161.45,116.53 161.45,116.27 161.6,116.05 161.6,116.05 162.17,115.48 163.18,115.48 163.31,115.35 163.31,114.83 163.72,114.42 163.72,113 162.97,112.25 159.49,112.25 159.16,112.58 159.16,113.86 158.31,114.71 158.31,116.2 158.7,116.59 158.72,116.6 158.74,116.6 158.85,116.6 158.96,116.62 158.97,116.62 159.4,116.62 159.43,116.64 161.38,116.64
+1.5V_RUN on TOP (solid shape): 234.29,61.38 234.29,59.96 234.35,59.9 234.35,59.87 234.44,59.56 234.76,59.46 235.02,59.67 235,60 235,61.37 235.06,61.44 235.2,61.44 235.27,61.37 235.27,58.73 235.21,58.66 234.06,58.66 234,58.73 234,61.37 234.06,61.44 234.24,61.44
+1.5V_RUN on TOP (solid shape): 221.56,65.93 221.56,64.58 220.86,63.88 217.25,63.88 216.89,64.24 216.89,66.37 219.8,66.37 219.8,66.32 219.82,66.27 219.83,66.22 219.86,66.17 219.89,66.13 219.93,66.09 219.98,66.06 220.03,66.04 220.08,66.03 220.13,66.02 220.18,66.02 220.24,66.03 220.29,66.04 220.33,66.06 220.38,66.09 220.42,66.13 220.45,66.17 220.48,66.22 220.5,66.27 220.51,66.32 220.51,66.37 220.51,66.43 220.5,66.48 220.48,66.53 220.45,66.57 220.42,66.62 220.38,66.65 220.33,66.68 220.29,66.71 220.24,66.72 220.18,66.73 220.13,66.73 220.08,66.72 220.03,66.71 219.98,66.68 219.93,66.65 219.89,66.62 219.86,66.57 219.83,66.53 219.82,66.48 219.8,66.43 219.8,66.37 216.89,66.37 216.89,66.39 217.33,66.82 220.66,66.82
+1.5V_RUN on TOP (solid shape): outline of 167 points within 152.34,145.43 169.39,152.99
+1.05V_RUN on TOP (solid shape): outline of 278 points within 157.15,133.72 166.43,139.1
+1.05V_RUN on BOTTOM (solid shape): 156.71,152.77 156.71,151.71 156.52,151.52 155.38,151.52 154.76,152.15 154.76,152.71 154.96,152.91 156.56,152.91
+1.5V_RUN on BOTTOM (solid shape): 154.69,152.04 154.73,151.99 154.78,151.94 154.95,151.77 154.95,151.15 154.88,151.08 153.34,151.08 152.61,151.81 152.61,152.55 152.9,152.84 153.88,152.84
+1.05V_RUN on BOTTOM (solid shape): 154.11,97.93 154.11,96.06 154.01,95.95 152.96,95.95 152.8,96.11 152.8,97.23 152.64,97.4 151.8,97.4 151.67,97.53 151.67,98.13 151.79,98.25 153.79,98.25
+1.05V_RUN on BOTTOM (solid shape): 168.85,140.57 168.85,140.38 169.1,140.12 169.1,140 168.45,139.34 168.45,139.2 168.44,139.18 168.43,139.17 168.36,139.09 168.23,139.09 167.41,139.91 167.41,140.05 167.71,140.35 167.71,140.53 167.87,140.68 168.08,140.68 168.21,140.55 168.38,140.55 168.52,140.69 168.73,140.69
+1.05V_RUN on BOTTOM (solid shape): 166.48,139.3 166.48,139.19 166.25,138.96 166.25,138.71 166.5,138.45 166.8,138.45 166.97,138.62 167.68,138.62 167.7,138.6 167.76,138.54 167.83,138.51 167.86,138.49 167.86,138.27 166.52,136.93 166.52,135.92 166.49,135.9 166.33,135.74 166.29,135.52 165.71,134.93 164.88,134.93 164.72,135.1 164.72,137.72 165.65,138.65 165.65,138.7 165.66,138.71 165.68,138.81 165.67,138.92 165.76,139.01 165.83,139.06 165.88,139.13 166.21,139.46 166.32,139.46
+1.05V_RUN on BOTTOM (solid shape): 164.25,137.29 164.25,137.05 164.22,137.03 164.14,136.97 164.09,136.88 164.09,136.87 163.97,136.75 163.97,135.99 163.9,135.92 163.89,135.92 163.75,135.84 163.67,135.7 163.66,135.68 163.69,135.41 163.9,135.25 163.93,135.23 163.93,135.06 163.75,134.88 162.85,134.88 162.31,135.42 162.31,135.85 162.44,135.98 162.44,136.16 162.26,136.34 161.36,136.34 161.29,136.26 161.18,136.26 160.95,136.5 160.95,136.56 160.95,136.62 160.95,136.78 160.73,137 160.73,137.11 160.97,137.34 162.01,137.34 162.31,137.04 163.46,137.04 163.89,137.47 164.07,137.47
+1.5V_RUN on IN1 (solid shape): 222.69,65.56 222.69,64.63 222.43,64.36 219.77,64.36 219.56,64.57 219.56,65.44 219.83,65.71 222.54,65.71
+1.5V_RUN on IN1 (solid shape): 234.34,59.91 234.35,59.88 234.35,59.87 234.35,59.71 234.43,59.57 234.43,58.71 234.32,58.6 234.08,58.6 232.81,59.87 232.81,60.4 233.17,60.76 233.49,60.76
+1.05V_RUN on IN2 (solid shape): 160.17,114.87 160.17,114.22 159.98,114.03 157.94,114.03 157.56,114.41 157.56,115.03 157.74,115.2 159.84,115.2
+1.5V_RUN on IN2 (solid shape): 222.4,108.81 222.4,104.8 222.17,104.56 219.9,104.56 219.74,104.72 219.74,108.54 220.54,109.34 220.54,109.34 221.88,109.34
+1.05V_RUN on IN2 (solid shape): 154.49,98.41 154.49,96.29 154.15,95.95 153.3,95.95 153.11,96.14 153.11,98.26 153.37,98.53 154.37,98.53
+1.5V_RUN on IN2 (solid shape): outline of 1061 points within 216.36,64.21 222.82,95.79
+1.5V_RUN on IN2 (solid shape): outline of 3689 points within 151.39,118.23 163.57,152.87
+1.05V_RUN on IN3 (solid shape): 156.27,152.21 156.27,150.93 156.04,150.7 154.85,150.7 154.72,150.83 154.72,152.31 154.92,152.5 155.97,152.5
+1.05V_RUN on IN3 (solid shape): 156.59,141.91 156.59,141.02 156.47,140.9 154.5,140.9 154.12,141.28 154.12,141.72 154.56,142.17 156.34,142.17
+1.5V_RUN on IN3 (solid shape): outline of 104 points within 78.85,151.2 86.9,155.09
+1.5V_RUN on IN3 (solid shape): outline of 188 points within 24.71,192.08 28.46,202.6
+1.5V_RUN on IN3 (solid shape): outline of 1753 points within 105.31,150.78 154.42,161.49
+1.5V_RUN on IN3 (solid shape): outline of 2081 points within 155.01,106.17 221.77,120.26
+1.05V_RUN on IN4 (solid shape): outline of 86 points within 162.31,133.72 166.5,137.53
+1.05V_RUN on VCC: 154.03,108.58 148.78,113.82 148.78,138.89 153.67,143.78 153.67,145.81 155.3,147.44 165.69,147.44 167.39,145.74 167.39,143.97 169.93,141.43 169.93,139.88 168.36,139.88 167.07,138.59 167.07,133.57 165.8,132.3 165.8,126.33 163.64,124.17 163.64,110.71 161.5,108.58
+1.5V_RUN_HDMI on TOP (solid shape): 24.92,202.16 24.92,201.78 24.95,201.76 25.45,201.76 25.48,201.73 25.48,201.59 25.46,201.58 24.92,201.58 24.91,201.57 24.91,201.2 24.87,201.16 24.68,201.16 24.43,201.41 22.54,201.41 22.32,201.19 20.48,201.19 20.42,201.25 20.42,201.73 20.67,201.98 24.26,201.98 24.45,202.17 24.91,202.17
+1.5V_RUN_HDMI on BOTTOM (solid shape): outline of 740 points within 14.04,195.7 23.43,202.68
+1.5V_RUNP on TOP (solid shape): 196.71,61.13 197.21,61.13 197.21,61.65 197.51,61.65 197.51,61.13 198.01,61.13 198.01,61.65 198.38,61.65 198.57,61.46 198.57,59.81 196.41,57.65 196.41,53.27 196.15,53.01 194.06,53.01 193.87,53.2 193.87,57.14 194.25,57.52 194.25,61.27 194.63,61.65 196.71,61.65
+1.05VSP_5V on TOP (solid shape): 174.31,98.92 174.31,97.97 173.93,97.59 173.93,96.83 174.44,96.32 175.07,96.32 175.13,96.26 175.13,96.13 175.07,96.07 174.31,96.07 174.18,96.19 172.98,96.19 172.79,96.38 172.79,98.73 173.04,98.99 174.25,98.99
+1.05VSP_B+ on TOP (solid shape): 170.88,96.76 170.88,94.67 170.69,94.48 170.33,94.48 170.33,95 169.82,95 169.82,94.48 169.53,94.48 169.53,95 169.02,95 169.02,94.48 166.12,94.48 165.74,94.1 165.74,93.52 165.63,93.41 163.43,93.41 163.32,93.52 163.32,95.68 163.45,95.81 164.97,95.81 165.93,96.76 165.93,97.27 165.99,97.34 170.31,97.34
+1.8V_RUN_GFX on TOP (solid shape): 73.75,149.63 73.75,148.67 73.67,148.59 73.26,148.59 72.97,148.89 72.94,148.89 72.92,148.91 72.6,148.91 72.58,148.89 71.49,148.89 71.19,148.58 71.19,148.1 71.09,148.01 70.68,148.01 70.42,147.75 70.42,147.09 69.92,146.59 69.92,144.54 70.04,144.41 70.04,142.17 69.7,141.83 69,141.83 68.35,142.47 68.35,146.86 69.15,147.66 69.15,148.96 69.88,148.96 69.88,148.91 69.89,148.86 69.91,148.81 69.94,148.76 69.97,148.72 70.01,148.68 70.05,148.65 70.1,148.63 70.15,148.61 70.21,148.61 70.26,148.61 70.31,148.61 70.36,148.63 70.41,148.65 70.45,148.68 70.49,148.72 70.53,148.76 70.55,148.81 70.57,148.86 70.58,148.91 70.59,148.96 70.58,149.01 70.57,149.07 70.55,149.12 70.53,149.16 70.49,149.2 70.45,149.24 70.41,149.27 70.36,149.29 70.31,149.31 70.26,149.32 70.21,149.32 70.15,149.31 70.1,149.29 70.05,149.27 70.01,149.24 69.97,149.2 69.94,149.16 69.91,149.12 69.89,149.07 69.88,149.01 69.88,148.96 69.15,148.96 69.15,149.59 69.93,150.36 73.03,150.36
+1.8V_RUN_GFX on BOTTOM (solid shape): 73.22,150.17 73.22,149.36 72.98,149.12 71.96,149.12 71.66,149.42 71.66,149.87 71.41,150.13 67.99,150.13 67.95,150.17 67.95,150.89 68.1,151.03 72.35,151.03
+1.8V_RUN_GFX on BOTTOM (solid shape): 96,127.38 96,126.31 96.53,126.31 96.53,126.06 96,126.06 96,125.51 96.53,125.51 96.53,125.31 96.48,125.26 96,125.26 96,124.78 95.95,124.73 95.95,124.45 95.82,124.32 94.35,124.32 94.17,124.5 94.17,127.37 94.36,127.56 95.82,127.56
+1.8V_RUN_GFX on IN3 (solid shape): outline of 184 points within 88.62,124.83 95.46,129.91
+1.8V_RUN_GFX on IN3 (solid shape): outline of 604 points within 68.21,140.07 85.51,146.05
+1.8V_RUN_VIN on BOTTOM (solid shape): 105.91,126.3 106.85,126.3 106.85,125.77 107.36,125.77 107.36,126.3 107.65,126.3 107.65,125.77 108.16,125.77 108.16,126.3 109.21,126.3 109.41,126.1 109.41,123.94 109.03,123.56 106.01,123.56 105.67,123.91 105.67,124.39 105.28,124.77 103.76,124.77 103.57,124.95 103.57,126.87 103.76,127.05 105.16,127.05
+1.8V_RUNP on BOTTOM (solid shape): 99.51,129.59 99.51,127.37 100.01,126.86 100.01,125.21 99.82,125.02 98.05,125.02 97.03,124.01 97.03,123.18 96.9,123.05 96.39,123.05 96.13,123.32 96.13,125.13 96.66,125.13 96.66,125.64 96.13,125.64 96.13,125.93 96.66,125.93 96.66,126.44 96.13,126.44 96.13,127.59 96.26,127.72 96.26,128.76 97.22,129.72 99.38,129.72
+1.8V_SPLL_PVDD on TOP (solid shape): 59.57,128.91 59.73,128.91 59.74,128.9 59.88,128.87 60.02,128.9 60.03,128.91 62.27,128.91 62.35,128.86 62.36,128.76 62.46,128.37 62.86,128.37 63.08,128.37 63.24,128.2 63.41,128.2 63.65,127.97 63.65,127.71 63.4,127.46 62.8,127.46 62.48,127.78 62.29,127.78 61.96,128.11 60.5,128.11 60.18,128.43 58.06,128.43 57.51,127.88 56.94,127.88 56.86,127.96 56.86,128.47 56.93,128.55 57.4,128.55 57.78,128.93 57.78,128.96 57.78,128.96 57.78,129.39 57.86,129.46 59.01,129.46
+1.35V_MEM on TOP (solid shape): outline of 15684 points within 87.19,11.42 156.34,91.69
+1.35V_MEM on BOTTOM (solid shape): 122.84,29.78 122.9,29.86 123,29.85 123.11,29.79 123.24,29.78 123.26,29.77 123.28,29.76 123.51,29.54 123.51,29 122.73,28.22 122.73,28.2 122.68,28.14 122.64,28.12 122.6,28.14 122.55,28.2 122.84,28.49
+1.35V_MEM on BOTTOM (solid shape): 121.86,29.87 121.92,29.78 121.92,29.37 120.93,28.38 120.93,28.22 120.93,28.2 120.84,28.15 120.75,28.2 120.75,28.22 120.75,29.06 121.46,29.77 121.48,29.78 121.49,29.78 121.63,29.79 121.75,29.86
+1.35V_MEM on BOTTOM (solid shape): 118.74,21.15 118.83,21.1 118.83,21.08 118.83,20.74 117.91,19.81 117.89,19.81 117.88,19.81 117.73,19.79 117.61,19.72 117.5,19.7 117.44,19.79 117.44,20.17 117.87,20.61 118.11,20.61 118.54,21.04 118.61,21.07 118.66,21.12
+1.35V_MEM on BOTTOM (solid shape): 125.96,29.75 126.01,29.84 126.12,29.84 126.23,29.79 126.35,29.78 126.36,29.78 126.38,29.77 126.68,29.47 126.68,28.61 126.33,28.26 126.33,28.22 126.33,28.2 126.24,28.15 126.15,28.2 126.15,28.22 126.15,29.02 125.96,29.21
+1.35V_MEM on BOTTOM (solid shape): 126.45,37.99 126.49,37.91 126.49,37.67 126.73,37.43 126.73,37.16 126.72,37.12 126.68,37.1 126.3,37.1 126.03,36.84 126.03,36.42 126.03,36.4 125.94,36.35 125.85,36.4 125.85,36.42 125.85,37.66 126.16,37.97 126.18,37.98 126.19,37.98 126.27,37.98 126.35,38
+1.35V_MEM on BOTTOM (solid shape): 129.02,16.15 129.08,16.06 129.08,15.72 128.77,15.41 128.45,15.41 128.13,15.09 128.13,15.02 128.13,15 128.04,14.95 127.95,15 127.95,15.02 127.95,15.56 128.48,16.09 128.51,16.09 128.52,16.08 128.73,16.05 128.91,16.14
+1.35V_MEM on BOTTOM (solid shape): 129.88,40.43 129.92,40.42 129.94,40.38 129.94,40.21 130.22,39.93 130.23,39.91 130.23,39.89 130.43,39.53 130.83,39.59 130.94,39.61 131,39.52 131,38.67 130.94,38.57 130.83,38.59 130.43,38.65 130.23,38.3 130.23,38.29 130.23,38.27 129.9,37.94 129.9,37.33 130.19,37.05 130.19,36.89 130.18,36.89 129.88,36.89 129.63,36.64 129.63,36.42 129.63,36.4 129.54,36.35 129.45,36.4 129.45,36.42 129.45,36.94 129.64,37.14 129.64,40.38 129.66,40.42 129.69,40.43
+1.35V_MEM on BOTTOM (solid shape): 128.29,40.29 128.33,40.27 128.35,40.24 128.35,39.87 128.57,39.64 128.63,39.64 128.65,39.64 128.66,39.63 128.86,39.51 129.08,39.53 129.18,39.52 129.22,39.44 129.22,38.75 129.18,38.66 129.08,38.66 128.73,38.62 128.58,38.3 128.58,38.29 128.58,38.27 128.08,37.77 128.08,36.6 127.95,36.47 127.94,36.46 127.85,36.42 127.78,36.34 127.74,36.32 127.7,36.34 127.68,36.37 127.65,36.4 127.65,36.41 127.9,36.66 127.9,37.9 127.63,38.17 127.46,38.17 127.42,38.19 127.41,38.22 127.41,38.69 127.42,38.72 127.46,38.74 127.64,38.74 128,39.11 128,40.24 128.02,40.27 128.05,40.29
+1.35V_MEM on BOTTOM (solid shape): 130.97,17.56 131,17.48 131,15.68 131,15.67 130.98,15.57 131,15.46 131,15.46 131,12.63 130.43,12.06 128.51,12.06 128.42,12.12 128.44,12.23 128.56,12.47 128.49,12.72 128.46,12.8 128.51,12.87 128.61,12.98 128.65,13.12 128.65,14.78 128.64,14.82 128.63,14.86 128.65,14.95 128.73,14.99 128.95,14.99 129.16,15.2 129.27,15.22 129.33,15.13 129.33,15.02 129.33,15 129.26,14.89 129.23,14.78 129.23,13.12 129.43,12.84 129.77,12.92 129.84,12.95 129.91,12.92 130.25,12.84 130.45,13.12 130.45,14.78 130.25,15.06 129.91,14.98 129.84,14.95 129.75,15 129.75,15.09 130,15.34 130,16.82 130.75,17.57 130.77,17.57 130.83,17.57 130.88,17.58
+1.35V_MEM on BOTTOM (solid shape): outline of 169 points within 116.55,85.04 138.84,89.19
+1.35V_MEM on BOTTOM (solid shape): outline of 4647 points within 113.16,12.06 131,42.03
+1.35V_MEM on IN1 (solid shape): outline of 888 points within 116.87,84.66 138.45,89.64
+1.35V_MEM on IN2 (solid shape): outline of 1017 points within 115.82,84.95 138.33,89.38
+1.35V_MEM on IN3 (solid shape): outline of 8310 points within 116.47,60.58 138.2,89.45
+1.35V_MEM on VCC: 112.46,25.45 112.46,52.46 113.16,53.16 113.16,64.02 119.76,70.62 119.76,74.56 120.27,75.07 120.27,84.76 136.53,84.76 136.53,74.81 137.16,74.18 137.16,44.93 132.84,40.61 132.84,34.05 133.48,33.41 133.48,25.45
+1.35V_MEM_GFX on TOP (solid shape): 87.31,120.2 87.31,116.96 87.25,116.89 86.68,116.89 86.62,116.96 86.62,117.72 86.43,117.91 85.09,117.91 84.9,118.1 84.9,119.94 85.28,120.32 87.19,120.32
+1.35V_MEM_GFX on TOP (solid shape): 83.94,92.35 84.2,92.17 84.47,92.35 84.48,92.38 86.93,92.38 87.19,92.13 87.19,90.41 87.19,88.95 86.68,88.45 85.16,88.45 84.78,88.07 84.78,87.87 84.71,87.81 84.14,87.81 83.95,88 83.95,89.08 83.51,89.53 83.44,89.53 83.44,89.83 83.38,89.83 83.38,90.1 83.22,90.4 82.88,90.46 82.88,90.46 82.7,90.46 82.49,90.67 82.49,90.92 82.3,91.11 82.07,91.11 82.03,91.13 81.98,91.18 81.98,92.07 82.17,92.26 82.42,92.26 82.55,92.38 83.93,92.38
+1.35V_MEM_GFX on IN2 (solid shape): outline of 13863 points within 52.48,89.91 94.56,130.81
+1.35V_MEM_GFX on VCC: 83.1,89.84 79.99,92.95 56.49,92.95 56.45,93 56.45,129.59 75.69,129.59 75.69,129.49 77.05,128.13 84.48,128.13 84.9,127.71 84.9,117.17 91.95,110.12 91.95,90.27 91.53,89.84
+1.35V_MEN_P on TOP (solid shape): 172.48,86.33 172.48,85.93 171.95,85.93 171.95,85.5 172.48,85.5 172.48,85.1 172.4,85.02 171.2,85.02 171.01,85.21 171.01,86.35 171.2,86.54 172.28,86.54
+1.35V_MEN_P on TOP (solid shape): 164.32,73.1 164.32,64.23 157.99,57.9 157.99,55.04 157.58,54.64 156.41,54.64 153.97,57.08 153.62,56.72 153.21,57.13 153.57,57.48 153.58,57.5 153.09,57.99 153.07,57.98 152.72,57.63 152.37,57.98 152.72,58.33 152.74,58.35 152.24,58.84 152.08,58.69 151.87,58.47 151.46,58.88 151.82,59.23 150.29,60.76 149.94,60.41 149.53,60.81 149.9,61.18 149.9,61.18 149.4,61.68 149.39,61.66 149.03,61.31 148.68,61.66 149.04,62.01 149.05,62.03 148.56,62.53 148.54,62.51 148.18,62.16 147.79,62.55 147.79,65.4 154.33,71.94 155.81,73.42 156.61,74.22 163.2,74.22
+1.35V_MEN_P on BOTTOM (solid shape): 164.32,83.07 164.32,79.81 163.33,78.81 163.33,70.1 162.43,69.21 157.34,69.21 156.69,69.86 156.69,77.66 154.33,80.02 153.15,80.02 152.67,80.5 152.67,83.27 152.9,83.49 163.9,83.49
+1.35V_MEN_P on IN3 (solid shape): 164.41,74.6 164.41,70.09 163.52,69.21 158.9,69.21 158.55,69.56 158.55,74.54 159.18,75.17 163.83,75.17
+1.35V_MEN_P on IN3 (solid shape): 172.85,86.16 172.85,83.81 172.66,83.62 171.45,83.62 171.01,84.06 171.01,86.23 171.2,86.42 172.59,86.42
+3.3V_ALW on TOP (solid shape): 192.08,57.33 192.08,55.99 191.9,55.81 190.23,55.81 189.23,56.81 189.23,58.05 189.38,58.19 191.22,58.19
+3.3V_ALW on TOP (solid shape): 196.85,71.49 196.85,70.03 196.66,69.84 195.58,69.84 195.52,69.9 195.52,71.55 195.58,71.62 196.72,71.62
+3.3V_ALW on TOP (solid shape): 196.98,170.19 196.98,169.28 196.81,169.11 194.62,169.11 194.44,169.29 194.44,170.06 194.93,170.55 196.62,170.55
+3.3V_ALW on TOP (solid shape): 196.46,74.59 198.06,74.59 198.17,74.48 198.17,73.94 197.72,73.48 195.1,73.48 194.76,73.83 194.76,74.81 194.85,74.89 196.15,74.89
+3.3V_ALW on TOP (solid shape): 228.72,73.35 228.72,72.14 228.32,71.75 227.33,71.75 227.27,71.81 227.27,73.07 227.65,73.45 228.61,73.45
+3.3V_ALW on TOP (solid shape): 245.81,149.29 245.81,148.14 245.43,147.76 244.38,147.76 244.26,147.88 244.26,149.11 244.49,149.34 245.76,149.34
+3.3V_ALW on TOP (solid shape): 248.49,148.99 248.49,147.96 248.26,147.73 247.39,147.73 247.2,147.92 247.2,149.31 247.25,149.37 248.11,149.37
+3.3V_ALW on TOP (solid shape): 190.44,169.05 190.44,168.41 190.17,168.14 190.17,168.12 190.16,168.11 190.16,167.06 190.03,166.94 189.23,166.94 189.14,167.02 189.14,168.93 189.38,169.17 190.32,169.17
+3.3V_ALW on TOP (solid shape): 221.74,130.55 221.74,128.7 221.41,128.37 220.32,128.37 220.25,128.43 220.25,128.96 219.97,129.25 219.97,130.67 220.09,130.8 221.49,130.8
+3.3V_ALW on TOP (solid shape): 264.56,176.04 264.56,174.74 264.46,174.64 264.46,174.44 264.45,174.44 264.45,174.08 264.29,173.92 263.02,173.92 262.76,174.17 262.76,175.69 263.16,176.09 264.51,176.09
+3.3V_ALW on TOP (solid shape): 199.92,101.65 199.92,100.31 200.35,99.87 200.75,99.87 200.9,99.72 200.9,98.63 200.59,98.32 199.36,98.32 199.29,98.39 199.29,101.64 199.41,101.76 199.81,101.76
+3.3V_ALW on TOP (solid shape): 234.95,76.13 234.95,74.67 235.21,74.41 235.59,74.41 235.73,74.27 235.73,70.47 235.57,70.31 233.84,70.31 232.95,71.2 232.95,76.03 233.17,76.25 234.82,76.25
+3.3V_ALW on TOP (solid shape): 221.62,70.29 221.62,67.98 221.44,67.81 220.38,67.81 220.21,67.98 220.21,68.35 220.74,68.35 220.74,68.79 220.21,68.79 220.21,69.18 219.72,69.68 219.72,70.54 219.85,70.67 221.24,70.67
+3.3V_ALW on TOP (solid shape): 228.38,70.05 229.14,70.05 229.29,69.91 229.29,69.66 228.31,68.69 227.88,68.69 227.27,69.3 227.27,70.29 227.33,70.35 228.09,70.35
+3.3V_ALW on TOP (solid shape): 267.66,175.89 267.66,174.46 267.64,174.44 267.64,174.15 267.46,173.98 266.32,173.98 266.26,174.04 266.26,174.35 265.99,174.63 265.99,175.24 265.94,175.28 265.94,176.06 265.98,176.1 267.45,176.1
+3.3V_ALW on TOP (solid shape): 210.31,93.02 210.31,92.57 210.19,92.45 209.93,92.45 209.68,92.19 209.68,91.94 208.78,91.04 206.76,91.04 206.65,91.15 206.65,92.21 207.71,93.27 208.03,93.27 208.04,93.27 210.06,93.27
+3.3V_ALW on TOP (solid shape): 207.58,58.42 207.58,56.68 207.02,56.12 205.42,56.12 205.23,56.31 205.23,56.97 205.77,56.97 205.77,57.52 205.23,57.52 205.23,57.77 205.78,57.77 205.78,58.33 205.23,58.33 205.23,58.85 205.36,58.98 207.01,58.98
+3.3V_ALW on TOP (solid shape): 208.92,70.09 208.92,69.33 209.41,68.84 210.75,68.84 210.89,68.7 210.89,68.14 210.84,68.09 210.08,68.09 209.6,67.61 207.41,67.61 206.98,68.05 206.45,68.05 206.37,68.13 206.37,70.1 206.44,70.17 208.84,70.17
