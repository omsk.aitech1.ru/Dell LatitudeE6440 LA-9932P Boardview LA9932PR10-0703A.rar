# Allegro board LA9932PR10-0703A.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
ACES_50228-0067N-001_6P
  oval 0.61x1.549 smd: 1(0,0) 2(-1,0) 3(-2,0) 4(-3,0) 5(-4,0) 6(-5,0)
  rect 1.194x1.803 smd: 7(1.3,2.525) 8(-6.3,2.525)
ACES_50273-0020N-001_2P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(-2.55,-2.9) 4(3.8,-2.9)
ACES_50273-0040N-001_4P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0)
  rect 2.108x2.997 smd: 5(-2.55,-2.9) 6(6.3,-2.9)
ACES_59003-04006-001_40P
  round 0.889 hole 0.889 unplated: (-20.25,2.125) (0.75,2.125)
  oval 0.254x1.143 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0) 21(-10,0) 22(-10.5,0) 23(-11,0) 24(-11.5,0) 25(-12,0) 26(-12.5,0) 27(-13,0) 28(-13.5,0) 29(-14,0) 30(-14.5,0) 31(-15,0) 32(-15.5,0) 33(-16,0) 34(-16.5,0) 35(-17,0) 36(-17.5,0) 37(-18,0) 38(-18.5,0) 39(-19,0) 40(-19.5,0)
  rect 1.499x2.997 smd: 41(-22,2.125) 42(2.5,2.125)
  rect 2.794x1.499 smd: 43(-15.45,4.175) 44(-4.05,4.175)
ALC3226-CG_QFN48_7X7
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 25(5.5,7.1) 26(5,7.1) 27(4.5,7.1) 28(4,7.1) 29(3.5,7.1) 30(3,7.1) 31(2.5,7.1) 32(2,7.1) 33(1.5,7.1) 34(1,7.1) 35(0.5,7.1) 36(0,7.1)
  oval 0.889x0.254 smd: 13(6.3,0.8) 14(6.3,1.3) 15(6.3,1.8) 16(6.3,2.3) 17(6.3,2.8) 18(6.3,3.3) 19(6.3,3.8) 20(6.3,4.3) 21(6.3,4.8) 22(6.3,5.3) 23(6.3,5.8) 24(6.3,6.3) 37(-0.8,6.3) 38(-0.8,5.8) 39(-0.8,5.3) 40(-0.8,4.8) 41(-0.8,4.3) 42(-0.8,3.8) 43(-0.8,3.3) 44(-0.8,2.8) 45(-0.8,2.3) 46(-0.8,1.8) 47(-0.8,1.3) 48(-0.8,0.8)
  rect 5.512x5.512 smd: 49(2.75,3.55)
ALPS_SCDACA0101_19P
  round 1.295 hole 1.295 unplated: (-17,-26.3) (3,-26.3)
  oval 0.711x1.397 smd: 1(0,0) 2(-1.5,0) 4(-9,0) 5(-10.5,0) 6(-13.5,0) 7(-15,0) 8(-16.5,0) 9(1.5,0) 17(-12,0) 18(-18,0)
  oval 0.61x1.397 smd: 3(-4.45,0)
  oval 1.803x1.575 smd: 10(-12.95,-26.525) 13(-2.45,-26.525)
  oval 0.787x1.27 smd: 11(-2.575,-20.005) 12(-4.075,-20.005) 14(-8.55,-20.005) 15(-10.075,-20.005) 16(-11.575,-20.005)
  oval 1.092x1.245 smd: 19(4.8,0.375)
  rect 0.991x1.245 smd: 20(-5.7,0.375)
  rect 1.092x1.245 smd: 21(-19.25,0.375)
  rect 0.991x1.803 smd: 22(6.75,-14.6) 23(6.75,-27.55) 24(-20.75,-21.1) 25(-20.75,-27.55)
AO4354_SOIC-8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
APL3512ABI-TRG_SOT23-5
  oval 0.61x1.041 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.7) 5(0,2.7)
AT97SC3204-X2A14-AB_TSSOP28
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(5.2,0) 10(5.85,0) 11(6.5,0) 12(7.15,0) 13(7.8,0) 14(8.45,0) 15(8.45,5.8) 16(7.8,5.8) 17(7.15,5.8) 18(6.5,5.8) 19(5.85,5.8) 20(5.2,5.8) 21(4.55,5.8) 22(3.9,5.8) 23(3.25,5.8) 24(2.6,5.8) 25(1.95,5.8) 26(1.3,5.8) 27(0.65,5.8) 28(0,5.8)
BAS40-05W_SC70-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
BAT54CW_SOT323-3
  oval 0.61x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
BELLW_80003-1121_52P
  round 1.6 hole 1.6 unplated: (-0.7,4.1)
  round 1.092 hole 1.092 unplated: (24.3,4.1)
  oval 0.61x2.007 smd: 1(0,0) 2(0.4,8.2) 3(0.8,0) 4(1.2,8.2) 5(1.6,0) 6(2,8.2) 7(2.4,0) 8(2.8,8.2) 9(3.2,0) 10(3.6,8.2) 11(4,0) 12(4.4,8.2) 13(4.8,0) 14(5.2,8.2) 15(5.6,0) 16(6,8.2) 17(9.6,0) 18(10,8.2) 19(10.4,0) 20(10.8,8.2) 21(11.2,0) 22(11.6,8.2) 23(12,0) 24(12.4,8.2) 25(12.8,0) 26(13.2,8.2) 27(13.6,0) 28(14,8.2) 29(14.4,0) 30(14.8,8.2) 31(15.2,0) 32(15.6,8.2) 33(16,0) 34(16.4,8.2) 35(16.8,0) 36(17.2,8.2) 37(17.6,0) 38(18,8.2) 39(18.4,0) 40(18.8,8.2) 41(19.2,0) 42(19.6,8.2) 43(20,0) 44(20.4,8.2) 45(20.8,0) 46(21.2,8.2) 47(21.6,0) 48(22,8.2) 49(22.4,0) 50(22.8,8.2) 51(23.2,0) 52(23.6,8.2)
  rect 2.311x3.2 smd: 53(-2.85,0.6) 54(26.45,0.6)
BELLW_80003-8041_52P
  round 1.6 hole 1.6 unplated: (-0.7,4.1)
  round 1.092 hole 1.092 unplated: (24.3,4.1)
  oval 0.61x2.007 smd: 1(0,0) 2(0.4,8.2) 3(0.8,0) 4(1.2,8.2) 5(1.6,0) 6(2,8.2) 7(2.4,0) 8(2.8,8.2) 9(3.2,0) 10(3.6,8.2) 11(4,0) 12(4.4,8.2) 13(4.8,0) 14(5.2,8.2) 15(5.6,0) 16(6,8.2) 17(9.6,0) 18(10,8.2) 19(10.4,0) 20(10.8,8.2) 21(11.2,0) 22(11.6,8.2) 23(12,0) 24(12.4,8.2) 25(12.8,0) 26(13.2,8.2) 27(13.6,0) 28(14,8.2) 29(14.4,0) 30(14.8,8.2) 31(15.2,0) 32(15.6,8.2) 33(16,0) 34(16.4,8.2) 35(16.8,0) 36(17.2,8.2) 37(17.6,0) 38(18,8.2) 39(18.4,0) 40(18.8,8.2) 41(19.2,0) 42(19.6,8.2) 43(20,0) 44(20.4,8.2) 45(20.8,0) 46(21.2,8.2) 47(21.6,0) 48(22,8.2) 49(22.4,0) 50(22.8,8.2) 51(23.2,0) 52(23.6,8.2)
  rect 2.311x3.2 smd: 53(-2.85,0.6) 54(26.45,0.6)
BQ24738RGRR_QFN20_3P5X3P5
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 11(2,3.45) 12(1.5,3.45) 13(1,3.45) 14(0.5,3.45) 15(0,3.45)
  oval 1.041x0.254 smd: 6(2.725,0.725) 7(2.725,1.225) 8(2.725,1.725) 9(2.725,2.225) 10(2.725,2.725) 16(-0.725,2.725) 17(-0.725,2.225) 18(-0.725,1.725) 19(-0.725,1.225) 20(-0.725,0.725)
  rect 2.057x2.057 smd: 21(1,1.725)
BSS138W-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
C_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1808
  rect 1.041x2.311 smd: 1(0,0) 2(4.35,0)
C_APXK2R5ARA331MF451
  oval 3.15x1.6 smd: 1(0,0) 2(-5.05,0)
C_APXK6R3ARA221MF451
  oval 3.15x1.6 smd: 1(0,0) 2(5.05,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_D1
  rect 1.803x2.794 smd: 1(0,0) 2(6.5,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_EEEFK1E101YP
  oval 3.2x1.6 smd: 1(0,0) 2(5,0)
C_SX
  rect 2.388x2.794 smd: 1(0,0) 2(6,0)
CD3301RHHR_QFN36_6X6
  oval 0.254x1.194 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 19(4,5.8) 20(3.5,5.8) 21(3,5.8) 22(2.5,5.8) 23(2,5.8) 24(1.5,5.8) 25(1,5.8) 26(0.5,5.8) 27(0,5.8)
  oval 1.194x0.254 smd: 10(4.9,0.9) 11(4.9,1.4) 12(4.9,1.9) 13(4.9,2.4) 14(4.9,2.9) 15(4.9,3.4) 16(4.9,3.9) 17(4.9,4.4) 18(4.9,4.9) 28(-0.9,4.9) 29(-0.9,4.4) 30(-0.9,3.9) 31(-0.9,3.4) 32(-0.9,2.9) 33(-0.9,2.4) 34(-0.9,1.9) 35(-0.9,1.4) 36(-0.9,0.9)
  rect 4.089x4.089 smd: 37(2,2.9)
CONCR_099ATAC19NBLCNF_19P
  round 0.813 hole 0.559: 1(0,0) 2(0.5,1.55) 3(1,0) 4(1.5,1.55) 5(2,0) 6(2.5,1.55) 7(3,0) 8(3.5,1.55) 9(4,0) 10(4.5,1.55) 11(5,0) 12(5.5,1.55) 13(6,0) 14(6.5,1.55) 15(7,0) 16(7.5,1.55) 17(8,0) 18(8.5,1.55) 19(9,0)
  oval 1.499x2.21 hole 0.889x1.6: 20(-2.75,1.7) 21(-4.65,-6.5) 22(11.75,1.7) 23(13.65,-7.75)
CSD86350Q5D_SON8
  oval 2.032x0.889 smd: 1(0,0)
  oval 0.711x0.889 smd: 2(1.98,0) 3(3.3,0) 4(3.3,5.39) 5(1.98,5.39) 6(0.66,5.39) 7(-0.66,5.39)
  custom 0.883x0.883 smd: 8(1.32,2.695)
CYNTE_PCMB053T-1R0MS_2P
  rect 1.905x2.794 smd: 1(0,0) 2(4.1,0)
CYNTE_PCMB063T-2R2MS_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
CYNTE_PCMB063T-3R3MS_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
CYNTE_PH041H-1R0MS_2P
  rect 1.295x3.81 smd: 1(0,0) 2(3.1,0)
DH82LPMS-QCG1-B0_FCBGA_695P
  round 0.483 smd: A2(0.624,0) A44(18.101,0) B1(0,-0.624) B45(18.625,-0.524) BD1(0,-18.101) BD45(18.625,-18.101) BE2(0.524,-18.625) BE44(18.101,-18.625)
  round 0.356 smd: A4(1.217,0) A5(1.81,0) A41(16.915,0) A43(17.508,0) B2(0.603,-0.603) B44(18.022,-0.603) BA1(0,-16.915) BA45(18.625,-16.915) BC1(0,-17.508) BC45(18.625,-17.508) BD2(0.603,-18.022) BD44(18.022,-18.022) BE3(1.117,-18.625) BE5(1.71,-18.625) BE41(16.915,-18.625) BE43(17.508,-18.625) C45(18.625,-1.117) D1(0,-1.217) E1(0,-1.81) E45(18.625,-1.71)
  round 0.33 smd: A6(2.483,0) A40(16.242,0) AY1(0,-16.242) AY45(18.625,-16.242) B4(1.315,-0.586) B42(17.233,-0.637) BA2(0.551,-16.664) BB2(0.563,-17.31) BB44(17.988,-17.233) BD4(1.391,-17.988) BD41(16.664,-18.074) BD42(17.31,-18.061) BE6(2.383,-18.625) BE40(16.242,-18.625) D2(0.637,-1.391) D44(18.061,-1.315) E44(18.074,-1.96) F1(0,-2.483) F45(18.625,-2.383)
  round 0.305 smd: A8(3.216,0) A10(4.029,0) A12(4.842,0) A14(5.655,0) A16(6.468,0) A18(7.28,0) A20(8.093,0) A22(8.906,0) A24(9.719,0) A26(10.532,0) A28(11.344,0) A30(12.157,0) A32(12.97,0) A34(13.783,0) A36(14.596,0) A38(15.408,0) AA2(0.452,-8.478) AA4(1.336,-8.5) AA14(5.515,-8.827) AA16(6.328,-8.827) AA18(7.141,-8.827) AA20(7.954,-8.827) AA22(8.766,-8.827) AA24(9.579,-8.827) AA26(10.392,-8.827) AA28(11.205,-8.827) AA30(12.018,-8.827) AA32(12.83,-8.827) AA42(17.289,-8.5) AA44(18.173,-8.521) AB1(0,-8.906) AB3(0.904,-8.906) AB6(1.934,-9.008) AB7(2.531,-9.008) AB8(3.128,-9.008) AB10(3.724,-9.008) AB11(4.321,-9.008) AB12(4.918,-9.008) AB34(13.707,-9.008) AB35(14.304,-9.008) AB36(14.9,-9.008) AB38(15.497,-9.008) AB39(16.094,-9.008) AB40(16.691,-9.008) AB43(17.721,-8.906) AB45(18.625,-8.906) AC2(0.472,-9.312) AC44(18.152,-9.312) AD1(0,-9.719) AD3(0.904,-9.719) AD6(1.934,-9.617) AD7(2.531,-9.617) AD8(3.128,-9.617) AD10(3.724,-9.617) AD11(4.321,-9.617) AD12(4.918,-9.617) AD14(5.515,-9.488) AD16(6.328,-9.488) AD18(7.141,-9.488) AD20(7.954,-9.488) AD22(8.766,-9.488) AD24(9.579,-9.488) AD26(10.392,-9.488) AD28(11.205,-9.488) AD30(12.018,-9.488) AD32(12.83,-9.488) AD34(13.707,-9.617) AD35(14.304,-9.617) AD36(14.9,-9.617) AD38(15.497,-9.617) AD39(16.094,-9.617) AD40(16.691,-9.617) AD43(17.721,-9.719) AD45(18.625,-9.719) AE2(0.452,-10.103) AE4(1.336,-10.125) AE14(5.515,-10.148) AE16(6.328,-10.148) AE18(7.141,-10.148) AE20(7.954,-10.148) AE22(8.766,-10.148) AE24(9.579,-10.148) AE26(10.392,-10.148) AE28(11.205,-10.148) AE30(12.018,-10.148) AE32(12.83,-10.148) AE42(17.289,-10.125) AE44(18.173,-10.147) AF1(0,-10.532) AF3(0.904,-10.532) AF6(1.934,-10.595) AF7(2.531,-10.595) AF8(3.128,-10.595) AF10(3.724,-10.595) AF11(4.321,-10.595) AF12(4.918,-10.595) AF34(13.707,-10.595) AF35(14.304,-10.595) AF36(14.9,-10.595) AF38(15.497,-10.595) AF39(16.094,-10.595) AF40(16.691,-10.595) AF43(17.721,-10.532) AF45(18.625,-10.532) AG2(0.472,-10.938) AG14(5.515,-10.808) AG16(6.328,-10.808) AG18(7.141,-10.808) AG20(7.954,-10.808) AG22(8.766,-10.808) AG24(9.579,-10.808) AG26(10.392,-10.808) AG28(11.205,-10.808) AG30(12.018,-10.808) AG32(12.83,-10.808) AG44(18.152,-10.938) AH1(0,-11.344) AH3(0.904,-11.344) AH43(17.721,-11.344) AH45(18.625,-11.344) AJ2(0.452,-11.729) AJ4(1.336,-11.751) AJ6(1.934,-11.573) AJ7(2.531,-11.573) AJ8(3.128,-11.573) AJ10(3.724,-11.573) AJ11(4.321,-11.573) AJ12(4.918,-11.573) AJ14(5.515,-11.469) AJ16(6.328,-11.469) AJ18(7.141,-11.469) AJ20(7.954,-11.469) AJ22(8.766,-11.469) AJ24(9.579,-11.469) AJ26(10.392,-11.469) AJ28(11.205,-11.469) AJ30(12.018,-11.469) AJ32(12.83,-11.469) AJ34(13.707,-11.573) AJ35(14.304,-11.573) AJ36(14.9,-11.573) AJ38(15.497,-11.573) AJ39(16.094,-11.573) AJ40(16.691,-11.573) AJ42(17.289,-11.751) AJ44(18.173,-11.773) AK1(0,-12.157) AK3(0.904,-12.157) AK14(5.515,-12.129) AK16(6.328,-12.129) AK18(7.141,-12.129) AK20(7.954,-12.129) AK22(8.766,-12.129) AK24(9.579,-12.129) AK26(10.392,-12.129) AK28(11.205,-12.129) AK30(12.018,-12.129) AK32(12.83,-12.129) AK43(17.721,-12.157) AK45(18.625,-12.157) AL2(0.472,-12.564) AL6(1.934,-12.551) AL7(2.531,-12.551) AL8(3.128,-12.551) AL10(3.724,-12.551) AL11(4.321,-12.551) AL12(4.918,-12.551) AL34(13.707,-12.551) AL35(14.304,-12.551) AL36(14.9,-12.551) AL38(15.497,-12.551) AL39(16.094,-12.551) AL40(16.691,-12.551) AL44(18.152,-12.564) AM1(0,-12.97) AM3(0.904,-12.97) AM14(5.515,-12.79) AM16(6.328,-12.79) AM18(7.141,-12.79) AM20(7.954,-12.79) AM22(8.766,-12.79) AM24(9.579,-12.79) AM26(10.392,-12.79) AM28(11.205,-12.79) AM30(12.018,-12.79) AM32(12.83,-12.79) AM43(17.721,-12.97) AM45(18.625,-12.97) AN2(0.452,-13.355) AN4(1.336,-13.376) AN6(1.934,-13.529) AN7(2.531,-13.529) AN8(3.128,-13.529) AN10(3.724,-13.529) AN11(4.321,-13.529) AN34(13.656,-13.529) AN35(14.304,-13.529) AN36(14.9,-13.529) AN38(15.497,-13.529) AN39(16.094,-13.529) AN40(16.691,-13.529) AN42(17.289,-13.376) AN44(18.173,-13.398) AP1(0,-13.783) AP3(0.904,-13.783) AP13(5.096,-13.656) AP15(6.074,-13.707) AP17(7.052,-13.707) AP20(8.03,-13.707) AP22(9.008,-13.707) AP24(9.617,-13.707) AP26(10.595,-13.707) AP29(11.573,-13.707) AP31(12.551,-13.707) AP43(17.721,-13.783) AP45(18.625,-13.783) AR2(0.472,-14.189) AR13(5.096,-14.304) AR15(6.074,-14.304) AR17(7.052,-14.304) AR20(8.03,-14.304) AR22(9.008,-14.304) AR24(9.617,-14.304) AR26(10.595,-14.304) AR29(11.573,-14.304) AR31(12.551,-14.304) AR33(13.529,-14.304) AR44(18.152,-14.189) AT1(0,-14.596) AT3(0.904,-14.596) AT6(1.934,-14.507) AT7(2.531,-14.507) AT8(3.128,-14.507) AT10(4.118,-14.9) AT13(5.096,-14.9) AT15(6.074,-14.9) AT17(7.052,-14.9) AT20(8.03,-14.9) AT22(9.008,-14.9) AT24(9.617,-14.9) AT26(10.595,-14.9) AT29(11.573,-14.9) AT31(12.551,-14.9) AT33(13.529,-14.9) AT36(14.9,-14.507) AT38(15.497,-14.507) AT39(16.094,-14.507) AT40(16.691,-14.507) AT43(17.721,-14.596) AT45(18.625,-14.596) AU2(0.452,-14.98) AU4(1.336,-15.002) AU42(17.289,-15.002) AU44(18.173,-15.024) AV1(0,-15.408) AV3(0.904,-15.408) AV6(1.934,-15.485) AV7(2.531,-15.485) AV10(4.118,-15.497) AV13(5.096,-15.497) AV15(6.074,-15.497) AV17(7.052,-15.497) AV20(8.03,-15.497) AV22(9.008,-15.497) AV24(9.617,-15.497) AV26(10.595,-15.497) AV29(11.573,-15.497) AV31(12.551,-15.497) AV33(13.529,-15.497) AV36(14.507,-15.497) AV40(16.691,-15.485) AV43(17.721,-15.408) AV45(18.625,-15.408) AW2(0.472,-15.815) AW8(3.14,-16.094) AW10(4.118,-16.094) AW13(5.096,-16.094) AW15(6.074,-16.094) AW17(7.052,-16.094) AW20(8.03,-16.094) AW22(9.008,-16.094) AW24(9.617,-16.094) AW26(10.595,-16.094) AW29(11.573,-16.094) AW31(12.551,-16.094) AW33(13.529,-16.094) AW36(14.507,-16.094) AW38(15.485,-16.094) AW40(17.123,-16.221) AW44(18.152,-15.815) AY3(0.978,-16.221) AY5(1.743,-16.051) AY7(2.404,-17.123) AY8(3.14,-16.691) AY10(4.118,-16.691) AY13(5.096,-16.691) AY15(6.074,-16.691) AY17(7.052,-16.691) AY20(8.03,-16.691) AY22(9.008,-16.691) AY24(9.617,-16.691) AY26(10.595,-16.691) AY29(11.573,-16.691) AY31(12.551,-16.691) AY33(13.529,-16.691) AY36(14.507,-16.691) AY38(15.485,-16.691) AY43(17.721,-16.221) B5(1.96,-0.586) B7(2.739,-0.552) B9(3.645,-0.452) B11(4.436,-0.472) B13(5.27,-0.452) B15(6.061,-0.472) B17(6.896,-0.452) B19(7.687,-0.472) B21(8.521,-0.452) B23(9.312,-0.472) B25(10.147,-0.452) B27(10.938,-0.472) B29(11.773,-0.452) B31(12.564,-0.472) B33(13.398,-0.452) B35(14.189,-0.472) B37(15.024,-0.452) B39(15.815,-0.472) BA40(16.051,-16.882) BB4(1.391,-17.302) BB9(3.623,-17.289) BB13(5.248,-17.289) BB17(6.874,-17.289) BB21(8.5,-17.289) BB25(10.125,-17.289) BB29(11.751,-17.289) BB33(13.376,-17.289) BB37(15.002,-17.289) BB42(17.302,-17.233) BC6(2.404,-17.721) BC8(3.216,-17.721) BC10(4.029,-17.721) BC12(4.842,-17.721) BC14(5.655,-17.721) BC16(6.468,-17.721) BC18(7.28,-17.721) BC20(8.093,-17.721) BC22(8.906,-17.721) BC24(9.719,-17.721) BC26(10.532,-17.721) BC28(11.344,-17.721) BC30(12.157,-17.721) BC32(12.97,-17.721) BC34(13.783,-17.721) BC36(14.596,-17.721) BC38(15.408,-17.721) BC40(16.221,-17.647) BD7(2.81,-18.152) BD9(3.601,-18.173) BD11(4.436,-18.152) BD13(5.227,-18.173) BD15(6.061,-18.152) BD17(6.852,-18.173) BD19(7.687,-18.152) BD21(8.478,-18.173) BD23(9.312,-18.152) BD25(10.103,-18.173) BD27(10.938,-18.152) BD29(11.729,-18.173) BD31(12.564,-18.152) BD33(13.355,-18.173) BD35(14.189,-18.152) BD37(14.98,-18.173) BD39(15.815,-18.152) BE8(3.216,-18.625) BE10(4.029,-18.625) BE12(4.842,-18.625) BE14(5.655,-18.625) BE16(6.468,-18.625) BE18(7.28,-18.625) BE20(8.093,-18.625) BE22(8.906,-18.625) BE24(9.719,-18.625) BE26(10.532,-18.625) BE28(11.344,-18.625) BE30(12.157,-18.625) BE32(12.97,-18.625) BE34(13.783,-18.625) BE36(14.596,-18.625) BE38(15.408,-18.625) C6(2.37,-1.017) C8(3.216,-0.904) C10(4.029,-0.904) C12(4.842,-0.904) C14(5.655,-0.904) C16(6.468,-0.904) C18(7.28,-0.904) C20(8.093,-0.904) C22(8.906,-0.904) C24(9.719,-0.904) C26(10.532,-0.904) C28(11.344,-0.904) C30(12.157,-0.904) C32(12.97,-0.904) C34(13.783,-0.904) C36(14.596,-0.904) C38(15.408,-0.904) C40(16.221,-0.904) D4(1.323,-1.391) D9(3.623,-1.336) D13(5.248,-1.336) D17(6.874,-1.336) D21(8.5,-1.336) D25(10.125,-1.336) D29(11.751,-1.336) D33(13.376,-1.336) D37(15.002,-1.336) D42(17.233,-1.323) E6(2.574,-1.743) F3(0.978,-2.359) F8(3.14,-1.934) F10(4.118,-1.934) F13(5.096,-1.934) F15(6.074,-1.934) F17(7.052,-1.934) F20(8.03,-1.934) F22(9.008,-1.934) F24(9.617,-1.934) F26(10.595,-1.934) F29(11.573,-1.934) F31(12.551,-1.934) F33(13.529,-1.934) F36(14.507,-1.934) F38(15.485,-1.934) F39(16.221,-1.502) F41(16.882,-2.574) F43(17.647,-2.404) G2(0.532,-2.752) G5(1.562,-2.48) G8(3.14,-2.531) G10(4.118,-2.531) G13(5.096,-2.531) G15(6.074,-2.531) G17(7.052,-2.531) G20(8.03,-2.531) G22(9.008,-2.531) G24(9.617,-2.531) G26(10.595,-2.531) G29(11.573,-2.531) G31(12.551,-2.531) G33(13.529,-2.531) G36(14.507,-2.531) G38(15.485,-2.531) G44(18.152,-2.81) H1(0,-3.216) H3(0.904,-3.216) H6(1.934,-3.14) H7(2.531,-3.14) H10(4.118,-3.128) H13(5.096,-3.128) H15(6.074,-3.128) H17(7.052,-3.128) H20(8.03,-3.128) H22(9.008,-3.128) H24(9.617,-3.128) H26(10.595,-3.128) H29(11.573,-3.128) H31(12.551,-3.128) H33(13.529,-3.128) H36(14.507,-3.128) H39(16.094,-3.14) H40(16.691,-3.14) H43(17.721,-3.216) H45(18.625,-3.216) J2(0.452,-3.601) J4(1.336,-3.623) J42(17.289,-3.623) J44(18.173,-3.645) K1(0,-4.029) K3(0.904,-4.029) K6(1.934,-4.118) K7(2.531,-4.118) K8(3.128,-4.118) K10(3.724,-4.118) K13(5.096,-3.724) K15(6.074,-3.724) K17(7.052,-3.724) K20(8.03,-3.724) K22(9.008,-3.724) K24(9.617,-3.724) K26(10.595,-3.724) K29(11.573,-3.724) K31(12.551,-3.724) K33(13.529,-3.724) K36(14.507,-3.724) K38(15.497,-4.118) K39(16.094,-4.118) K40(16.691,-4.118) K43(17.721,-4.029) K45(18.625,-4.029) L2(0.472,-4.436) L13(5.096,-4.321) L15(6.074,-4.321) L17(7.052,-4.321) L20(8.03,-4.321) L22(9.008,-4.321) L24(9.617,-4.321) L26(10.595,-4.321) L29(11.573,-4.321) L31(12.551,-4.321) L33(13.529,-4.321) L44(18.152,-4.436) M1(0,-4.842) M3(0.904,-4.842) M15(6.074,-4.918) M17(7.052,-4.918) M20(8.03,-4.918) M22(9.008,-4.918) M24(9.617,-4.918) M26(10.595,-4.918) M29(11.573,-4.918) M31(12.551,-4.918) M33(13.529,-4.969) M43(17.721,-4.842) M45(18.625,-4.842) N2(0.452,-5.227) N4(1.336,-5.248) N6(1.934,-5.096) N7(2.531,-5.096) N8(3.128,-5.096) N10(3.724,-5.096) N11(4.321,-5.096) N12(4.969,-5.096) N35(14.304,-5.096) N36(14.9,-5.096) N38(15.497,-5.096) N39(16.094,-5.096) N40(16.691,-5.096) N42(17.289,-5.248) N44(18.173,-5.27) P1(0,-5.655) P3(0.904,-5.655) P14(5.515,-5.525) P16(6.328,-5.525) P18(7.141,-5.525) P20(7.954,-5.525) P22(8.766,-5.525) P24(9.579,-5.525) P26(10.392,-5.525) P28(11.205,-5.525) P30(12.018,-5.525) P32(12.83,-5.525) P43(17.721,-5.655) P45(18.625,-5.655) R2(0.472,-6.061) R6(1.934,-6.074) R7(2.531,-6.074) R8(3.128,-6.074) R10(3.724,-6.074) R11(4.321,-6.074) R12(4.918,-6.074) R14(5.515,-6.186) R16(6.328,-6.186) R18(7.141,-6.186) R20(7.954,-6.186) R22(8.766,-6.186) R24(9.579,-6.186) R26(10.392,-6.186) R28(11.205,-6.186) R30(12.018,-6.186) R32(12.83,-6.186) R34(13.707,-6.074) R35(14.304,-6.074) R36(14.9,-6.074) R38(15.497,-6.074) R39(16.094,-6.074) R40(16.691,-6.074) R44(18.152,-6.061) T1(0,-6.468) T3(0.904,-6.468) T43(17.721,-6.468) T45(18.625,-6.468) U2(0.452,-6.852) U4(1.336,-6.874) U6(1.934,-7.052) U7(2.531,-7.052) U8(3.128,-7.052) U10(3.724,-7.052) U11(4.321,-7.052) U12(4.918,-7.052) U14(5.515,-6.846) U16(6.328,-6.846) U18(7.141,-6.846) U20(7.954,-6.846) U22(8.766,-6.846) U24(9.579,-6.846) U26(10.392,-6.846) U28(11.205,-6.846) U30(12.018,-6.846) U32(12.83,-6.846) U34(13.707,-7.052) U35(14.304,-7.052) U36(14.9,-7.052) U38(15.497,-7.052) U39(16.094,-7.052) U40(16.691,-7.052) U42(17.289,-6.874) U44(18.173,-6.896) V1(0,-7.28) V3(0.904,-7.28) V14(5.515,-7.506) V16(6.328,-7.506) V18(7.141,-7.506) V20(7.954,-7.506) V22(8.766,-7.506) V24(9.579,-7.506) V26(10.392,-7.506) V28(11.205,-7.506) V30(12.018,-7.506) V32(12.83,-7.506) V43(17.721,-7.28) V45(18.625,-7.28) W2(0.472,-7.687) W44(18.152,-7.687) Y1(0,-8.093) Y3(0.904,-8.093) Y6(1.934,-8.03) Y7(2.531,-8.03) Y8(3.128,-8.03) Y10(3.724,-8.03) Y11(4.321,-8.03) Y12(4.918,-8.03) Y14(5.515,-8.167) Y16(6.328,-8.167) Y18(7.141,-8.167) Y20(7.954,-8.167) Y22(8.766,-8.167) Y24(9.579,-8.167) Y26(10.392,-8.167) Y28(11.205,-8.167) Y30(12.018,-8.167) Y32(12.83,-8.167) Y34(13.707,-8.03) Y35(14.304,-8.03) Y36(14.9,-8.03) Y38(15.497,-8.03) Y39(16.094,-8.03) Y40(16.691,-8.03) Y43(17.721,-8.093) Y45(18.625,-8.093)
DMG2301U-7_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
E-T_1000K-Y40E-02L_40P
  round 0.66 hole 0.66 unplated: (-9.81,-2.125) (0.19,-2.125)
  oval 0.381x1.753 smd: 1(0,0) 2(0,-4.25) 39(-9.62,0) 40(-9.62,-4.25)
  oval 0.254x1.753 smd: 3(-0.56,0) 4(-0.56,-4.25) 5(-1.06,0) 6(-1.06,-4.25) 7(-1.56,0) 8(-1.56,-4.25) 9(-2.06,0) 10(-2.06,-4.25) 11(-2.56,0) 12(-2.56,-4.25) 13(-3.06,0) 14(-3.06,-4.25) 15(-3.56,0) 16(-3.56,-4.25) 17(-4.06,0) 18(-4.06,-4.25) 19(-4.56,0) 20(-4.56,-4.25) 21(-5.06,0) 22(-5.06,-4.25) 23(-5.56,0) 24(-5.56,-4.25) 25(-6.06,0) 26(-6.06,-4.25) 27(-6.56,0) 28(-6.56,-4.25) 29(-7.06,0) 30(-7.06,-4.25) 31(-7.56,0) 32(-7.56,-4.25) 33(-8.06,0) 34(-8.06,-4.25) 35(-8.56,0) 36(-8.56,-4.25) 37(-9.06,0) 38(-9.06,-4.25)
  custom 0.337x0.337 smd: 41(-10.685,-2.125) 42(1.065,-2.125)
E-T_1001K-F30C-03L_30P-T
  round 0.66 hole 0.66 unplated: (-8.31,-2.425) (1.19,-2.425)
  oval 0.381x1.143 smd: 1(0,0) 2(0,-4.85) 29(-7.12,0) 30(-7.12,-4.85)
  oval 0.254x1.143 smd: 3(-0.56,0) 4(-0.56,-4.85) 5(-1.06,0) 6(-1.06,-4.85) 7(-1.56,0) 8(-1.56,-4.85) 9(-2.06,0) 10(-2.06,-4.85) 11(-2.56,0) 12(-2.56,-4.85) 13(-3.06,0) 14(-3.06,-4.85) 15(-3.56,0) 16(-3.56,-4.85) 17(-4.06,0) 18(-4.06,-4.85) 19(-4.56,0) 20(-4.56,-4.85) 21(-5.06,0) 22(-5.06,-4.85) 23(-5.56,0) 24(-5.56,-4.85) 25(-6.06,0) 26(-6.06,-4.85) 27(-6.56,0) 28(-6.56,-4.85)
  custom 0.4x0.4 smd: 31(2.14,-2.425) 32(-9.26,-2.425)
E-T_3702K-Q08C-07L_8P
  oval 0.61x1.753 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0)
  rect 1.194x2.007 smd: 9(-1.3,2.525) 10(8.3,2.525)
ECE5048-LZY_DQFN132_11X11
  oval 0.279x0.737 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0) A13(6,0) A14(6.5,0) A15(7,0) A16(7.5,0) A33(7.5,10.9) A34(7,10.9) A35(6.5,10.9) A36(6,10.9) A37(5.5,10.9) A38(5,10.9) A39(4.5,10.9) A40(4,10.9) A41(3.5,10.9) A42(3,10.9) A43(2.5,10.9) A44(2,10.9) A45(1.5,10.9) A46(1,10.9) A47(0.5,10.9) A48(0,10.9)
  oval 0.737x0.279 smd: A17(9.2,1.7) A18(9.2,2.2) A19(9.2,2.7) A20(9.2,3.2) A21(9.2,3.7) A22(9.2,4.2) A23(9.2,4.7) A24(9.2,5.2) A25(9.2,5.7) A26(9.2,6.2) A27(9.2,6.7) A28(9.2,7.2) A29(9.2,7.7) A30(9.2,8.2) A31(9.2,8.7) A32(9.2,9.2) A49(-1.7,9.2) A50(-1.7,8.7) A51(-1.7,8.2) A52(-1.7,7.7) A53(-1.7,7.2) A54(-1.7,6.7) A55(-1.7,6.2) A56(-1.7,5.7) A57(-1.7,5.2) A58(-1.7,4.7) A59(-1.7,4.2) A60(-1.7,3.7) A61(-1.7,3.2) A62(-1.7,2.7) A63(-1.7,2.2) A64(-1.7,1.7)
  oval 0.318x0.61 smd: B1(-0.25,0.855) B2(0.25,0.855) B3(0.75,0.855) B4(1.25,0.855) B5(1.75,0.855) B6(2.25,0.855) B7(2.75,0.855) B8(3.25,0.855) B9(3.75,0.855) B10(4.25,0.855) B11(4.75,0.855) B12(5.25,0.855) B13(5.75,0.855) B14(6.25,0.855) B15(6.75,0.855) B16(7.25,0.855) B17(7.75,0.855) B35(7.75,10.045) B36(7.25,10.045) B37(6.75,10.045) B38(6.25,10.045) B39(5.75,10.045) B40(5.25,10.045) B41(4.75,10.045) B42(4.25,10.045) B43(3.75,10.045) B44(3.25,10.045) B45(2.75,10.045) B46(2.25,10.045) B47(1.75,10.045) B48(1.25,10.045) B49(0.75,10.045) B50(0.25,10.045) B51(-0.25,10.045)
  oval 0.61x0.318 smd: B18(8.345,1.45) B19(8.345,1.95) B20(8.345,2.45) B21(8.345,2.95) B22(8.345,3.45) B23(8.345,3.95) B24(8.345,4.45) B25(8.345,4.95) B26(8.345,5.45) B27(8.345,5.95) B28(8.345,6.45) B29(8.345,6.95) B30(8.345,7.45) B31(8.345,7.95) B32(8.345,8.45) B33(8.345,8.95) B34(8.345,9.45) B52(-0.845,9.45) B53(-0.845,8.95) B54(-0.845,8.45) B55(-0.845,7.95) B56(-0.845,7.45) B57(-0.845,6.95) B58(-0.845,6.45) B59(-0.845,5.95) B60(-0.845,5.45) B61(-0.845,4.95) B62(-0.845,4.45) B63(-0.845,3.95) B64(-0.845,3.45) B65(-0.845,2.95) B66(-0.845,2.45) B67(-0.845,1.95) B68(-0.845,1.45)
  rect 5.105x5.105 smd: C1(3.75,5.45)
FDC654P-G_SSOT-6
  oval 0.711x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.6) 5(0.95,2.6) 6(0,2.6)
FDN338P_NL_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FDS6679AZ_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.16) 6(2.54,5.16) 7(1.27,5.16) 8(0,5.16)
FDV301N_NL_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G547I2P81U_MSOP8
  oval 0.381x1.549 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.37) 6(1.3,4.37) 7(0.65,4.37) 8(0,4.37)
G971ADJF11U_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.3) 6(2.54,5.3) 7(1.27,5.3) 8(0,5.3)
  rect 2.997x2.464 smd: 9(1.905,2.65)
H_2P0N
  round 2.007 hole 2.007 unplated: (0,0)
H_2P3
  round 2.819 hole 2.311: 1(0,0)
H_3P0
  round 3.505 hole 2.997: 1(0,0)
H_3P1X2P1N
  oval 3.099x2.108 hole 3.099x2.108 unplated: (0,0)
H_3P2
  round 3.708 hole 3.2: 1(0,0)
H_3P3
  round 3.81 hole 3.302: 1(0,0)
H_3P8
  round 4.318 hole 3.81: 1(0,0)
HB_A090620-SAHR21_6P
  oval 0.61x1.499 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0)
  rect 2.489x2.21 smd: 7(-3,-3.15) 8(8,-3.15)
HB_A091020-SAHR22_10P
  oval 0.61x1.499 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0) 9(8,0) 10(9,0)
  rect 2.489x2.21 smd: 11(-3,-3.15) 12(12,-3.15)
HB_A520620-SCHR22_6P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0)
  rect 2.489x1.905 smd: 7(-2.15,-3.3) 8(4.65,-3.3)
HB_A520820-SCHR22_8P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0)
  rect 2.489x1.905 smd: 9(-2.15,-3.3) 10(5.65,-3.3)
HB_A522020-SCHR22_20P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 2.489x1.905 smd: 21(-2.15,-3.3) 22(11.65,-3.3)
HB_A531015-SCHR21_10P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.991x2.007 smd: 11(6.6,-3.05) 12(-2.1,-3.05)
IMD2AT-108_SC74-6
  oval 0.508x1.473 smd: 1(0,0) 2(-0.95,0) 3(-1.9,0) 4(-1.9,2.55) 5(-0.95,2.55) 6(0,2.55)
INA199A2DCKR_SC70-6
  oval 0.406x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,2.2) 5(0.65,2.2) 6(0,2.2)
ISL62883CHRTZ-T_TQFN40_5X5
  oval 0.203x0.991 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 21(3.6,4.95) 22(3.2,4.95) 23(2.8,4.95) 24(2.4,4.95) 25(2,4.95) 26(1.6,4.95) 27(1.2,4.95) 28(0.8,4.95) 29(0.4,4.95) 30(0,4.95)
  oval 0.991x0.203 smd: 11(4.275,0.675) 12(4.275,1.075) 13(4.275,1.475) 14(4.275,1.875) 15(4.275,2.275) 16(4.275,2.675) 17(4.275,3.075) 18(4.275,3.475) 19(4.275,3.875) 20(4.275,4.275) 31(-0.675,4.275) 32(-0.675,3.875) 33(-0.675,3.475) 34(-0.675,3.075) 35(-0.675,2.675) 36(-0.675,2.275) 37(-0.675,1.875) 38(-0.675,1.475) 39(-0.675,1.075) 40(-0.675,0.675)
  rect 3.505x3.505 smd: 41(1.8,2.475)
ISL95812HRZ-T_QFN32_4X4
  oval 0.203x0.914 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 17(2.8,4.077) 18(2.4,4.077) 19(2,4.077) 20(1.6,4.077) 21(1.2,4.077) 22(0.8,4.077) 23(0.4,4.077) 24(0,4.077)
  oval 0.914x0.203 smd: 9(3.438,0.639) 10(3.438,1.039) 11(3.438,1.438) 12(3.438,1.838) 13(3.438,2.239) 14(3.438,2.639) 15(3.438,3.039) 16(3.438,3.438) 25(-0.639,3.438) 26(-0.639,3.039) 27(-0.639,2.639) 28(-0.639,2.239) 29(-0.639,1.838) 30(-0.639,1.438) 31(-0.639,1.039) 32(-0.639,0.639)
  rect 2.642x2.642 smd: 33(1.4,2.039)
J-L_TNBNRBC80002008_13P-T
  round 1.295 hole 0.889: 1(0,0) 2(1.02,-1.1) 3(2.04,0) 4(3.06,-1.1) 5(4.08,0) 6(5.1,-1.1) 7(6.12,0) 8(7.14,-1.1) 9(-3.39,1.4) 10(-2.245,-0.1) 11(8.24,1.4) 12(9.385,-0.1) 13(10.53,1.4)
  oval 1.753x3.15 hole 0.991x2.388: 14(-5.95,-11.6) 15(13.09,-11.6)
JAE_WD2F144WB1R300_144P
  oval 1.702x1.092 hole 1.702x1.092 unplated: (3,-4) (34.5,-4)
  oval 0.254x1.803 smd: 1(0,0) 2(0,-8) 3(0.5,0) 4(0.5,-8) 5(1,0) 6(1,-8) 7(1.5,0) 8(1.5,-8) 9(2,0) 10(2,-8) 11(2.5,0) 12(2.5,-8) 13(3,0) 14(3,-8) 15(3.5,0) 16(3.5,-8) 17(4,0) 18(4,-8) 19(4.5,0) 20(4.5,-8) 21(5,0) 22(5,-8) 23(5.5,0) 24(5.5,-8) 25(6,0) 26(6,-8) 27(6.5,0) 28(6.5,-8) 29(7,0) 30(7,-8) 31(7.5,0) 32(7.5,-8) 33(8,0) 34(8,-8) 35(8.5,0) 36(8.5,-8) 37(9,0) 38(9,-8) 39(9.5,0) 40(9.5,-8) 41(10,0) 42(10,-8) 43(10.5,0) 44(10.5,-8) 45(11,0) 46(11,-8) 47(11.5,0) 48(11.5,-8) 49(12,0) 50(12,-8) 51(13.5,0) 52(13.5,-8) 53(14,0) 54(14,-8) 55(14.5,0) 56(14.5,-8) 57(15,0) 58(15,-8) 59(15.5,0) 60(15.5,-8) 61(16,0) 62(16,-8) 63(16.5,0) 64(16.5,-8) 65(17,0) 66(17,-8) 67(17.5,0) 68(17.5,-8) 69(18,0) 70(18,-8) 71(18.5,0) 72(18.5,-8) 73(19,0) 74(19,-8) 75(19.5,0) 76(19.5,-8) 77(20,0) 78(20,-8) 79(20.5,0) 80(20.5,-8) 81(21,0) 82(21,-8) 83(21.5,0) 84(21.5,-8) 85(22,0) 86(22,-8) 87(22.5,0) 88(22.5,-8) 89(23,0) 90(23,-8) 91(23.5,0) 92(23.5,-8) 93(24,0) 94(24,-8) 95(25.5,0) 96(25.5,-8) 97(26,0) 98(26,-8) 99(26.5,0) 100(26.5,-8) 101(27,0) 102(27,-8) 103(27.5,0) 104(27.5,-8) 105(28,0) 106(28,-8) 107(28.5,0) 108(28.5,-8) 109(29,0) 110(29,-8) 111(29.5,0) 112(29.5,-8) 113(30,0) 114(30,-8) 115(30.5,0) 116(30.5,-8) 117(31,0) 118(31,-8) 119(31.5,0) 120(31.5,-8) 121(32,0) 122(32,-8) 123(32.5,0) 124(32.5,-8) 125(33,0) 126(33,-8) 127(33.5,0) 128(33.5,-8) 129(34,0) 130(34,-8) 131(34.5,0) 132(34.5,-8) 133(35,0) 134(35,-8) 135(35.5,0) 136(35.5,-8) 137(36,0) 138(36,-8) 139(36.5,0) 140(36.5,-8) 141(37,0) 142(37,-8) 143(37.5,0) 144(37.5,-8)
  oval 1.753x3.607 hole 0.991x2.845: 145(-5.425,-4) 152(42.925,-4)
  oval 1.905x1.702 hole 1.143x0.94: 146(-1.55,-2.275) 148(-1.55,-5.725) 149(39.05,-2.275) 151(39.05,-5.725)
  oval 1.702x2.667 hole 0.94x1.905: 147(-2.475,-4) 150(39.975,-4)
  oval 3.759x1.6 hole 2.997x0.838: 153(-3.75,-0.075) 156(41.25,-0.075) 161(-3.75,-7.925) 164(41.25,-7.925)
  oval 1.753x1.6 hole 1.245x0.838: 154(12.75,-0.075) 155(24.75,-0.075) 162(12.75,-7.925) 163(24.75,-7.925)
  round 1.753 hole 0.991: 157(0.75,-4) 158(12.75,-4) 159(24.75,-4) 160(36.75,-4)
JESS_UCNR2451M005-0_5P
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
K4G41325FC-HC04_FBGA_170P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) A14(10.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) B14(10.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) C14(10.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) D14(10.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) E14(10.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) F14(10.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) G14(10.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) H14(10.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) J14(10.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) K14(10.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) L14(10.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) M14(10.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601) N14(10.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P4(2.4,-10.401) P5(3.2,-10.401) P10(7.201,-10.401) P11(8.001,-10.401) P12(8.801,-10.401) P13(9.601,-10.401) P14(10.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R4(2.4,-11.201) R5(3.2,-11.201) R10(7.201,-11.201) R11(8.001,-11.201) R12(8.801,-11.201) R13(9.601,-11.201) R14(10.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T4(2.4,-12.002) T5(3.2,-12.002) T10(7.201,-12.002) T11(8.001,-12.002) T12(8.801,-12.002) T13(9.601,-12.002) T14(10.401,-12.002) U1(0,-12.802) U2(0.8,-12.802) U3(1.6,-12.802) U4(2.4,-12.802) U5(3.2,-12.802) U10(7.201,-12.802) U11(8.001,-12.802) U12(8.801,-12.802) U13(9.601,-12.802) U14(10.401,-12.802)
KC_FBMA-L18-453215_L1812_2P
  rect 1.803x3.404 smd: 1(0,0) 2(3.8,0)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
L03ESDL5V0CC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L30ESD24VC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L30ESDL5V0C3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L_1812-1806
  oval 1.016x3.708 smd: 1(0,0) 2(4.013,0)
LED_LTW-193ZDS5_2P
  rect 0.787x0.787 smd: 1(0,0) 2(1.5,0)
LM393DR_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
LNG3DMTR_LGA16_3X3
  oval 0.305x0.864 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 9(2,2.958) 10(1.5,2.958) 11(1,2.958) 12(0.5,2.958) 13(0,2.958)
  oval 0.864x0.305 smd: 6(2.479,0.979) 7(2.479,1.479) 8(2.479,1.979) 14(-0.479,1.979) 15(-0.479,1.479) 16(-0.479,0.979)
LOTES_ABA-USB-116-P04_9P
  round 1.194 hole 0.787: 1(0,0) 2(2.5,0) 3(4.5,0) 4(7,0) 5(7.5,1.5) 6(5.5,1.5) 7(3.5,1.5) 8(1.5,1.5) 9(-0.5,1.5)
  oval 1.397x2.692 hole 0.787x2.108: 10(9.9,0.5) 12(-2.9,0.5)
  oval 1.397x2.007 hole 0.787x1.397: 11(9.9,-5.6) 13(-2.9,-5.6)
LOTES_AZIF0012-P002B_947P-T
  round 0.508 smd: A2(0,1) A3(0,2) A33(0,32) A34(0,33) A35(0,34) AP1(33,0) AP35(33,34) AR1(34,0) AR2(34,1) AR34(34,33) AR35(34,34) AT1(35,0) AT2(35,1) AT3(35,2) AT33(35,32) AT34(35,33) AT35(35,34) B1(1,0) B2(1,1) B34(1,33) B35(1,34) C1(2,0) C35(2,34)
  oval 0.61x0.457 smd: A4(0,3) A5(0,4) A6(0,5) A7(0,6) A8(0,7) A9(0,8) A10(0,9) A11(0,10) A12(0,11) A13(0,12) A14(0,13) A15(0,14) A16(0,15) A17(0,16) A18(0,17) A19(0,18) A20(0,19) A21(0,20) A22(0,21) A23(0,22) A24(0,23) A25(0,24) A26(0,25) A27(0,26) A28(0,27) A29(0,28) A30(0,29) A31(0,30) A32(0,31) AT4(35,3) AT5(35,4) AT6(35,5) AT7(35,6) AT8(35,7) AT9(35,8) AT10(35,9) AT11(35,10) AT12(35,11) AT13(35,12) AT14(35,13) AT15(35,14) AT16(35,15) AT17(35,16) AT18(35,17) AT19(35,18) AT20(35,19) AT21(35,20) AT22(35,21) AT23(35,22) AT24(35,23) AT25(35,24) AT26(35,25) AT27(35,26) AT28(35,27) AT29(35,28) AT30(35,29) AT31(35,30) AT32(35,31)
  oval 0.457x0.61 smd: AA1(20,0) AA35(20,34) AB1(21,0) AB35(21,34) AC1(22,0) AC35(22,34) AD1(23,0) AD35(23,34) AE1(24,0) AE35(24,34) AF1(25,0) AF35(25,34) AG1(26,0) AG35(26,34) AH1(27,0) AH35(27,34) AJ1(28,0) AJ35(28,34) AK1(29,0) AK35(29,34) AL1(30,0) AL35(30,34) AM1(31,0) AM35(31,34) AN1(32,0) AN35(32,34) D1(3,0) D35(3,34) E1(4,0) E35(4,34) F1(5,0) F35(5,34) G1(6,0) G35(6,34) H1(7,0) H35(7,34) J1(8,0) J35(8,34) K1(9,0) K35(9,34) L1(10,0) L35(10,34) M1(11,0) M35(11,34) N1(12,0) N35(12,34) P1(13,0) P35(13,34) R1(14,0) R35(14,34) T1(15,0) T35(15,34) U1(16,0) U35(16,34) V1(17,0) V35(17,34) W1(18,0) W35(18,34) Y1(19,0) Y35(19,34)
  round 0.457 smd: AA2(20,1) AA3(20,2) AA4(20,3) AA5(20,4) AA6(20,5) AA7(20,6) AA8(20,7) AA9(20,8) AA10(20,9) AA11(20,10) AA25(20,24) AA26(20,25) AA27(20,26) AA28(20,27) AA29(20,28) AA30(20,29) AA31(20,30) AA32(20,31) AA33(20,32) AA34(20,33) AB2(21,1) AB3(21,2) AB4(21,3) AB5(21,4) AB6(21,5) AB7(21,6) AB8(21,7) AB9(21,8) AB10(21,9) AB11(21,10) AB25(21,24) AB26(21,25) AB27(21,26) AB28(21,27) AB29(21,28) AB30(21,29) AB31(21,30) AB32(21,31) AB33(21,32) AB34(21,33) AC2(22,1) AC3(22,2) AC4(22,3) AC5(22,4) AC6(22,5) AC7(22,6) AC8(22,7) AC9(22,8) AC10(22,9) AC11(22,10) AC25(22,24) AC26(22,25) AC27(22,26) AC28(22,27) AC29(22,28) AC30(22,29) AC31(22,30) AC32(22,31) AC33(22,32) AC34(22,33) AD2(23,1) AD3(23,2) AD4(23,3) AD5(23,4) AD6(23,5) AD7(23,6) AD8(23,7) AD9(23,8) AD10(23,9) AD11(23,10) AD25(23,24) AD26(23,25) AD27(23,26) AD28(23,27) AD29(23,28) AD30(23,29) AD31(23,30) AD32(23,31) AD33(23,32) AD34(23,33) AE2(24,1) AE3(24,2) AE4(24,3) AE5(24,4) AE6(24,5) AE7(24,6) AE8(24,7) AE9(24,8) AE10(24,9) AE11(24,10) AE25(24,24) AE26(24,25) AE27(24,26) AE28(24,27) AE29(24,28) AE30(24,29) AE31(24,30) AE32(24,31) AE33(24,32) AE34(24,33) AF2(25,1) AF3(25,2) AF4(25,3) AF5(25,4) AF6(25,5) AF7(25,6) AF8(25,7) AF9(25,8) AF10(25,9) AF11(25,10) AF25(25,24) AF26(25,25) AF27(25,26) AF28(25,27) AF29(25,28) AF30(25,29) AF31(25,30) AF32(25,31) AF33(25,32) AF34(25,33) AG2(26,1) AG3(26,2) AG4(26,3) AG5(26,4) AG6(26,5) AG7(26,6) AG8(26,7) AG9(26,8) AG10(26,9) AG11(26,10) AG25(26,24) AG26(26,25) AG27(26,26) AG28(26,27) AG29(26,28) AG30(26,29) AG31(26,30) AG32(26,31) AG33(26,32) AG34(26,33) AH2(27,1) AH3(27,2) AH4(27,3) AH5(27,4) AH6(27,5) AH7(27,6) AH8(27,7) AH9(27,8) AH10(27,9) AH11(27,10) AH25(27,24) AH26(27,25) AH27(27,26) AH28(27,27) AH29(27,28) AH30(27,29) AH31(27,30) AH32(27,31) AH33(27,32) AH34(27,33) AJ2(28,1) AJ3(28,2) AJ4(28,3) AJ5(28,4) AJ6(28,5) AJ7(28,6) AJ8(28,7) AJ9(28,8) AJ10(28,9) AJ11(28,10) AJ25(28,24) AJ26(28,25) AJ27(28,26) AJ28(28,27) AJ29(28,28) AJ30(28,29) AJ31(28,30) AJ32(28,31) AJ33(28,32) AJ34(28,33) AK2(29,1) AK3(29,2) AK4(29,3) AK5(29,4) AK6(29,5) AK7(29,6) AK8(29,7) AK9(29,8) AK10(29,9) AK11(29,10) AK25(29,24) AK26(29,25) AK27(29,26) AK28(29,27) AK29(29,28) AK30(29,29) AK31(29,30) AK32(29,31) AK33(29,32) AK34(29,33) AL2(30,1) AL3(30,2) AL4(30,3) AL5(30,4) AL6(30,5) AL7(30,6) AL8(30,7) AL9(30,8) AL10(30,9) AL11(30,10) AL12(30,11) AL13(30,12) AL14(30,13) AL15(30,14) AL16(30,15) AL17(30,16) AL18(30,17) AL19(30,18) AL20(30,19) AL21(30,20) AL22(30,21) AL23(30,22) AL24(30,23) AL25(30,24) AL26(30,25) AL27(30,26) AL28(30,27) AL29(30,28) AL30(30,29) AL31(30,30) AL32(30,31) AL33(30,32) AL34(30,33) AM2(31,1) AM3(31,2) AM4(31,3) AM5(31,4) AM6(31,5) AM7(31,6) AM8(31,7) AM9(31,8) AM10(31,9) AM11(31,10) AM12(31,11) AM13(31,12) AM14(31,13) AM15(31,14) AM16(31,15) AM17(31,16) AM18(31,17) AM19(31,18) AM20(31,19) AM21(31,20) AM22(31,21) AM23(31,22) AM24(31,23) AM25(31,24) AM26(31,25) AM27(31,26) AM28(31,27) AM29(31,28) AM30(31,29) AM31(31,30) AM32(31,31) AM33(31,32) AM34(31,33) AN2(32,1) AN3(32,2) AN4(32,3) AN5(32,4) AN6(32,5) AN7(32,6) AN8(32,7) AN9(32,8) AN10(32,9) AN11(32,10) AN12(32,11) AN13(32,12) AN14(32,13) AN15(32,14) AN16(32,15) AN17(32,16) AN18(32,17) AN19(32,18) AN20(32,19) AN21(32,20) AN22(32,21) AN23(32,22) AN24(32,23) AN25(32,24) AN26(32,25) AN27(32,26) AN28(32,27) AN29(32,28) AN30(32,29) AN31(32,30) AN32(32,31) AN33(32,32) AN34(32,33) AP2(33,1) AP3(33,2) AP4(33,3) AP5(33,4) AP6(33,5) AP7(33,6) AP8(33,7) AP9(33,8) AP10(33,9) AP11(33,10) AP12(33,11) AP13(33,12) AP14(33,13) AP15(33,14) AP16(33,15) AP17(33,16) AP18(33,17) AP19(33,18) AP20(33,19) AP21(33,20) AP22(33,21) AP23(33,22) AP24(33,23) AP25(33,24) AP26(33,25) AP27(33,26) AP28(33,27) AP29(33,28) AP30(33,29) AP31(33,30) AP32(33,31) AP33(33,32) AP34(33,33) AR3(34,2) AR4(34,3) AR5(34,4) AR6(34,5) AR7(34,6) AR8(34,7) AR9(34,8) AR10(34,9) AR11(34,10) AR12(34,11) AR13(34,12) AR14(34,13) AR15(34,14) AR16(34,15) AR17(34,16) AR18(34,17) AR19(34,18) AR20(34,19) AR21(34,20) AR22(34,21) AR23(34,22) AR24(34,23) AR25(34,24) AR26(34,25) AR27(34,26) AR28(34,27) AR29(34,28) AR30(34,29) AR31(34,30) AR32(34,31) AR33(34,32) B3(1,2) B4(1,3) B5(1,4) B6(1,5) B7(1,6) B8(1,7) B9(1,8) B10(1,9) B11(1,10) B12(1,11) B13(1,12) B14(1,13) B15(1,14) B16(1,15) B17(1,16) B18(1,17) B19(1,18) B20(1,19) B21(1,20) B22(1,21) B23(1,22) B24(1,23) B25(1,24) B26(1,25) B27(1,26) B28(1,27) B29(1,28) B30(1,29) B31(1,30) B32(1,31) B33(1,32) C2(2,1) C3(2,2) C4(2,3) C5(2,4) C6(2,5) C7(2,6) C8(2,7) C9(2,8) C10(2,9) C11(2,10) C12(2,11) C13(2,12) C14(2,13) C15(2,14) C16(2,15) C17(2,16) C18(2,17) C19(2,18) C20(2,19) C21(2,20) C22(2,21) C23(2,22) C24(2,23) C25(2,24) C26(2,25) C27(2,26) C28(2,27) C29(2,28) C30(2,29) C31(2,30) C32(2,31) C33(2,32) C34(2,33) D2(3,1) D3(3,2) D4(3,3) D5(3,4) D6(3,5) D7(3,6) D8(3,7) D9(3,8) D10(3,9) D11(3,10) D12(3,11) D13(3,12) D14(3,13) D15(3,14) D16(3,15) D17(3,16) D18(3,17) D19(3,18) D20(3,19) D21(3,20) D22(3,21) D23(3,22) D24(3,23) D25(3,24) D26(3,25) D27(3,26) D28(3,27) D29(3,28) D30(3,29) D31(3,30) D32(3,31) D33(3,32) D34(3,33) E2(4,1) E3(4,2) E4(4,3) E5(4,4) E6(4,5) E7(4,6) E8(4,7) E9(4,8) E10(4,9) E11(4,10) E12(4,11) E13(4,12) E14(4,13) E15(4,14) E16(4,15) E17(4,16) E18(4,17) E19(4,18) E20(4,19) E21(4,20) E22(4,21) E23(4,22) E24(4,23) E25(4,24) E26(4,25) E27(4,26) E28(4,27) E29(4,28) E30(4,29) E31(4,30) E32(4,31) E33(4,32) E34(4,33) F2(5,1) F3(5,2) F4(5,3) F5(5,4) F6(5,5) F7(5,6) F8(5,7) F9(5,8) F10(5,9) F11(5,10) F12(5,11) F13(5,12) F14(5,13) F15(5,14) F16(5,15) F17(5,16) F18(5,17) F19(5,18) F20(5,19) F21(5,20) F22(5,21) F23(5,22) F24(5,23) F25(5,24) F26(5,25) F27(5,26) F28(5,27) F29(5,28) F30(5,29) F31(5,30) F32(5,31) F33(5,32) F34(5,33) G2(6,1) G3(6,2) G4(6,3) G5(6,4) G6(6,5) G7(6,6) G8(6,7) G9(6,8) G10(6,9) G11(6,10) G25(6,24) G26(6,25) G27(6,26) G28(6,27) G29(6,28) G30(6,29) G31(6,30) G32(6,31) G33(6,32) G34(6,33) H2(7,1) H3(7,2) H4(7,3) H5(7,4) H6(7,5) H7(7,6) H8(7,7) H9(7,8) H10(7,9) H11(7,10) H25(7,24) H26(7,25) H27(7,26) H28(7,27) H29(7,28) H30(7,29) H31(7,30) H32(7,31) H33(7,32) H34(7,33) J2(8,1) J3(8,2) J4(8,3) J5(8,4) J6(8,5) J7(8,6) J8(8,7) J9(8,8) J10(8,9) J11(8,10) J25(8,24) J26(8,25) J27(8,26) J28(8,27) J29(8,28) J30(8,29) J31(8,30) J32(8,31) J33(8,32) J34(8,33) K2(9,1) K3(9,2) K4(9,3) K5(9,4) K6(9,5) K7(9,6) K8(9,7) K9(9,8) K10(9,9) K11(9,10) K25(9,24) K26(9,25) K27(9,26) K28(9,27) K29(9,28) K30(9,29) K31(9,30) K32(9,31) K33(9,32) K34(9,33) L2(10,1) L3(10,2) L4(10,3) L5(10,4) L6(10,5) L7(10,6) L8(10,7) L9(10,8) L10(10,9) L11(10,10) L25(10,24) L26(10,25) L27(10,26) L28(10,27) L29(10,28) L30(10,29) L31(10,30) L32(10,31) L33(10,32) L34(10,33) M2(11,1) M3(11,2) M4(11,3) M5(11,4) M6(11,5) M7(11,6) M8(11,7) M9(11,8) M10(11,9) M11(11,10) M25(11,24) M26(11,25) M27(11,26) M28(11,27) M29(11,28) M30(11,29) M31(11,30) M32(11,31) M33(11,32) M34(11,33) N2(12,1) N3(12,2) N4(12,3) N5(12,4) N6(12,5) N7(12,6) N8(12,7) N9(12,8) N10(12,9) N11(12,10) N25(12,24) N26(12,25) N27(12,26) N28(12,27) N29(12,28) N30(12,29) N31(12,30) N32(12,31) N33(12,32) N34(12,33) P2(13,1) P3(13,2) P4(13,3) P5(13,4) P6(13,5) P7(13,6) P8(13,7) P9(13,8) P10(13,9) P11(13,10) P25(13,24) P26(13,25) P27(13,26) P28(13,27) P29(13,28) P30(13,29) P31(13,30) P32(13,31) P33(13,32) P34(13,33) R2(14,1) R3(14,2) R4(14,3) R5(14,4) R6(14,5) R7(14,6) R8(14,7) R9(14,8) R10(14,9) R11(14,10) R25(14,24) R26(14,25) R27(14,26) R28(14,27) R29(14,28) R30(14,29) R31(14,30) R32(14,31) R33(14,32) R34(14,33) T2(15,1) T3(15,2) T4(15,3) T5(15,4) T6(15,5) T7(15,6) T8(15,7) T9(15,8) T10(15,9) T11(15,10) T25(15,24) T26(15,25) T27(15,26) T28(15,27) T29(15,28) T30(15,29) T31(15,30) T32(15,31) T33(15,32) T34(15,33) U2(16,1) U3(16,2) U4(16,3) U5(16,4) U6(16,5) U7(16,6) U8(16,7) U9(16,8) U10(16,9) U11(16,10) U25(16,24) U26(16,25) U27(16,26) U28(16,27) U29(16,28) U30(16,29) U31(16,30) U32(16,31) U33(16,32) U34(16,33) V2(17,1) V3(17,2) V4(17,3) V5(17,4) V6(17,5) V7(17,6) V8(17,7) V9(17,8) V10(17,9) V11(17,10) V25(17,24) V26(17,25) V27(17,26) V28(17,27) V29(17,28) V30(17,29) V31(17,30) V32(17,31) V33(17,32) V34(17,33) W2(18,1) W3(18,2) W4(18,3) W5(18,4) W6(18,5) W7(18,6) W8(18,7) W9(18,8) W10(18,9) W11(18,10) W25(18,24) W26(18,25) W27(18,26) W28(18,27) W29(18,28) W30(18,29) W31(18,30) W32(18,31) W33(18,32) W34(18,33) Y2(19,1) Y3(19,2) Y4(19,3) Y5(19,4) Y6(19,5) Y7(19,6) Y8(19,7) Y9(19,8) Y10(19,9) Y11(19,10) Y25(19,24) Y26(19,25) Y27(19,26) Y28(19,27) Y29(19,28) Y30(19,29) Y31(19,30) Y32(19,31) Y33(19,32) Y34(19,33)
MEC5075-LZY_DQFN132_11X11
  oval 0.279x0.711 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0) A13(6,0) A14(6.5,0) A15(7,0) A16(7.5,0) A33(7.5,10.9) A34(7,10.9) A35(6.5,10.9) A36(6,10.9) A37(5.5,10.9) A38(5,10.9) A39(4.5,10.9) A40(4,10.9) A41(3.5,10.9) A42(3,10.9) A43(2.5,10.9) A44(2,10.9) A45(1.5,10.9) A46(1,10.9) A47(0.5,10.9) A48(0,10.9)
  oval 0.711x0.279 smd: A17(9.2,1.7) A18(9.2,2.2) A19(9.2,2.7) A20(9.2,3.2) A21(9.2,3.7) A22(9.2,4.2) A23(9.2,4.7) A24(9.2,5.2) A25(9.2,5.7) A26(9.2,6.2) A27(9.2,6.7) A28(9.2,7.2) A29(9.2,7.7) A30(9.2,8.2) A31(9.2,8.7) A32(9.2,9.2) A49(-1.7,9.2) A50(-1.7,8.7) A51(-1.7,8.2) A52(-1.7,7.7) A53(-1.7,7.2) A54(-1.7,6.7) A55(-1.7,6.2) A56(-1.7,5.7) A57(-1.7,5.2) A58(-1.7,4.7) A59(-1.7,4.2) A60(-1.7,3.7) A61(-1.7,3.2) A62(-1.7,2.7) A63(-1.7,2.2) A64(-1.7,1.7)
  oval 0.305x0.61 smd: B1(-0.25,0.85) B2(0.25,0.85) B3(0.75,0.85) B4(1.25,0.85) B5(1.75,0.85) B6(2.25,0.85) B7(2.75,0.85) B8(3.25,0.85) B9(3.75,0.85) B10(4.25,0.85) B11(4.75,0.85) B12(5.25,0.85) B13(5.75,0.85) B14(6.25,0.85) B15(6.75,0.85) B16(7.25,0.85) B17(7.75,0.85) B35(7.75,10.05) B36(7.25,10.05) B37(6.75,10.05) B38(6.25,10.05) B39(5.75,10.05) B40(5.25,10.05) B41(4.75,10.05) B42(4.25,10.05) B43(3.75,10.05) B44(3.25,10.05) B45(2.75,10.05) B46(2.25,10.05) B47(1.75,10.05) B48(1.25,10.05) B49(0.75,10.05) B50(0.25,10.05) B51(-0.25,10.05)
  oval 0.61x0.305 smd: B18(8.35,1.45) B19(8.35,1.95) B20(8.35,2.45) B21(8.35,2.95) B22(8.35,3.45) B23(8.35,3.95) B24(8.35,4.45) B25(8.35,4.95) B26(8.35,5.45) B27(8.35,5.95) B28(8.35,6.45) B29(8.35,6.95) B30(8.35,7.45) B31(8.35,7.95) B32(8.35,8.45) B33(8.35,8.95) B34(8.35,9.45) B52(-0.85,9.45) B53(-0.85,8.95) B54(-0.85,8.45) B55(-0.85,7.95) B56(-0.85,7.45) B57(-0.85,6.95) B58(-0.85,6.45) B59(-0.85,5.95) B60(-0.85,5.45) B61(-0.85,4.95) B62(-0.85,4.45) B63(-0.85,3.95) B64(-0.85,3.45) B65(-0.85,2.95) B66(-0.85,2.45) B67(-0.85,1.95) B68(-0.85,1.45)
  rect 5.004x5.004 smd: C1(3.75,5.45)
MMBT3906WT1G_SC70-3
  rect 0.813x0.914 smd: 1(0.65,-1.9) 2(1.3,0) 3(0,0)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MOLEX_52435-2671_26P-T
  oval 0.305x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0)
  custom 0.597x0.597 smd: 27(-2.45,-1.925) 28(14.95,-1.925)
MURAT_BLM15AG102SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15BB221SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15BD601SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PX600SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM18PG181SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18PG330SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_DLW21SN121SQ2L_4P
  rect 0.889x0.406 smd: 1(0,0) 2(1.7,0) 3(1.7,0.8) 4(0,0.8)
MURAT_DLW21SN900HQ2L_0805_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_DLW21SN900SQ2L_0805_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
NEC_MPC0740LR42C_2P
  rect 2.692x2.591 smd: 1(0,0) 2(6.2,0)
NL17SZ08DFT2G_SC70-5
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
NTGD4161PT1G_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.35) 5(0.95,2.35) 6(0,2.35)
NTR4502PT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
OCTEK_BTJ-09WKFB_9P
  round 1.397 hole 0.991: 1(0,0) 2(2,0) 3(4,0) 4(6,0) 5(8,0) 6(10,0) 7(12,0) 8(14,0) 9(16,0)
  oval 1.753x3.607 hole 0.991x2.845: 10(19.125,0) 11(-3.125,0)
OZ777FJ2LN_QFN48_6X6
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,6.1) 26(4,6.1) 27(3.6,6.1) 28(3.2,6.1) 29(2.8,6.1) 30(2.4,6.1) 31(2,6.1) 32(1.6,6.1) 33(1.2,6.1) 34(0.8,6.1) 35(0.4,6.1) 36(0,6.1)
  oval 0.889x0.203 smd: 13(5.25,0.85) 14(5.25,1.25) 15(5.25,1.65) 16(5.25,2.05) 17(5.25,2.45) 18(5.25,2.85) 19(5.25,3.25) 20(5.25,3.65) 21(5.25,4.05) 22(5.25,4.45) 23(5.25,4.85) 24(5.25,5.25) 37(-0.85,5.25) 38(-0.85,4.85) 39(-0.85,4.45) 40(-0.85,4.05) 41(-0.85,3.65) 42(-0.85,3.25) 43(-0.85,2.85) 44(-0.85,2.45) 45(-0.85,2.05) 46(-0.85,1.65) 47(-0.85,1.25) 48(-0.85,0.85)
  rect 4.343x4.343 smd: 49(2.2,3.05)
PDS5100H-13_POWERDI5-3
  rect 4.851x3.353 smd: 1(0,0)
  rect 1.397x1.397 smd: 2(3.982,-0.92) 3(3.982,0.92)
PDTA114EU_SC70-3
  oval 0.61x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
PESD5V0U2BT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PI3C3125LEX_TSSOP14
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(3.9,5.8) 9(3.25,5.8) 10(2.6,5.8) 11(1.95,5.8) 12(1.3,5.8) 13(0.65,5.8) 14(0,5.8)
PI3L720ZHEX_TQFN42_9X3P5
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 22(8,3.45) 23(7.5,3.45) 24(7,3.45) 25(6.5,3.45) 26(6,3.45) 27(5.5,3.45) 28(5,3.45) 29(4.5,3.45) 30(4,3.45) 31(3.5,3.45) 32(3,3.45) 33(2.5,3.45) 34(2,3.45) 35(1.5,3.45) 36(1,3.45) 37(0.5,3.45) 38(0,3.45)
  oval 1.041x0.254 smd: 18(8.475,0.975) 19(8.475,1.475) 20(8.475,1.975) 21(8.475,2.475) 39(-0.475,2.475) 40(-0.475,1.975) 41(-0.475,1.475) 42(-0.475,0.975)
  rect 7.544x2.057 smd: 43(4,1.725)
PI3V713-AZLEX_TQFN32_6X3
  oval 0.203x0.813 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 17(4,3.177) 18(3.6,3.177) 19(3.2,3.177) 20(2.8,3.177) 21(2.4,3.177) 22(2,3.177) 23(1.6,3.177) 24(1.2,3.177) 25(0.8,3.177) 26(0.4,3.177) 27(0,3.177)
  oval 0.813x0.203 smd: 12(5.088,0.789) 13(5.088,1.189) 14(5.088,1.589) 15(5.088,1.989) 16(5.088,2.389) 28(-1.089,2.389) 29(-1.089,1.989) 30(-1.089,1.589) 31(-1.089,1.189) 32(-1.089,0.789)
  rect 5.004x2.007 smd: 33(2,1.589)
PMST3904_SOT323-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
PMV65XP_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
