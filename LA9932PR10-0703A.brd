# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_AZ_CODEC_SDOUT: length 98.6
  TOP w0.102: v3(267.08,157.66) 267.39,157.97 U74.5
  IN1 w0.102: v3(182.1,139.3) 182.1,138.96 183.88,137.18 196.36,137.18 199.32,140.15 203.69,140.15 204.21,140.67 214.54,140.67 216.09,142.22 217.22,142.22 218.05,143.06 220.35,143.06 223.4,146.1 236.56,146.1 237.6,147.14 248.7,147.14 253.66,152.1 257.14,152.1 258.07,153.03 261.1,153.03 261.96,153.89 262.38,153.89 263.21,154.71 263.21,155.17 263.53,155.49 263.53,156.58 264.15,157.2 266.63,157.2 v3(267.08,157.66)
  BOTTOM w0.102: v3(182.1,139.3) 182.1,139.29 180.85,138.04 RPH10.2
PCH_AZ_CODEC_SYNC: length 95.3
  TOP w0.102: U74.10 267.39,155.47 267.27,155.35 263.73,155.35 263.58,155.5 262.51,155.5 v3(262.07,155.06)
  IN1 w0.102: v3(185.5,138.15) 194.36,138.15 195.65,139.44 197.25,139.44 198.92,141.11 203.29,141.11 203.81,141.63 214.14,141.63 215.69,143.18 216.82,143.18 217.98,144.35 220.28,144.35 223,147.07 236.16,147.07 238.14,149.05 249.24,149.05 254.06,153.86 255.56,153.86 256.68,154.99 262,154.99 v3(262.07,155.06)
  BOTTOM w0.102: v3(185.5,138.15) 185.24,137.89 182.46,137.89 v1(182.36,137.79) 181.6,137.04 RPH10.4
PCH_AZ_RST#: length 4.8
  BOTTOM w0.089: 178.31,137.55 178.09,137.76 177.45,137.76 177.22,137.54 176.53,137.54 176.44,137.45 175.66,137.45 175.36,137.76 UH1.C24
  BOTTOM w0.102: 178.31,137.55 178.32,137.54 RPH10.6
PCH_AZ_SDIN0_R: length 1.8
  TOP w0.102: R1096.2 266.71,156.2 267.21,156.2 267.48,156.47 U74.8
PCH_AZ_SDOUT: length 11.9
  BOTTOM w0.089: UH1.A24 177,137.76 177.28,138.04 178.31,138.04
  BOTTOM w0.102: RH45.2 185.27,137.07 184.98,137.37 v1(184.81,137.37) 184.3,137.37 RH35.2 183.4,136.46 180.36,136.46 179.9,136.93 179.9,137.91 179.77,138.04 RPH10.7 178.31,138.04
PCH_AZ_SYNC: length 4
  BOTTOM w0.089: 178.31,137.04 178.19,137.04 177.9,137.33 v1(177.78,137.33) 177.59,137.33 176.91,136.65 176.09,136.65 UH1.A22
  BOTTOM w0.102: RPH10.5 178.31,137.04
PCH_BATLOW#: length 14.6
  TOP w0.089: v3(172.16,130.67) 172,130.67 171.23,131.45 v1(170.8,131.45)
  TOP w0.102: RH112.2 v3(176.85,122.68)
  IN2 w0.089: v3(172.16,130.67) 172.4,130.67 172.59,130.48 172.59,129.78 172.34,129.53 172.34,128.77 173.55,127.56 173.55,126.62
  IN2 w0.127: v3(176.85,122.68) 176.72,122.81 176.72,125.5 175.61,126.61 174.61,126.61 174.34,126.34 173.69,126.34 173.55,126.48 173.55,126.62
  BOTTOM w0.089: UH1.K7 172.05,130.57 v3(172.16,130.67)
PCH_CL_CLK1: length 78.5
  IN1 w0.089: v3(164.72,132.07) 164.95,131.84 165.13,131.84 165.32,131.65 165.32,131.24 165.54,131.02 166.03,131.02 166.35,131.33 166.35,133.11 166.79,133.56 170.09,133.56 170.76,134.23 171.83,134.23 172.12,134.52 172.12,134.7 172.73,135.31 174.5,135.31 175.39,134.41 175.74,134.41 175.74,134.42 175.76,134.42
  IN1 w0.102: v3(216.3,139.18) 216.41,139.07 216.41,138.87 216.28,138.74 207.45,138.74 206.95,138.24 199.47,138.24 196.85,135.63 189.53,135.63 188.87,134.97 181.8,134.97 181.52,135.25 179.91,135.25 179.09,134.42 175.76,134.42
  BOTTOM w0.089: UH1.AF11 165.01,132.36 v3(164.72,132.07)
  BOTTOM w0.102: v3(216.3,139.18) 216.49,139.37 216.49,142.63 217.29,143.43 217.29,151.27 214.5,154.06 214.5,155.65 214.52,155.77 214.27,156.09 JMINI2.45
PCH_CL_DATA1: length 78.9
  IN1 w0.089: 175.76,134.19 175.74,134.19 175.74,134.2 175.31,134.2 174.41,135.09 172.82,135.09 172.34,134.61 172.34,134.43 171.92,134.01 170.85,134.01 170.18,133.34 166.88,133.34 166.56,133.02 166.56,131.24 166.12,130.8 165.45,130.8 165.11,131.15 165.11,131.56 165.04,131.62 164.96,131.62 v3(164.73,131.39)
  IN1 w0.102: 175.76,134.19 179.18,134.19 180.01,135.02 181.43,135.02 181.71,134.74 188.97,134.74 189.63,135.4 196.95,135.4 199.56,138.01 207.04,138.01 207.54,138.51 216.37,138.51 216.64,138.78 216.64,138.94 v3(216.88,139.18)
  BOTTOM w0.089: UH1.AF10 165.1,131.76 v3(164.73,131.39)
  BOTTOM w0.102: v3(216.88,139.18) 216.71,139.35 216.71,142.53 217.51,143.33 217.51,151.37 214.73,154.15 214.73,155.64 214.74,155.74 215.06,155.98 JMINI2.47
PCH_CL_RST1#: length 89.8
  IN1 w0.089: v3(164.72,130.8) 165.29,130.23 165.29,130.17 165.57,129.89 166.16,129.89 166.91,130.64 166.91,133.05 166.98,133.13 174.41,133.13 175.01,133.73 177.53,133.73
  IN1 w0.102: 177.53,133.73 179.13,133.73 179.33,133.53 179.33,133.28 179.58,133.02 180.65,133.02 182.01,134.38 189.11,134.38 189.77,135.04 197.09,135.04 199.71,137.66 216.61,137.66 v3(217.49,138.53)
  BOTTOM w0.089: v3(164.72,130.8) 164.95,130.57 UH1.AF7
  BOTTOM w0.102: v3(217.49,138.53) 217.92,138.53 218.38,138.99 218.38,140.95 218.82,141.39 218.82,150.8 222.25,154.23 222.25,158.97 219.22,162.01 v1(218.66,162.01) 217.54,162.01 R707.2
PCH_CLK_BIASREF: length 4.9
  BOTTOM w0.254: UH1.AN44 162.4,146.82 162.3,146.93 162.3,147.51 v1(160.85,148.96) 159.83,149.98 RH165.1
PCH_CRT_BLU: length 46.4
  IN4 w0.102: v3(172.09,149.66) 172.09,149.93 170.94,151.07 168,151.07 167.21,151.86 163.79,151.86 162.92,152.73 161.21,152.73 161.02,152.92 156.62,152.92 153.84,155.7 146.46,155.7 145.75,156.42 140.55,156.42 139.7,157.26 v3(139.7,157.41)
  BOTTOM w0.102: U6.5 138.26,154.7 139.7,156.14 v1(139.7,156.71) v3(139.7,157.41)
  BOTTOM w0.18: UH1.T45 169.33,147.03 170.88,148.58 171.18,148.58 172.09,149.48 v3(172.09,149.66) 172.09,149.72 171.55,150.26 RPH17.6
PCH_CRT_DDC_CLK: length 47.2
  IN4 w0.102: v3(173.26,148.35) 173.09,148.52 170.94,148.52 170.33,147.91 167.9,147.91 166.34,149.47 165.64,149.47 165.2,149.91 164.32,149.91 163.8,149.39 161.7,149.39 160.97,150.12 156.15,150.12 155.57,150.7 153.04,150.7 150.41,153.33 148.83,153.33 148.46,152.96 140.95,152.96 v3(140.77,152.78)
  BOTTOM w0.089: UH1.M43 170.96,146.22 171.26,146.52 171.26,146.81 171.95,147.51 171.95,147.95 172.56,148.55 173.05,148.55 v3(173.26,148.35)
  BOTTOM w0.102: RH88.2 174.6,150.09 174.6,149.27 173.82,148.49 173.41,148.49 v3(173.26,148.35) ; v3(140.77,152.78) 140.57,152.99 139.29,152.99 139.08,152.78 137.37,152.78 137.29,152.7 U6.10
PCH_CRT_DDC_DAT: length 46.2
  IN4 w0.102: v3(173.26,148.93) 173.08,148.75 170.84,148.75 170.23,148.14 167.99,148.14 166.43,149.7 165.74,149.7 165.29,150.14 164.23,150.14 163.7,149.62 161.8,149.62 161.07,150.35 156.24,150.35 155.67,150.93 153.13,150.93 150.51,153.56 148.74,153.56 148.37,153.19 140.95,153.19 v3(140.77,153.37)
  BOTTOM w0.089: v3(173.26,148.93) 173.1,148.77 172.47,148.77 171.74,148.04 171.74,147.6 170.96,146.82 UH1.M45
  BOTTOM w0.102: RH89.2 174.37,150.07 174.37,149.37 173.72,148.72 173.47,148.72 v3(173.26,148.93) ; U6.9 137.29,153.1 137.37,153.01 138.99,153.01 139.19,153.22 140.62,153.22 v3(140.77,153.37)
PCH_CRT_GRN: length 45
  IN4 w0.102: v3(139.09,157.41) 139.09,157.01 140.3,155.81 145.47,155.81 146.19,155.1 151.66,155.1 153.06,153.7 154.98,153.7 156.38,152.3 157.9,152.3 158.17,152.03 161.47,152.03 162.33,151.17 163.45,151.17 163.53,151.25 166.96,151.25 168.15,150.05 171.12,150.05 v3(171.52,149.66)
  BOTTOM w0.102: U6.2 137.16,155.9 137.34,156.07 137.86,156.07 139.09,157.3 v3(139.09,157.41)
  BOTTOM w0.18: RPH17.7 171.05,150.15 171.52,149.68 v3(171.52,149.66) 171.52,149.41 171.07,148.96 170.82,148.96 168.91,147.05 UH1.U44
PCH_CRT_HSYNC: length 42.1
  TOP w0.102: RH94.1 v3(173.14,151.95)
  IN4 w0.102: v3(140.97,157.98) 141.04,157.91 146.05,157.91 146.99,156.97 154.38,156.97 157.16,154.19 161.54,154.19 161.73,154 166.4,154 167.21,153.19 171.68,153.19 172.29,152.58 172.5,152.58 v3(173.14,151.95)
  BOTTOM w0.102: U6.6 139.08,154.3 v1(139.33,154.54) 140.59,155.8 140.59,157.6 v3(140.97,157.98)
PCH_CRT_RED: length 44.3
  IN4 w0.102: v3(138.05,157.53) 138.05,157.19 140.04,155.2 145.22,155.2 145.93,154.49 151.35,154.49 152.8,153.04 154.76,153.04 156.11,151.69 157.61,151.69 158.08,151.22 161.43,151.22 162.08,150.56 163.7,150.56 163.78,150.64 166.66,150.64 168.3,149 170.28,149 v3(170.94,149.66)
  BOTTOM w0.102: U6.1 137.13,156.3 v1(137.7,156.87) 138.05,157.22 v3(138.05,157.53)
  BOTTOM w0.18: UH1.V45 168.52,147.1 170.94,149.52 v3(170.94,149.66) 170.55,150.05 RPH17.8
PCH_CRT_VSYNC: length 41.7
  IN4 w0.102: v3(172.53,151.92) 171.35,151.92 171.31,151.96 168.44,151.96 167.68,152.72 166.99,152.72 166.12,153.6 161.57,153.6 161.38,153.79 156.99,153.79 154.2,156.57 146.82,156.57 145.88,157.51 141.26,157.51 v3(141.04,157.28)
  BOTTOM w0.102: RH95.1 172.75,151.32 172.53,151.54 v3(172.53,151.92) ; v3(141.04,157.28) v1(141.04,155.9) 141.04,155.67 139.25,153.89 138.18,153.89 138.18,153.9 U6.7
PCH_DDPB_CTRLCLK: length 203.3
  TOP w0.089: RH255.2 170.76,146.09 170.84,146.02 170.84,145.73 170.47,145.37 170.47,145.09 170.35,144.96 170.21,144.96 v3(170.08,145.09)
  TOP w0.102: U19.38 14.98,198.89 v3(14.88,198.98)
  IN4 w0.102: v3(14.88,198.98) 15.02,198.85 15.65,198.85 16.41,198.08 20.47,198.08 23.75,194.81 23.75,187.42 26.23,184.95 26.23,174.55 31.45,169.33 35.07,169.33 36.69,167.71 40.17,167.71 46.38,161.5 48.29,161.5 48.96,160.84 48.96,160.2 51.03,158.13 51.03,157.19 53.66,154.56 58.27,154.56 58.87,154.56 59.57,154.56 60.31,153.83 66.5,153.83 67.22,153.11 76.03,153.11 76.68,153.76 81.26,153.76 81.91,153.1 89.67,153.1 90.17,152.61 91.33,151.44 101.14,151.44 107.28,157.58 109.37,157.58 110.27,158.48 116.93,158.48 117.12,158.67 117.12,159.65 117.99,160.52 129.96,160.52 130.18,160.3 131.22,160.3 131.48,160.56 132.86,160.56 134.2,159.22 136.24,159.22 137.19,158.27 137.19,156.83 139.57,154.45 139.57,153.3 141.27,151.6 151.81,151.6 153.76,149.66 155.96,149.66 156.43,149.19 164.62,149.19 165.01,148.81 165.64,148.81 168.95,145.5 168.95,145.31 169.43,144.83 169.83,144.83 v3(170.08,145.09)
  BOTTOM w0.089: v3(170.08,145.09) 169.73,144.73 UH1.R40
PCH_DDPB_CTRLDATA: length 203.4
  TOP w0.089: RH256.2 171.26,145.85 170.69,145.28 170.69,145 v3(170.14,144.45)
  TOP w0.102: v3(14.88,198.4) 14.98,198.49 U19.39
  IN4 w0.102: v3(170.14,144.45) 169.99,144.6 169.33,144.6 168.72,145.21 168.72,145.41 165.55,148.58 164.91,148.58 164.53,148.96 156.33,148.96 155.86,149.43 153.66,149.43 151.72,151.37 141.18,151.37 139.35,153.2 139.35,154.35 136.96,156.74 136.96,158.18 136.15,158.99 134.11,158.99 132.76,160.33 131.58,160.33 131.32,160.07 130.08,160.07 129.87,160.29 118.09,160.29 117.35,159.55 117.35,158.57 117.03,158.25 110.36,158.25 109.47,157.36 107.37,157.36 101.23,151.21 91.24,151.21 89.94,152.51 89.58,152.87 81.81,152.87 81.16,153.53 76.77,153.53 76.12,152.88 67.12,152.88 66.41,153.6 60.21,153.6 59.47,154.33 58.96,154.33 58.36,154.33 53.57,154.33 50.8,157.1 50.8,158.04 48.73,160.11 48.73,160.74 48.2,161.27 46.28,161.27 40.07,167.48 36.59,167.48 34.98,169.1 31.36,169.1 26,174.46 26,184.85 23.52,187.33 23.52,194.71 20.38,197.86 16.32,197.86 15.55,198.62 15.1,198.62 v3(14.88,198.4)
  BOTTOM w0.089: UH1.R39 170.05,144.45 v3(170.14,144.45)
PCH_DDPC_CTRLCLK: length 20.5
  TOP w0.102: U20.12 v3(170.12,157.04)
  IN3 w0.127: v3(170.22,142.59) 170.22,143.68 169.08,144.82 169.08,145.85 168.2,146.73 168.2,149.47 169.17,150.43 v3(169.48,150.43)
  BOTTOM w0.089: UH1.R35 169.98,142.59 v3(170.22,142.59)
  BOTTOM w0.102: RP1.8 170.88,156.51 170.34,157.04 v3(170.12,157.04) v1(169.55,156.47) 169.55,150.5 v3(169.48,150.43)
PCH_DDPC_CTRLDATA: length 18.6
  TOP w0.089: v1(168.76,142.32) 168.95,142.32 v3(169.25,142.62)
  TOP w0.102: U20.9 170.91,155.09 170.61,155.39 v3(170.53,155.39)
  IN3 w0.127: v3(170.53,155.39) 167.93,152.8 167.93,146.51 168.71,145.73 168.71,143.68 169.25,143.14 v3(169.25,142.62)
  BOTTOM w0.089: UH1.R36 169.57,142.94 v3(169.25,142.62)
  BOTTOM w0.102: RP1.7 171.14,156.01 v3(170.53,155.39)
PCH_DDPD_CTRLCLK: length 19.5
  TOP w0.102: U23.12 172.9,155.74 172.72,155.57 172.72,154.3 171.6,153.18 170.66,153.18 170.21,152.72 v3(170.21,152.69)
  IN3 w0.089: v3(171.23,144.46) 170.71,144.98 170.71,145.72 170.54,145.9
  IN3 w0.127: v3(169.51,149.42) 169.51,146.93 170.54,145.9
  BOTTOM w0.089: v3(171.23,144.46) 170.97,144.46 UH1.N40
  BOTTOM w0.102: v3(169.51,149.42) 170.21,150.12 v3(170.21,152.69) 170.26,152.75 v1(170.26,154.43) 170.26,154.54 171.23,155.51 RP1.6
PCH_DDPD_CTRLDATA: length 23.4
  TOP w0.089: v3(171.18,143.24) 171.72,143.78 v1(171.72,144.21)
  TOP w0.102: U23.9 174.82,157.69 v3(175.14,157.37)
  IN3 w0.089: 170.47,145.33 170.47,144.74 170.66,144.55 170.66,143.75 v3(171.18,143.24)
  IN3 w0.127: 170.47,145.33 169.05,146.75 169.05,149.72 169.31,149.98 169.7,149.98 172.57,152.85 v3(172.57,153.05) 173.97,154.45 173.97,156.2 v3(175.14,157.37)
  BOTTOM w0.089: UH1.N38 170.9,143.53 170.9,143.52 v3(171.18,143.24)
  BOTTOM w0.102: RP1.5 172.38,155.01 172.57,154.82 v3(172.57,153.05)
PCH_DPWROK: length 105.2
  TOP w0.089: 175.21,126.62 174.93,126.62 174.5,127.05 174.5,127.82 174.31,128.01 174.31,129.47 173.98,129.8 173.98,130.73 173.6,131.12 172.72,131.12 172.59,131.25 171.95,131.25 171.71,131.5 171.71,131.88 171.86,132.04 v3(171.86,132.67)
  TOP w0.102: 175.21,126.62 177.13,124.7 177.48,124.7 177.67,124.51 177.67,123.8 RH79.1 177.74,122.72 RH120.2 ; v3(192.7,77.41) 192.53,77.24 R802.1
  IN4 w0.089: v3(171.86,132.67) 171.71,132.51 171.71,131.37 171.83,131.24 172.53,131.24 172.72,131.05 172.72,130.55 172.59,130.42 172.59,129.63 172.28,129.31 172.28,128.83 173.47,127.63 173.47,126.62
  IN4 w0.102: v3(175.26,75.34) 175.54,75.34 177.32,77.12 178.78,77.12 179.09,77.42 179.09,78.24 180.66,79.8 181.37,79.8 184.32,82.76 184.32,90.67 183.45,91.53 183.45,96.48 183.31,96.62 183.31,101.35 181.55,103.11 181.55,108.3 175.74,114.11 175.74,117.17 174.77,118.15 174.77,121.38 174.03,122.12 174.03,124.98 173.47,125.53 173.47,126.62
  BOTTOM w0.089: v3(171.86,132.67) 171.86,132.75 UH1.L13
  BOTTOM w0.102: v3(175.26,75.34) 175.26,77 v1(175.97,77.71) 177.1,78.84 190.98,78.84 192.42,77.41 v3(192.7,77.41)
PCH_GPIO06: length 18.5
  TOP w0.102: RPH19.2 187,136.02 186.74,135.77 186.74,135.28 188.51,133.52 v3(188.51,132.81)
  BOTTOM w0.089: UH1.A14 176.06,133.69 178.28,133.69 178.54,133.43 178.54,133.18
  BOTTOM w0.102: v3(188.51,132.81) 188.24,132.54 184.9,132.54 184.1,133.34 183.1,133.34 182.78,133.66 180.54,133.66 179.85,132.97 v1(179.58,132.97) 178.76,132.97 178.54,133.18
PCH_GPIO07: length 7.7
  TOP w0.089: v3(173.68,133.62) 174.72,133.62 174.95,133.86 177.31,133.86 177.56,134.1 v2(178.61,134.1) 179.26,134.1 179.38,134.22
  TOP w0.102: 179.38,134.22 179.46,134.3 179.46,134.31 179.78,134.62 RPH6.4
  BOTTOM w0.089: v3(173.68,133.62) 173.68,133.7 UH1.G15
PCH_GPIO15: length 16.9
  TOP w0.102: v3(171.02,121.75) 171.09,121.81 171.69,121.81 v1(171.72,121.78) 171.91,121.59 171.91,120.79 172.34,120.36 172.58,120.36 172.8,120.14 172.96,120.14 173.12,120.3 RPH15.1
  IN2 w0.089: 169.14,125.25 168.73,125.66 168.73,127.67 167.45,128.96 167.45,129.78 167.58,129.91 167.58,130.55 167.69,130.66 167.69,132.28 v3(167.31,132.67)
  IN2 w0.127: 169.14,125.25 170.87,123.52 170.87,121.9 v3(171.02,121.75)
  BOTTOM w0.089: v3(167.31,132.67) 167,132.36 UH1.AB11
PCH_GPIO22: length 92.1
  TOP w0.102: v3(153.18,125.47) 153.48,125.77 v2(153.48,125.95) RH331.2 RH332.2 153.77,128.41 154.08,128.41 156.36,130.7 157.94,130.7 v3(158.7,129.94) ; v3(218.12,100.56) 219.04,101.48 R3771.1
  IN1 w0.102: v3(218.12,100.56) 217.88,100.32 206.91,100.32 200.9,106.33 188.88,106.33 188.41,106.8 171.51,106.8 164.99,113.32 160.05,113.32 158.08,115.29 158.08,116.13 153.18,121.03 v3(153.18,125.47)
  BOTTOM w0.089: v3(158.7,129.94) 158.5,129.74 UH1.BB4
PCH_GPIO24: length 16.8
  TOP w0.102: RPH15.2 173.62,120.12 173.33,119.84 172.61,119.84 172.44,120 v1(171.86,120) 171.26,120.6 v3(171.26,121.11)
  IN2 w0.089: 169.14,125.77 169.06,125.84 169.06,128.47 168.66,128.88 168.66,131.74 v3(168.35,132.05)
  IN2 w0.127: v3(171.26,121.11) 171.27,121.11 171.45,121.29 171.45,122 171.31,122.14 171.31,123.59 169.14,125.77
  BOTTOM w0.089: UH1.Y10 168.06,131.76 v3(168.35,132.05)
PCH_GPIO33: length 5.1
  TOP w0.089: 177.22,135.74 176.88,135.74 v3(176.35,135.21)
  TOP w0.102: 177.22,135.74 177.57,135.74 v1(178.32,136.5) 178.83,137.01 RH40.2
  BOTTOM w0.089: UH1.B17 175.41,135 176.13,135 v3(176.35,135.21)
PCH_GPIO34: length 7
  TOP w0.089: 161.47,126.62 161.47,128.44 161.99,128.96 161.99,129.44 161.8,129.63 v3(161.8,130.08)
  TOP w0.102: RPH14.2 v1(161.86,125.72) 161.86,125.91 161.47,126.31 161.47,126.62
  BOTTOM w0.089: v3(161.8,130.08) 161.81,130.07 162.18,130.07 UH1.AN6
PCH_GPIO35: length 61.3
  TOP w0.102: v3(160.27,124.2) 159.81,124.67 159.45,124.67 159.38,124.59 RPH16.1
  IN3 w0.127: v3(160.27,124.2) 161.77,124.2 162.74,123.23 164.62,123.23 164.88,122.98 167.51,122.98 168.68,121.81 169.71,121.81 171.09,120.43 173.02,120.43 173.19,120.61 174.59,120.61 175.41,119.79 175.79,119.79 176.63,118.95 180.93,118.95 181.76,118.12 186.02,118.12 187.99,116.16 196.62,116.16 196.93,116.46 202.31,116.46 v3(202.44,116.59)
  BOTTOM w0.089: 161.43,126.62 161.43,127.35 162.02,127.94 UH1.AP1
  BOTTOM w0.102: RH25.1 201.4,109.68 201.09,109.98 201.09,110.73 203.04,112.68 203.04,115.99 v3(202.44,116.59) ; 161.43,126.62 161.43,126.05 160.85,125.47 160.85,124.96 v1(160.95,124.86) 160.95,124.6 160.55,124.2 v3(160.27,124.2)
PCH_GPIO36: length 62.4
  IN3 w0.127: v3(161.43,119.55) 161.63,119.35 163.83,119.35 165.04,118.14 166.08,118.14 167.82,116.4 169.66,116.4 170.78,115.28 173.75,115.28 174.02,115.01 184.31,115.01 186.05,113.27 199.98,113.27 v3(200.38,113.68)
  BOTTOM w0.089: UH1.AT3 161.21,128.48 161.51,128.17 161.51,127.93 160.97,127.4 160.97,126.62
  BOTTOM w0.102: RH12.1 201.41,106.63 200.22,107.83 v1(200.22,111.05) 200.22,113.51 v3(200.38,113.68) ; 159.4,121.61 160.02,122.23 160.02,122.74 159.77,122.99 159.77,125.04 160.97,126.24 160.97,126.62 ; 159.4,121.61 RH230.1 160.28,121.59 160.78,121.08 160.78,119.95 161.19,119.55 v3(161.43,119.55) ; 159.4,121.61 RH228.1
PCH_GPIO37: length 64.7
  IN3 w0.127: v3(201.49,117.4) 201.31,117.22 196.5,117.22 196.19,116.92 188.3,116.92 185.51,119.71 177.88,119.71 177.29,120.3 177.29,121.23 176.8,121.73 174,121.73 173.54,122.19 172.91,122.19 172.26,122.84 169.88,122.84 168.9,123.81 165.12,123.81 164.94,123.99 163.53,123.99 163.13,124.39 163.13,124.83 v3(163.14,124.83)
  BOTTOM w0.089: 163.13,125 163.13,125.15 163.07,125.21 163.07,126.93 163.19,127.05 163.19,127.43 163.37,127.61 163.37,127.62 163.65,127.9 UH1.AK1
  BOTTOM w0.102: v3(201.49,117.4) 201.49,115.81 v1(200.95,115.27) 199.2,113.53 199.2,107.46 201.04,105.62 RH14.1 ; 163.13,125 163.13,124.84 v3(163.14,124.83) 163.14,124.53 RH231.1 163.12,123.63 163.12,122.56 163.12,122.56 163.12,122.19 RH229.2
PCH_GPIO49: length 67.9
  IN3 w0.127: v3(162.68,125.72) 162.84,125.72 163.56,125 163.56,124.45 163.77,124.25 165.05,124.25 165.23,124.07 169.01,124.07 169.98,123.09 173.62,123.09 173.76,122.95 173.76,122.33 174.11,121.99 176.9,121.99 178.16,120.73 178.16,120.46 178.65,119.97 185.62,119.97 188.41,117.17 196.09,117.17 196.39,117.48 199.44,117.48 v3(199.61,117.64)
  BOTTOM w0.089: UH1.AK3 163.6,128.89 163.6,128.42 163.32,128.14 163.32,127.85 163.14,127.67 163.14,127.67 163.02,127.55 163.02,127.13 162.68,126.79 v3(162.68,125.72) 162.7,125.7 162.7,125.03
  BOTTOM w0.102: v3(199.61,117.64) v1(199.61,116.7) 199.61,115.34 198.73,114.47 198.73,104.7 199.85,103.59 RH19.1 ; RH227.1 161.91,121.67 161.67,121.91 161.67,123.2 162.56,124.08 RH225.1 162.7,124.16 162.7,125.03
PCH_GPIO55: length 16.4
  TOP w0.089: v1(162.73,130.75) 162.76,130.71 v3(162.76,130.16)
  TOP w0.102: v3(161.45,120.13) 161.27,120.32 161.27,121.15 161.79,121.67 RH76.1
  IN2 w0.089: 161.29,129.72 161.29,130.86 161.48,131.05 162.18,131.05 162.76,130.47 v3(162.76,130.16)
  IN2 w0.127: 161.29,129.72 160.77,129.2 160.77,124.3 161.2,123.87 161.2,120.38 v3(161.45,120.13)
  BOTTOM w0.089: v3(162.76,130.16) 163.06,130.16 UH1.AL6
PCH_GPIO69: length 7.1
  TOP w0.089: v3(177.52,133.01) 177.58,132.94 178.48,132.94 178.94,132.47 v1(178.94,132.26) 178.94,131.94 179.24,131.64 179.37,131.64
  TOP w0.102: 179.37,131.64 179.38,131.64 RPH13.4
  BOTTOM w0.089: v3(177.52,133.01) 177.19,133.34 176.16,133.34 176,133.18 175.68,133.18 175.51,133.01 175.48,133.01 175.47,133.01 175.23,133.01 174.95,133.29 UH1.D13
PCH_GPIO70: length 8.8
  TOP w0.089: v3(173.05,132.66) 173.42,133.04 173.94,133.04 174.04,133.14 175.12,133.14 175.36,133.38 v1(176.46,133.38) 177.53,133.38 177.84,133.69 178.15,133.69 178.54,133.3 178.54,133.19 179.09,132.64 179.38,132.64
  TOP w0.102: RPH13.2 179.38,132.64
  BOTTOM w0.089: v3(173.05,132.66) 173.27,132.88 UH1.G13
PCH_GPIO71: length 9.5
  TOP w0.089: v1(172.65,133.2) 172.65,133.21 v3(173.04,133.61) 173.17,133.61 173.56,133.21 173.87,133.21 173.97,133.31 174.98,133.31 175.35,133.68 177.57,133.68 177.77,133.87 178.24,133.87 178.36,133.74 179.06,133.74 179.29,133.5 179.29,133.31 179.38,133.23
  TOP w0.102: RPH13.1 180.02,133.14 179.91,133.02 179.59,133.02 179.38,133.23
  BOTTOM w0.089: v3(173.04,133.61) 173.03,133.61 173.03,133.75 UH1.H15
PCH_INTVRMEN: length 7.8
  TOP w0.089: 177.22,127.96 177.14,127.88 176.62,127.88 176.56,127.82 176.21,127.82 175.96,128.07 v1(175.96,128.77) 175.96,129.27 175.04,130.2 174.77,130.2 174.16,130.81 174.16,130.81 173.67,131.29 173.1,131.29 v3(172.72,131.67)
  TOP w0.102: RH5.2 177.22,127.96
  BOTTOM w0.089: v3(172.72,131.67) 173.21,132.16 UH1.G10
PCH_JTAG_RST: length 61.8
  TOP w0.089: v3(167.2,130.23) 167.32,130.23 v2(167.65,129.9)
  IN4 w0.102: v3(167.2,130.23) 167.2,128.32 167.9,127.63 167.9,123.18 168.56,122.51 168.56,122.25 169.85,120.95 169.85,120.32 169.03,119.5 169.03,119.32 167.45,117.74 167.45,114.54 168.93,113.06 170.06,113.06 171.58,111.54 v3(171.58,110.35)
  BOTTOM w0.089: v3(167.2,130.23) 167.2,130.23 167.2,130.07 167.1,129.97 UH1.AB6
  BOTTOM w0.102: RH32.2 202.07,97.4 196.39,97.4 191.2,102.58 184.16,102.58 176.38,110.35 v3(171.58,110.35)
PCH_JTAG_RST_R: length 3
  BOTTOM w0.102: JXDP2.54 204.95,97.38 204.85,97.29 v1(204.28,97.29) 203.46,97.29 RH32.1
PCH_JTAG_TCK: length 72
  TOP w0.102: v3(167.6,121.84) 167.61,121.85 167.61,121.85 168,122.24 v2(168,122.78)
  IN4 w0.102: v3(171.52,109.06) 171.03,109.54 171.03,111.41 169.86,112.58 167.61,112.58 166.47,113.72 166.47,115.26 166.97,115.75 166.97,118.14 167.01,118.18 167.01,121.25 v3(167.6,121.84)
  BOTTOM w0.089: UH1.AB3 166.9,128.46 167.19,128.16 167.19,125.87 166.72,125.39 166.72,125
  BOTTOM w0.102: JXDP2.57 208.47,96.38 207.65,95.56 196.4,95.56 192.01,99.94 184.96,99.94 181.75,103.15 180.81,103.15 174.9,109.06 v3(171.52,109.06) ; 166.72,125 166.72,124.56 RH47.1 167.72,123.56 167.72,121.96 v3(167.6,121.84)
PCH_JTAG_TDI: length 69.9
  TOP w0.102: v3(165.83,125.48) 166.28,125.48 v2(166.44,125.31) 166.75,125.01 RH55.1 167.41,123.42 167.41,122.34 166.87,121.8 RH50.2
  IN4 w0.089: v3(165.83,125.48) 166.3,125
  IN4 w0.102: 166.3,125 166.39,124.92 166.39,124.1 165.71,123.43 165.71,122.02 165.99,121.74 165.99,119.64 165.71,119.36 165.71,115.91 165.32,115.52 165.32,113.62 167.24,111.69 169.49,111.69 170.13,111.05 170.13,110.58 v3(170.53,110.18)
  BOTTOM w0.089: UH1.AE2 165.76,128.43 165.76,128.35 165.57,128.16 165.57,127.91 165.39,127.74 165.37,127.74 165.26,127.63 165.26,126.89 165.26,126.88 165.26,126.42
  BOTTOM w0.102: v3(165.83,125.48) 165.26,126.04 165.26,126.42 ; v3(170.53,110.18) 170.59,110.18 170.81,109.95 176.22,109.95 183.99,102.17 191.04,102.17 196.76,96.45 203.4,96.45 203.6,96.65 203.84,96.88 JXDP2.56
PCH_JTAG_TDO: length 69.8
  TOP w0.102: RH56.1 164.1,122.29 164.1,123.46 RH52.2 164.72,126.05 v2(165.22,126.55) 165.36,126.69 v3(165.84,126.69)
  IN4 w0.102: v3(170.55,110.76) 170.55,111.21 169.66,112.1 167.41,112.1 165.72,113.78 165.72,115.35 166.16,115.78 166.16,118.21 166.52,118.58 166.52,123.66 166.79,123.93 166.79,125.75 v3(165.84,126.69)
  BOTTOM w0.089: UH1.AD3 166.08,128.48 166.24,128.32 166.24,128.3 166.38,128.16 166.38,127.91 166.24,127.78 166.24,127.09 165.85,126.69 v3(165.84,126.69)
  BOTTOM w0.102: JXDP2.52 204.93,97.88 204.85,97.81 196.55,97.81 191.37,102.99 184.33,102.99 176.55,110.76 v3(170.55,110.76)
PCH_JTAG_TMS: length 70.2
  TOP w0.102: RH48.2 165.55,122.64 165.33,122.85 165.33,123.61 RH54.1 165.29,124.59 165.29,125.57 v3(165.84,126.11) ; v2(169.89,109.59) v3(170.53,109.59)
  IN4 w0.089: v3(165.84,126.11) 165.3,125.58 165.3,125
  IN4 w0.102: 165.3,125 165.3,121.83 165.58,121.55 165.58,119.83 165.3,119.55 165.3,116.08 164.91,115.69 164.91,113.45 167.08,111.28 169.32,111.28 169.72,110.88 169.72,110.4 v3(170.53,109.59)
  BOTTOM w0.089: 165.47,126.62 165.47,127.55 165.96,128.04 UH1.AD1
  BOTTOM w0.102: v3(165.84,126.11) 165.47,126.48 165.47,126.62 ; JXDP2.58 203.91,96.38 203.57,96.04 196.6,96.04 190.87,101.77 183.82,101.77 176.05,109.54 170.65,109.54 170.6,109.59 v3(170.53,109.59)
PCH_PCIE_IREF: length 3.3
  BOTTOM w0.305: RH188.2 v1(155.01,140.18) 155.87,140.18 155.92,140.13 157.12,140.13 UH1.BE30
PCH_PCIE_RCOMP: length 3.2
  TOP w0.089: v2(156.86,141.77) RH192.2
  TOP w0.381: RH192.2 156.86,139.82 v3(156.68,139.63)
  BOTTOM w0.254: v3(156.68,139.63) 156.81,139.77 UH1.BD29
PCH_PCIE_WAKE#: length 85.5
  TOP w0.102: U51.A44 207.93,85.31 207.63,85.6 v3(207.39,85.6)
  IN1 w0.102: v3(171.99,122.42) 172.15,122.25 173.1,122.25 173.96,121.39 175.4,121.39 175.85,121.85 177.3,121.85 177.66,121.49 179.36,121.49 179.66,121.19 186.92,121.19 187.94,122.21 198.6,122.21 v3(200.2,120.61)
  IN4 w0.102: v3(207.39,85.6) 207.64,85.6 208.28,86.24 208.28,89.14 208.41,89.27 208.41,89.97 209.48,91.04 209.73,91.04 210.59,91.9 210.59,92.99 206.7,96.88 202.06,96.88 200.88,98.06 200.88,100.54 200.56,100.85 200.56,113.12 201,113.57 201,119.81 v3(200.2,120.61)
  BOTTOM w0.089: UH1.K3 171.68,128.85 171.68,128.38 171.45,128.15 171.45,127.18 171.94,126.7 171.94,126.62
  BOTTOM w0.102: RH78.2 RH92.2 ; RH78.2 173.61,124.61 171.94,126.28 171.94,126.62 ; RH78.2 173.05,124.21 v1(172.59,123.75) 172.59,122.86 172.15,122.42 v3(171.99,122.42)
PCH_PLTRST#: length 164.4
  TOP w0.102: v3(98.87,97.58) 97.17,97.58 96,98.75 96,113.33 97.6,114.93 97.6,121.91 96.89,122.62 96.89,138.25 97.14,138.5 97.14,140.71 97.6,141.17 97.6,141.95 102.21,146.56 110.41,146.56 110.79,146.94 116,146.94 119.03,149.96 120.74,149.96 122.42,151.65 v1(126.62,151.65) 129.12,151.65 133.23,147.54 137.16,147.54 137.41,147.29 v3(138.47,147.29) ; UH3.2 160.72,118.93 160.97,119.18 160.97,119.58 ; RH111.2 160.78,121.1 160.78,120.01 160.97,119.81 160.97,119.58 ; RH111.2 RH110.2 RH113.2 RH114.2 RH109.2 157.25,122.14 157.25,123.15 156.67,123.74 QH2.2 156.67,124.98 156.46,125.2 155.11,125.2 153.98,124.07 150.6,124.07 146.72,127.95 v3(146.72,141.44) ; RH111.2 160.28,123.18 160.28,123.18 160.28,123.2 v3(160.44,123.37) ; 160.97,119.58 UH3.1
  IN4 w0.089: 162.06,125.61 162.24,125.79 162.24,125.97 164.22,127.95 164.22,129.72 164.34,129.85 164.34,132.92 164.53,133.11 167.89,133.11 v3(168.32,132.67)
  IN4 w0.102: v3(160.44,123.37) 161.03,123.37 161.86,124.2 161.86,125.41 162.06,125.61 ; v3(146.72,141.44) 143.31,141.44 138.47,146.29 v3(138.47,147.29)
  BOTTOM w0.089: v3(168.32,132.67) 168.01,132.36 UH1.Y11
  BOTTOM w0.102: v3(98.87,97.58) 100.27,96.18 UC2.2
PCH_PLTRST#_BUF: length 5
  BOTTOM w0.102: RC67.1 104.25,97.71 RC60.2 103.19,96.83 UC2.4 ; RC67.1 104.26,98.65 RC64.1 ; RC67.1 102.62,97.72 v1(102.27,98.06)
PCH_PLTRST#_EC: length 341.3
  TOP w0.102: U46.B22 187.87,71.65 v3(188.36,71.16) ; v3(208.85,108.7) 209.41,108.15 U39.16 ; v3(213.62,80.66) 213.75,80.79 U51.B30 ; UH3.4 162.18,116.71 v3(161.86,116.4) ; U41.6 231.87,63.98 230.95,64.9 230.95,66.12 231.57,66.74 231.57,69.15 232.48,70.06 232.48,74.35 v1(231.55,75.27) 231.55,77.5 v3(231.9,77.85)
  IN1 w0.102: v3(161.86,116.4) 161.86,116.07 162.84,115.09 165.05,115.09 168.58,111.56 179.58,111.56 180.31,110.83 188.44,110.83 189.13,110.14 202.08,110.14 202.92,109.3 208.26,109.3 v3(208.85,108.7) ; v3(188.36,71.16) 187.9,71.62 187.9,72.44 188.77,73.32 188.77,74.58 189.69,75.49 189.69,76.46 193.05,79.82 193.05,81.4 194.1,82.44 197.27,82.44 197.49,82.22 200.09,82.22 202.16,84.29 206.3,84.29 207.65,82.95 207.65,82.03 208.01,81.66 211.7,81.66 212.22,81.14 213.13,81.14 v3(213.62,80.66) 215.18,80.66 215.79,81.27 221.87,81.27 223.54,79.61 227.08,79.61 228.84,77.85 v3(231.9,77.85) ; v3(200.51,143.73) 201.56,142.69 212,142.69 213.46,144.15 216.42,144.15 220.3,148.03 235.76,148.03 239.81,152.09 243.94,152.09 244.67,152.82 249.43,152.82 251.39,154.78 252.33,154.78 253.23,155.68 255,155.68 255.99,156.66 259.76,156.66 262.92,159.83 262.92,160.79 264.62,162.49 265.32,162.49 269.27,166.45 271.11,166.45 v3(271.97,167.31)
  IN2 w0.127: v3(271.97,167.31) 271.97,169.09 268.23,172.84 268.23,175.89 269.43,177.09 v3(269.43,190.06)
  IN4 w0.102: v3(213.62,80.66) 214.02,81.07 214.02,83.6 214.8,84.37 214.8,89.35 214.1,90.05 214.1,91.13 206.88,98.35 206.88,104.57 208.85,106.54 v3(208.85,108.7) 208.03,108.7 203.01,113.72 203.01,122.82 200.15,125.67 200.15,142.61 200.51,142.96 v3(200.51,143.73) ; v3(276.32,174.55) 278.13,174.55 279.73,176.15 v3(287.66,176.15)
  BOTTOM w0.102: v3(269.43,190.06) R704.1 ; JMINI3.22 276.72,174.15 v3(276.32,174.55) 275.63,174.55 274.87,173.79 272.48,173.79 271.81,173.12 271.81,167.48 v3(271.97,167.31) ; v3(287.66,176.15) JMINI3.17 ; v3(200.51,143.73) 200.93,143.31 202.89,143.31 203.52,143.94 203.52,145.99 R703.1
PCH_PWRBTN#_XDP: length 3.6
  BOTTOM w0.102: RH28.2 214.24,98.89 v1(213.59,99.53) 213.59,99.9 213.11,100.38 JXDP2.41
PCH_PWROK: length 14.1
  TOP w0.102: RH103.2 184.4,130.74 v3(184.53,130.61)
  IN1 w0.089: v3(173.28,131.67) 173.66,131.29 174.04,131.29 174.37,131.63 175.59,131.63 176.4,130.81 176.71,130.81 177.06,130.46 178.75,130.46
  IN1 w0.102: 178.75,130.46 179.44,130.46 180.14,131.16 183.98,131.16 v3(184.53,130.61)
  BOTTOM w0.089: UH1.F10 173.69,132.16 173.51,131.97 173.28,131.74 v3(173.28,131.67)
PCH_RI#: length 13.5
  BOTTOM w0.089: 170.58,126.62 170.58,127.74 170.48,127.83 170.48,128.12 170.28,128.33 170.28,128.61 170.55,128.89 UH1.N4
  BOTTOM w0.102: 170.58,126.62 170.58,125.4 170.56,125.39 v1(170.56,125.09) 170.56,124.59 169.89,123.92 169.89,120.1 168.36,118.57 167.66,118.57 167.31,118.22 RPH1.1
PCH_RSMRST#: length 71.6
  TOP w0.102: v3(208.15,82.15) 207.68,82.62 U51.B47 ; U9.1 175.35,118.69 R1623.1 175.28,119.19 175.45,119.37 v3(175.62,119.37) ; RP17.5 212.89,90.59 212.8,90.68 v3(211.81,90.68)
  IN4 w0.102: v3(184.81,95.46) 184.81,96.28 183.77,97.32 183.77,101.54 182.01,103.3 182.01,108.49 176.2,114.3 176.2,117.36 175.62,117.94 v3(175.62,119.37) ; v3(211.81,90.68) 210.49,90.68 208.71,88.9 v3(208.71,86.21) 208.03,85.52 208.03,84.45 207.77,84.19 207.77,82.52 v3(208.15,82.15)
  BOTTOM w0.102: v3(184.81,95.46) 185.47,95.46 v1(188.03,92.9) 189.41,91.52 197.87,91.52 199.79,89.6 202.64,89.6 206.04,86.21 v3(208.71,86.21)
PCH_RSMRST#_Q: length 79.9
  TOP w0.102: RH105.1 176.28,122.36 175.81,121.88 175.81,120.86 176.02,120.64 176.02,120.13 175.74,119.85 175.22,119.85 174.67,119.31 v3(174.36,119.31) R1623.2 ; v3(182.59,118.54) 182.59,118.13 v1(182.31,117.85) 181.85,117.39 R1636.2 180.8,117.02 R1624.1 180.23,117.32 179.83,117.72 179.01,117.72 178.68,117.39 U9.4
  IN1 w0.102: v3(213.82,119.62) 213.02,120.41 209.08,120.41 208.6,119.93 194.25,119.93 193.44,120.73 188.61,120.73 187.77,119.89 183.94,119.89 v3(182.59,118.54)
  BOTTOM w0.102: v3(182.59,118.54) 182.03,117.98 175.68,117.98 v3(174.36,119.31) ; v3(213.82,119.62) 214.58,119.62 219.69,114.51 219.69,101.27 218.32,99.9 RH26.1
PCH_RSMRST#_R: length 7.7
  TOP w0.102: v3(175.07,125.85) 175.17,125.85 v1(175.84,125.18) 176.28,124.74 RH105.2 RH79.2
  BOTTOM w0.089: 173.17,126.62 172.71,127.08 172.71,127.46 172.27,127.91 172.27,128.43 UH1.J2
  BOTTOM w0.102: v3(175.07,125.85) 173.74,125.85 173.23,126.36 173.23,126.56 173.17,126.62
PCH_RTCRST#: length 95.3
  TOP w0.089: 177.11,130.87 176.58,131.39 v3(176.61,131.39)
  TOP w0.102: RH44.2 178.84,127.97 CH7.2 178.61,129.06 CMOS1.2 178.61,130.32 178.43,130.5 177.47,130.5 177.11,130.87 ; JAPS1.9 227.83,97.4 226.52,98.71 v2(223.1,98.71) v3(221.77,98.71)
  IN1 w0.089: 178.75,130.94 177.03,130.94 176.58,131.39 v3(176.61,131.39)
  IN1 w0.102: 178.75,130.94 179.24,130.94 179.94,131.64 196.23,131.64 199.77,135.18 202.72,135.18 203.84,136.3 v3(205.42,136.3)
  IN4 w0.102: v3(221.77,98.71) 221.77,99.83 219.69,101.91 219.69,115.97 219.01,116.64 219.01,119.3 216.98,121.34 214.77,121.34 211.29,124.81 211.29,127.02 206.83,131.48 206.83,132.89 205.42,134.3 v3(205.42,136.3)
  BOTTOM w0.089: UH1.D9 174.94,131.66 175.22,131.38 175.49,131.38 175.67,131.56 176.44,131.56 v3(176.61,131.39)
PCH_RTCX1: length 10
  TOP w0.089: 176.94,126.62 176.59,126.62 175.39,127.81 175.39,129.02 174.79,129.62 v3(174.79,129.7)
  TOP w0.102: RH38.2 181.31,125.53 RH39.1 v1(179.39,125.99) 177.99,125.99 177.75,126.23 177.33,126.23 176.94,126.62
  BOTTOM w0.089: v3(174.79,129.7) 175.09,130 UH1.B5
PCH_RTCX1_R: length 3.3
  TOP w0.102: YH1.1 183.7,123.94 183.5,124.13 CH4.2 RH38.1
PCH_RTCX2: length 11
  TOP w0.089: 176.07,126.62 175.39,127.3 175.39,127.5 174.8,128.09 v3(174.8,129.02)
  TOP w0.102: 176.07,126.62 177.07,125.62 v1(177.45,125.62) 177.99,125.07 RH39.2 CH5.2 181.75,124.21 YH1.2
  BOTTOM w0.089: UH1.B4 175.14,129.35 v3(174.8,129.02)
PCH_SATA_MOD_EN#: length 102.2
  TOP w0.102: QH2.3 155.37,123.93 154.94,123.5 154.94,122.47 v3(155.37,122.04) ; U51.B36 213.18,82.82 v3(213.08,82.73)
  IN2 w0.127: v3(214.72,111.41) 215.24,110.89 215.24,108.66 214.29,107.7 214.29,96.28 213.89,95.88 213.89,90.2 213.43,89.73 213.43,87.96 212.26,86.79 212.26,83.75 212.52,83.49 213.08,82.92 v3(213.08,82.73)
  IN3 w0.127: v3(214.72,111.41) 214.72,110.95 213.69,109.92 208.05,109.92 205.72,112.26 185.6,112.26 184.62,113.24 178.54,113.24 177.78,114 173.6,114 173.4,114.19 168.59,114.19 167.07,115.71 166.35,115.71 165.67,116.39 165.67,116.96 165.25,117.38 164.73,117.38 163.52,118.59 161.08,118.59 160.99,118.67 160.28,119.39 160.28,119.98 159.34,120.92 155.53,120.92 155.2,121.25 155.2,121.86 v3(155.37,122.04)
  BOTTOM w0.102: v1(214.31,83.05) 214.26,83.1 213.36,83.1 213.08,82.82 v3(213.08,82.73)
PCH_SMB_ALERT#: length 23
  TOP w0.089: v3(171.2,130.16) 171.38,130.16 v1(171.65,130.43)
  TOP w0.102: RPH21.6 187.58,133.09 v3(187.42,133.24)
  IN3 w0.089: 178.75,130.33 176.16,130.33 174.93,131.56 174.31,131.56 174.03,131.28 172.49,131.28 172.38,131.17 172.02,131.17 171.71,130.86 171.71,130.67 v3(171.2,130.16)
  IN3 w0.127: 178.75,130.33 179.13,130.33 179.76,130.97 183.04,130.97 183.38,131.31 185.68,131.31 186.37,132 186.37,133.76 186.63,134.01 187.2,134.01 187.42,133.79 v3(187.42,133.24)
  BOTTOM w0.089: v3(171.2,130.16) 171.12,130.16 UH1.N7
PCH_SPI_CLK: length 69.2
  TOP w0.102: RH181.2 213.5,135.37 213.13,135 JSPI1.8 211.15,135 v3(211.01,134.86)
  IN1 w0.089: 170.22,128.51 171.17,127.56 172.28,127.56 172.59,127.24 172.59,126.8 172.78,126.62 ; v3(163.74,132.11) 164.15,131.7 164.15,130.7 164.31,130.54 164.31,129.88 164.21,129.78 164.21,129.39 164.72,128.89
  IN1 w0.102: 170.22,128.51 167.83,128.51 167.46,128.89 164.72,128.89 ; 172.78,126.62 173.04,126.36 174.34,126.36 174.85,126.86 176.98,126.86 177.56,127.45 182.26,127.45 182.56,127.75 182.91,127.75 183.01,127.65 183.01,127.13 183.14,127 183.39,127 183.52,127.13 183.52,127.65 183.62,127.75 183.92,127.75 184.02,127.65 184.02,127.13 184.15,127 184.41,127 184.53,127.13 184.53,127.65 184.63,127.75 186.06,127.75 186.16,127.65 186.16,127.13 186.29,127 186.54,127 186.67,127.13 186.67,128.01 186.79,128.13 187.05,128.13 187.17,128.01 187.17,127.13 187.3,127 187.56,127 187.68,127.13 187.68,128.07 187.81,128.2 188.16,128.2 188.26,128.09 188.26,127.56 188.37,127.46 188.67,127.46 188.77,127.56 188.77,128.09 188.87,128.2 189.18,128.2 189.28,128.09 189.28,127.13 189.41,127 189.66,127 189.79,127.13 189.79,128.09 189.89,128.2 196.98,128.2 204.26,135.47 210.66,135.47 211.01,135.12 v3(211.01,134.86)
  BOTTOM w0.089: UH1.AJ11 163.98,132.11 v3(163.74,132.11)
PCH_SPI_CS0#: length 60
  TOP w0.102: RH182.2 214.52,134 v1(213.55,134) JSPI1.10 210.86,134 210.38,134.48 v3(210.38,134.86)
  IN1 w0.089: 164.09,128.2 163.74,128.54 v3(163.74,130.16)
  IN1 w0.102: v3(210.38,134.86) 209.68,134.17 205.93,134.17 204.79,133.02 203.22,133.02 197.34,127.14 191.54,127.14 190.43,126.04 178.71,126.04 176.95,124.27 174.49,124.27 173.55,125.22 172.54,125.22 169.87,127.89 167.31,127.89 167.01,128.2 164.09,128.2
  BOTTOM w0.089: UH1.AJ7 164.05,130.57 163.74,130.25 v3(163.74,130.16)
PCH_SPI_CS1#: length 61
  TOP w0.102: RH177.2 213.93,139.18 212.75,138 JSPI1.2 211.43,138 208.93,135.51 v3(208.93,134.86)
  IN1 w0.089: v3(163.71,130.86) 164.11,130.46 164.11,129.96 163.96,129.8 163.96,128.96 164.34,128.58
  IN1 w0.102: v3(208.93,134.86) 208.59,134.52 204.22,134.52 197.19,127.5 191.39,127.5 190.29,126.39 178.56,126.39 177.47,125.3 174.04,125.3 173.76,125.58 172.69,125.58 170.01,128.26 167.45,128.26 167.13,128.58 164.34,128.58
  BOTTOM w0.089: UH1.AL7 163.55,130.86 v3(163.71,130.86)
PCH_SPI_DIN: length 61.9
  TOP w0.102: RH179.2 214.34,136.36 v1(213.62,136.36) 213.12,136.36 212.76,136 JSPI1.6 210.43,136 209.7,135.27 v3(209.7,132.77)
  IN1 w0.102: v3(164.39,127.1) 165.04,127.75 166.88,127.75 167.82,126.81 168.62,126.81 170.01,125.42 170.39,125.42 170.59,125.62 171.24,125.62 171.99,124.87 173.4,124.87 174.35,123.92 177.09,123.92 178.86,125.68 190.58,125.68 191.69,126.79 197.49,126.79 203.37,132.67 204.94,132.67 205.91,133.64 208.83,133.64 209.7,132.77 v3(209.7,132.77)
  BOTTOM w0.089: v3(164.39,127.1) 164.44,127.1 164.62,127.27 164.62,127.77 164.76,127.91 164.76,128.17 164.46,128.47 164.46,128.94 UH1.AH3
PCH_SPI_DO: length 63.4
  TOP w0.102: RH178.2 213.66,137.91 v1(213.5,137.75) 212.76,137 JSPI1.4 210.93,137 209.34,135.41 209.34,133 v3(209.12,132.78)
  IN1 w0.102: v3(164.29,125.97) 164.45,125.81 164.77,125.81 164.9,125.94 164.9,126.29 165.03,126.42 165.23,126.42 165.36,126.29 165.36,124.66 165.66,124.35 167.64,124.35 167.67,124.39 173.37,124.39 174.2,123.56 177.24,123.56 179.01,125.33 190.73,125.33 191.83,126.43 197.64,126.43 203.06,131.85 208.19,131.85 v3(209.12,132.78)
  BOTTOM w0.089: UH1.AH1 164.39,127.97 164.39,127.57 164.29,127.48 164.02,127.48 163.77,127.23 163.77,126.86 163.7,126.8 163.7,126.08 163.81,125.97 v3(164.29,125.97)
PCH_SPI_DO2: length 66.1
  TOP w0.102: v3(210.88,132.72) 211.16,133 JSPI1.12 214.45,133 RH183.2
  IN1 w0.102: v3(164.17,124.67) 164.34,124.67 165.36,123.64 167.93,123.64 167.97,123.68 173.08,123.68 173.93,122.83 173.93,122.59 174.27,122.25 179.35,122.25 179.64,122.55 180.17,122.55 180.81,121.9 187.12,121.9 187.79,122.57 194.78,122.57 202.57,130.36 207.75,130.36 207.85,130.46 207.85,131.02 207.98,131.14 208.23,131.14 208.36,131.02 208.36,130.46 208.46,130.36 208.76,130.36 208.87,130.46 208.87,131.02 208.99,131.14 209.25,131.14 209.37,131.02 209.37,130.48 209.5,130.36 209.81,130.36 209.93,130.48 209.93,131.02 210.06,131.14 210.75,131.14 210.88,131.27 v3(210.88,132.72)
  BOTTOM w0.089: UH1.AJ4 164.05,128.92 163.77,128.65 163.77,128.34 163.98,128.13 163.98,127.94 163.41,127.38 163.41,127.01 163.31,126.9 163.31,125.37 v1(163.49,125.19) 163.68,125
  BOTTOM w0.102: v3(164.17,124.67) 164.01,124.67 163.68,125
PCH_SPI_DO3: length 67.5
  TOP w0.102: v3(210.28,132.74) 210.28,132.1 210.38,132 JSPI1.14 v1(213.55,132) 214,131.56 RH184.2
  IN1 w0.102: v3(163.83,125.59) 164.72,125.59 165,125.31 165,124.51 165.51,124 167.79,124 167.82,124.03 173.23,124.03 174.05,123.21 180.01,123.21 180.96,122.26 186.98,122.26 187.64,122.93 194.63,122.93 202.42,130.71 203.21,130.71 203.31,130.81 203.31,131.4 203.41,131.5 203.71,131.5 203.82,131.4 203.82,130.81 203.92,130.71 204.22,130.71 204.32,130.81 204.32,131.4 204.43,131.5 204.73,131.5 204.83,131.4 204.83,130.81 204.93,130.71 205.24,130.71 205.34,130.81 205.34,131.4 205.44,131.5 205.75,131.5 205.85,131.4 205.85,130.81 205.95,130.71 206.25,130.71 206.36,130.81 206.36,131.4 206.46,131.5 206.76,131.5 206.86,131.4 206.86,130.81 206.97,130.71 207.27,130.71 207.39,130.84 207.39,131.37 207.52,131.5 210.16,131.5 210.28,131.63 v3(210.28,132.74)
  BOTTOM w0.089: v3(163.83,125.59) 163.49,125.94 163.49,126.83 163.59,126.94 163.59,127.3 164.16,127.87 164.16,128.41 UH1.AJ2
PCH_TD_IREF: length 9.7
  BOTTOM w0.102: v1(152.22,148.19) 152.6,147.81 RH176.1 152.78,147.07 156,147.07 156.71,147.77 157.72,147.77 158.25,147.24 158.82,147.24 159.22,146.84 159.22,146.55 159.58,146.18 UH1.AY43
PCH_THRMTRIP#_R: length 7.3
  BOTTOM w0.089: UH1.AV1 160.27,128.04 159.62,127.39 159.62,126.79 159.45,126.62
  BOTTOM w0.102: 159.45,126.62 159.08,126.25 158.45,126.25 157.8,125.6 CH17.1 RH206.2 v1(155.7,124.34)
PCH_TP25: length 1.8
  TOP w0.089: RH53.2 175,131.63 173.91,131.63 v3(173.87,131.66)
  BOTTOM w0.089: UH1.F8 v3(173.87,131.66)
PCI_5048: length 7.9
  TOP w0.089: 177.22,146.1 175.24,146.1 v3(174.81,145.67)
  TOP w0.102: RH158.1 181.03,146.1 v3(179.77,146.1) 179.46,145.79 178.31,145.79 v1(178.12,145.6) 177.72,145.6 177.22,146.1
  BOTTOM w0.089: UH1.D44 174.49,146 v3(174.81,145.67)
PCI_DOCK: length 2.6
  TOP w0.089: v3(175.24,144.74) 175.23,144.74 v1(174.82,145.15) 174.75,145.15 174.44,145.47 174.44,146.15 RH162.1
  BOTTOM w0.089: UH1.B42 175.17,144.81 v3(175.24,144.74)
PCI_LOOPBACKOUT: length 5.9
  BOTTOM w0.089: UH1.A40 175.91,144.39 176.1,144.39 176.9,145.19 176.9,146.05 177.1,146.26 177.1,147.37 177.22,147.49
  BOTTOM w0.102: 177.22,147.49 177.49,147.76 RH164.1
PCI_MEC: length 10.9
  BOTTOM w0.102: RH160.1 v1(179.2,149.66) 177.83,149.66 176.74,148.57 176.21,148.57 175.3,147.67 174.58,147.67 173.75,146.84 173.75,146.2 UH1.E44
PCI_PIRQA#: length 4.5
  TOP w0.089: RPH4.1 174.4,137.44 174.12,137.17 174.12,136.47 173.84,136.18 173.51,136.18 173.16,135.84 172.77,135.84 172.56,136.04 v3(172.56,136.57)
  BOTTOM w0.089: v3(172.56,136.57) 172.56,136.18 UH1.H20
PCI_PIRQB#: length 4.7
  TOP w0.089: RPH4.2 174.47,136.94 174.31,136.78 174.31,136.29 174.03,136.01 173.59,136.01 173.24,135.66 172.91,135.66 172.54,135.3 172.16,135.3 v3(171.84,135.62)
  BOTTOM w0.089: UH1.L20 171.84,135.71 v3(171.84,135.62)
PCI_PIRQC#: length 5.7
  TOP w0.089: v3(171.75,134.67) 171.77,134.67 172.04,134.94 172.69,134.94 173.05,135.3 173.38,135.3 173.71,135.63 175.07,135.63 175.37,135.93 175.37,136.26 175.19,136.44 RPH4.3
  BOTTOM w0.089: v3(171.75,134.67) 172.08,135 UH1.K17
PCI_PIRQD#: length 5.3
  TOP w0.089: v3(170.63,135.63) 171.1,135.16 v1(171.69,135.16) 171.73,135.12 172.62,135.12 172.98,135.48 173.31,135.48 173.66,135.83 174.37,135.83 174.49,135.94 RPH4.4
  BOTTOM w0.089: v3(170.63,135.63) 170.88,135.88 UH1.M20
PCI_TPM_TCM: length 7.4
  BOTTOM w0.089: UH1.C40 175.31,144.26 175.65,144.61 176.01,144.61 176.72,145.32 176.72,147.69 177.21,148.18
  BOTTOM w0.102: 177.21,148.18 177.68,148.65 RH155.2
PCIE_B+: length 1.7
  BOTTOM w0.102: v1(102.11,131.94) 102.43,131.63 PC680.1
PCIE_PRX_EMBTX_N4: length 147.1
  IN1 w0.089: v3(161.04,142.04) 161.3,142.04 161.46,141.87 161.46,141.77 161.34,141.65 161,141.65 160.06,140.7 158.86,140.7 157.85,139.69 157.85,138.88 157.84,138.87 157.84,138.86
  IN1 w0.114: v3(178.82,35.55) 179.03,35.33 179.17,35.33 179.29,35.45 179.29,52.85 177.73,54.41 177.73,59.56 176.25,61.04 176.25,66.93 177.2,67.88 177.2,73.04 179.65,75.5 179.65,81.35 180.59,82.29 180.59,86.07 181.19,86.67 181.19,90.7 181.69,91.2 181.69,97 173.33,105.36 171.93,105.36 164.69,112.61 159.75,112.61 157.37,114.99 157.37,115.81 152.26,120.92 152.26,131.09 155.6,134.43 156.92,134.43 157.84,135.35 157.84,138.86
  BOTTOM w0.089: UH1.AT33 161.1,141.77 161.1,141.98 v3(161.04,142.04)
  BOTTOM w0.102: JSATA2.19 166.31,33.79 166.31,33.65 166.43,33.53 167.27,33.53 167.83,34.09 171.64,34.09 172.55,35 177.65,35 177.97,35.32 178.59,35.32 v3(178.82,35.55)
PCIE_PRX_EMBTX_P4: length 147.1
  IN1 w0.089: 158.07,138.86 158.07,138.87 158.05,138.88 158.05,139.61 158.94,140.5 160.14,140.5 161.09,141.44 161.42,141.44 161.66,141.68 161.66,141.84 v3(161.82,141.99)
  IN1 w0.114: v3(178.82,34.96) 178.96,35.11 179.26,35.11 179.52,35.36 179.52,52.95 177.96,54.5 177.96,59.65 176.48,61.14 176.48,66.83 177.43,67.78 177.43,72.95 179.88,75.41 179.88,81.26 180.82,82.19 180.82,85.97 181.42,86.58 181.42,90.6 181.92,91.11 181.92,97.09 173.43,105.59 172.03,105.59 164.78,112.84 159.84,112.84 157.6,115.08 157.6,115.91 152.49,121.01 152.49,131 155.7,134.21 157.01,134.21 158.07,135.26 158.07,138.86
  BOTTOM w0.089: v3(161.82,141.99) 161.5,141.67 UH1.AR33
  BOTTOM w0.102: JSATA2.18 166.26,33.4 166.34,33.32 167.36,33.32 167.92,33.88 171.73,33.88 172.64,34.79 177.74,34.79 178.06,35.11 178.67,35.11 v3(178.82,34.96)
PCIE_PRX_EXPTX_N7: length 195.8
  TOP w0.102: v3(228,34.17) 228,33.61 228.22,33.39 228.86,33.39 229.11,33.65 JEXP1.15
  IN1 w0.089: 157.54,142.69 157.55,142.69 157.56,142.67 159.45,142.67 159.63,142.86 159.63,143.6 160.43,144.39 160.61,144.39 v3(160.76,144.55)
  IN1 w0.114: v3(228,34.17) 228,34.43 227.87,34.56 227.36,34.56 226.99,34.19 223.56,34.19 222.53,33.16 219.39,33.16 219.01,32.78 211.23,32.78 209.89,31.44 197.28,31.44 195.9,32.82 194.95,32.82 194.12,33.65 191.52,33.65 191.05,34.11 180.31,34.11 179.27,33.08 177.9,33.08 175.69,35.28 175.69,36.85 177.45,38.6 177.45,41.79 176.91,42.33 176.91,43.49 175.83,44.57 175.83,47.2 175.6,47.42 175.6,59.2 174.8,60.01 174.8,72.7 176.66,74.56 176.66,80.87 179.14,83.35 179.14,86.67 179.74,87.27 179.74,96.9 173.23,103.41 171.33,103.41 168.17,106.57 166.84,106.57 164,109.41 159.85,109.41 154.7,114.56 154.7,115.49 153.04,117.15 153.04,117.78 150.35,120.47 150.35,136.48 152.49,138.62 152.49,139.72 155,142.23 156.85,142.23 157.3,142.69 157.54,142.69
  BOTTOM w0.089: v3(160.76,144.55) 161.11,144.55 UH1.AT40
PCIE_PRX_EXPTX_P7: length 195.8
  TOP w0.102: v3(228.59,34.17) 228.22,33.79 228.22,33.69 228.31,33.6 228.72,33.6 228.98,33.86 228.98,34.02 229.11,34.15 JEXP1.17
  IN1 w0.089: v3(160.78,143.94) 160.78,144.06 160.65,144.19 160.52,144.19 159.84,143.51 159.84,142.77 159.53,142.47 157.57,142.47 157.56,142.46 157.54,142.46
  IN1 w0.114: 157.54,142.46 157.4,142.46 156.94,142 155.09,142 152.72,139.63 152.72,138.53 150.58,136.39 150.58,120.56 153.27,117.88 153.27,117.25 154.93,115.59 154.93,114.66 159.95,109.64 164.09,109.64 166.94,106.8 168.27,106.8 171.42,103.64 173.33,103.64 179.97,97 179.97,87.18 179.37,86.57 179.37,83.25 176.89,80.78 176.89,74.46 175.03,72.6 175.03,60.1 175.83,59.3 175.83,47.52 176.05,47.3 176.05,44.67 177.14,43.58 177.14,42.42 177.67,41.89 177.67,38.51 175.92,36.76 175.92,35.38 177.99,33.31 179.18,33.31 180.21,34.34 191.14,34.34 191.61,33.87 194.22,33.87 195.04,33.05 195.99,33.05 197.37,31.67 209.8,31.67 211.14,33.01 218.92,33.01 219.3,33.39 222.44,33.39 223.46,34.42 226.89,34.42 227.26,34.79 227.97,34.79 v3(228.59,34.17)
  BOTTOM w0.089: UH1.AT39 161.23,144.2 161.03,144.2 v3(160.78,143.94)
PCIE_PRX_GLANTX_N2: length 96.3
  TOP w0.102: C459.2 237.56,157.4 237.56,156.93 237.25,156.62 234.79,156.62 234.17,157.24 234.17,158.26 234.15,158.28 234.15,158.82 234.17,158.84 234.17,159.54 234.96,160.33 235.61,160.33 v3(236.27,160.99)
  IN1 w0.089: 165.23,146.71 165.22,146.71 165.2,146.7 165.14,146.7 163.16,144.72 163.16,141.65 163.07,141.57 162.5,141.57 162.45,141.62 161.87,141.62 161.32,141.07 v3(161.25,141.07)
  IN1 w0.114: 165.23,146.71 165.36,146.71 168.68,150.04 170.35,150.04 171.56,151.25 175.56,151.25 177.8,153.48 185.74,153.48 186.26,154 193.05,154 193.78,154.73 195.21,154.73 195.94,154 201.16,154 201.93,154.77 207.3,154.77 210.22,157.7 216.47,157.7 219.29,160.52 233.96,160.52 234.31,160.86 235.57,160.86 235.81,160.62 236.17,160.62 236.27,160.73 v3(236.27,160.99)
  BOTTOM w0.089: v3(161.25,141.07) 161.25,140.93 UH1.AT31
PCIE_PRX_GLANTX_N2_C: length 3.5
  TOP w0.102: U31.39 238.82,160.23 238.73,160.14 238.73,159.61 238.47,159.36 237.77,159.36 237.45,159.03 237.45,158.92 C459.1
PCIE_PRX_GLANTX_P2: length 96.2
  TOP w0.102: v3(236.86,160.99) 236.43,160.56 236.15,160.56 235.7,160.12 235.05,160.12 234.38,159.45 v4(234.38,158.55) 234.38,157.32 234.87,156.83 237.17,156.83 237.35,157.02 237.35,157.55 237.25,157.65 C458.2
  IN1 w0.089: 165.23,146.48 165.21,146.48 163.36,144.64 163.36,141.57 163.16,141.36 162.41,141.36 162.36,141.41 161.95,141.41 161.85,141.31 v3(161.85,141.07)
  IN1 w0.114: v3(236.86,160.99) 236.26,160.39 235.72,160.39 235.48,160.63 234.4,160.63 234.06,160.29 219.38,160.29 216.56,157.47 210.32,157.47 207.39,154.54 202.03,154.54 201.26,153.77 195.84,153.77 195.12,154.5 193.87,154.5 193.15,153.77 186.35,153.77 185.83,153.25 177.89,153.25 175.66,151.02 171.65,151.02 170.45,149.81 168.78,149.81 165.45,146.48 165.23,146.48
  BOTTOM w0.089: v3(161.85,141.07) 161.78,141.07 161.5,140.79 UH1.AR31
PCIE_PRX_GLANTX_P2_C: length 3.5
  TOP w0.102: C458.1 237.24,158.88 237.24,159.12 237.7,159.59 v4(238.06,159.59) 238.4,159.59 238.52,159.7 238.52,160.14 238.42,160.23 U31.38
PCIE_PRX_MMITX_N8: length 153.2
  TOP w0.102: C571.1 177.98,26.47 176.53,26.47 175.3,27.7 v4(175.3,29.77) 175.3,33.93 176.03,34.65 177.05,34.65 177.59,35.2 177.59,35.59 177.52,35.66 177.36,35.66 v3(177.17,35.46)
  IN1 w0.089: v3(161.77,143.93) 161.97,144.14 162.08,144.14 162.17,144.05 162.17,142.89 161.9,142.62 160.76,142.62 160.46,142.32 160.46,141.8 160.34,141.67 158.96,141.67 158.89,141.6 158.38,141.6 158.37,141.62 158.35,141.62
  IN1 w0.114: 158.35,141.62 157.82,141.62 157.06,140.86 157.06,135.99 156.23,135.16 153.39,135.16 151.08,132.84 151.08,120.84 153.87,118.05 153.87,117.36 160.73,110.51 165.77,110.51 172.14,104.14 173.53,104.14 180.47,97.2 180.47,86.97 179.87,86.37 179.87,83.05 177.39,80.57 177.39,74.26 175.53,72.4 175.53,60.37 176.4,59.49 176.4,54.66 178.46,52.6 178.46,37.11 178.28,36.92 176.93,36.92 176.42,36.41 176.42,35.79 176.66,35.55 177.08,35.55 v3(177.17,35.46)
  BOTTOM w0.089: UH1.AN38 162.17,143.53 v3(161.77,143.93)
PCIE_PRX_MMITX_N8_C: length 4.4
  TOP w0.102: U38.8 182.76,26.06 182.69,26.13 181.95,26.13 181.63,26.45 179.64,26.45 C571.2
PCIE_PRX_MMITX_P8: length 153.2
  TOP w0.102: C569.1 178.06,26.68 176.62,26.68 175.52,27.78 175.52,29.48 175.53,29.5 175.53,30.05 175.52,30.06 175.52,33.84 176.12,34.44 177.13,34.44 177.8,35.11 177.8,35.68 177.61,35.87 177.34,35.87 v3(177.17,36.05)
  IN1 w0.089: v3(161.77,144.53) 161.95,144.34 162.16,144.34 162.37,144.13 162.37,142.8 161.98,142.41 160.85,142.41 160.66,142.23 160.66,141.71 160.42,141.47 159.04,141.47 158.97,141.4 158.38,141.4 158.37,141.39 158.35,141.39
  IN1 w0.114: v3(177.17,36.05) 176.9,35.78 176.75,35.78 176.65,35.89 176.65,36.31 177.03,36.69 178.37,36.69 178.69,37.01 178.69,52.7 176.63,54.75 176.63,59.58 175.75,60.46 175.75,72.3 177.62,74.16 177.62,80.47 180.09,82.95 180.09,86.27 180.7,86.88 180.7,97.3 173.63,104.37 172.23,104.37 165.86,110.73 160.82,110.73 154.1,117.45 154.1,118.14 151.31,120.94 151.31,132.75 153.49,134.93 156.32,134.93 157.29,135.9 157.29,140.77 157.91,141.39 158.35,141.39
  BOTTOM w0.089: v3(161.77,144.53) 162.16,144.13 UH1.AN39
