# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D60: length 70.5
  IN4 w0.102: v3(141.47,86.2) 142.07,85.6 142.07,84.98 142.25,84.8 142.49,84.8 142.99,84.29 142.99,84.04 143.23,83.8 143.49,83.8 144.07,83.21 144.07,82.88 144.36,82.6 145.8,82.6 148.76,79.63 148.76,74.11 150.84,72.04 150.84,63.14 151.35,62.63 151.35,42.25 149.32,40.22 149.32,37.22 147.64,35.54 147.64,33.05 147.74,32.95 148.24,32.95 148.34,32.85 148.34,32.55 148.24,32.44 147.74,32.44 147.64,32.34 147.64,32.04 147.74,31.94 148.24,31.94 148.34,31.83 148.34,31.53 148.24,31.43 147.74,31.43 147.64,31.33 147.64,31.02 147.77,30.89 v3(148.83,30.89)
  BOTTOM w0.089: JCPU1.E11 141,85.73 v3(141.47,86.2)
  BOTTOM w0.102: JDIMM1.180 147.54,29.6 v3(148.83,30.89)
DDR_A_D61: length 70.2
  IN4 w0.102: v3(142.47,86.2) 142.47,85.8 142.87,85.4 142.87,84.92 143.19,84.6 143.61,84.6 143.87,84.34 143.87,83.92 144.18,83.61 144.69,83.61 144.87,83.43 144.87,82.97 145.04,82.8 146.03,82.8 149.07,79.76 149.07,74.41 151.14,72.33 151.14,63.27 151.66,62.76 151.66,42.13 149.62,40.09 149.62,36.68 149.52,36.58 149.14,36.58 149.04,36.48 149.04,36.17 149.14,36.07 149.52,36.07 149.62,35.97 149.62,35.66 149.52,35.56 149.14,35.56 149.04,35.46 149.04,35.16 149.14,35.06 149.52,35.06 149.62,34.95 149.62,34.65 149.52,34.55 149.14,34.55 149.04,34.45 149.04,34.14 149.14,34.04 149.52,34.04 149.62,33.94 149.62,33.63 149.52,33.53 149.14,33.53 149.04,33.43 149.04,33.12 149.14,33.02 149.52,33.02 149.62,32.92 149.62,29.71 149.28,29.37 v3(148.83,29.37)
  BOTTOM w0.089: v3(142.47,86.2) 142,85.73 JCPU1.D11
  BOTTOM w0.102: JDIMM1.182 148.14,28.67 v3(148.83,29.37)
DDR_A_D62: length 71
  IN4 w0.102: v3(152.57,30.89) 154.11,32.43 154.11,71.37 157.07,74.33 157.07,77.79 154.04,80.82 154.04,81.41 148.14,87.3 146.11,87.3 145.63,86.82 144.74,86.82 v3(144.45,87.11)
  BOTTOM w0.089: v3(144.45,87.11) 144.07,86.73 JCPU1.B12
  BOTTOM w0.102: v3(152.57,30.89) 151.14,29.46 JDIMM1.192
DDR_A_D63: length 70.3
  IN4 w0.102: v3(152.57,29.37) 154.41,31.21 154.41,71.24 157.37,74.2 157.37,77.92 154.34,80.95 154.34,81.53 148.19,87.68 145.96,87.68 v3(145.47,87.2)
  BOTTOM w0.089: v3(145.47,87.2) 145,86.73 JCPU1.A12
  BOTTOM w0.102: JDIMM1.194 151.74,28.54 v3(152.57,29.37)
DDR_A_DQS0: length 75.6
  IN4 w0.102: v3(111.47,88.2) 111.51,88.24 111.51,88.51 111.38,88.64 111.2,88.64 111.07,88.51 111.07,87.95 110.72,87.59 109.17,87.59 103.67,82.08 103.67,79.84 102.8,78.97 100.92,78.97 99.18,77.23 99.18,74.77 100.86,73.08 100.86,70.21 98.73,68.07 98.73,56.03 94.58,51.88 94.58,42.24 92.92,40.59 92.92,31.07 93.06,30.94 93.28,30.94 93.41,31.06 v3(93.41,31.27)
  BOTTOM w0.089: v3(111.47,88.2) 111.94,88.67 JCPU1.AP14
  BOTTOM w0.102: v3(93.41,31.27) 93.72,30.97 93.93,30.97 94.34,30.56 94.34,29.03 94.53,28.85 94.53,28.51 94.74,28.3 JDIMM1.12
DDR_A_DQS1: length 66.8
  IN4 w0.102: v3(111.47,83.2) 111.25,82.98 111.15,82.98 110.85,82.68 110.85,82.04 110.62,81.8 110.25,81.8 109.87,81.42 109.87,81.04 109.63,80.8 109.02,80.8 108.69,80.47 108.69,73.27 103.65,68.23 103.65,66.93 103.54,66.83 102.34,66.83 102.11,66.6 102.11,66.12 102.34,65.89 103.52,65.89 103.65,65.76 103.65,65.51 103.52,65.38 102.34,65.38 102.11,65.15 102.11,64.67 102.34,64.44 103.32,64.44 103.44,64.31 103.44,64.06 103.32,63.93 102.34,63.93 102.11,63.71 102.11,63.22 102.34,62.99 102.71,62.99 102.83,62.87 102.83,62.61 102.71,62.49 102.34,62.49 102.11,62.26 102.11,61.77 102.34,61.55 102.71,61.55 102.83,61.42 102.83,61.16 102.71,61.04 102.34,61.04 102.11,60.81 102.11,60.33 102.34,60.1 102.71,60.1 102.83,59.97 102.83,59.72 102.71,59.59 102.34,59.59 102.11,59.36 102.11,58.88 102.34,58.65 102.73,58.65 102.83,58.55 102.83,55.39 98.2,50.75 98.2,39.48 97.92,39.19 97.67,39.19 v3(97.39,39.47)
  BOTTOM w0.089: v3(111.47,83.2) 111.94,83.67 JCPU1.AP9
  BOTTOM w0.102: v3(97.39,39.47) 97.64,39.22 98.57,39.22 98.91,38.88 98.91,37.55 99.65,36.82 99.65,36.47 99.84,36.27 JDIMM1.29
DDR_A_DQS2: length 65
  IN4 w0.102: v3(103,39.47) 103.28,39.19 103.42,39.19 103.52,39.3 103.52,40.59 103.24,40.88 103.24,47.19 103.49,47.44 104.19,47.44 104.32,47.57 104.32,47.82 104.19,47.95 103.49,47.95 103.24,48.2 103.24,48.63 103.49,48.89 105.22,48.89 105.35,49.01 105.35,49.27 105.22,49.39 104.37,49.39 104.12,49.65 104.12,50.08 104.37,50.33 105.39,50.33 105.51,50.46 105.51,50.72 105.39,50.84 105.02,50.84 104.77,51.1 104.77,51.53 105.02,51.78 106.38,51.78 106.51,51.91 106.51,54.83 107.21,55.53 107.21,66.56 112.4,71.74 112.4,72.24 112.62,72.46 113.12,72.46 113.24,72.59 113.24,72.84 113.12,72.97 112.62,72.97 112.4,73.2 112.4,73.68 112.62,73.91 113.41,73.91 113.54,74.04 113.54,74.35 113.41,74.48 113.1,74.48 112.87,74.7 112.87,76.47 113.2,76.8 113.65,76.8 113.87,77.03 113.87,80.48 114.2,80.8 114.65,80.8 114.87,81.03 114.87,81.46 115.23,81.82 115.69,81.82 115.8,81.93 115.8,82.12 115.72,82.2 v3(115.47,82.2)
  BOTTOM w0.089: JCPU1.AK8 115.94,82.67 v3(115.47,82.2)
  BOTTOM w0.102: v3(103,39.47) 103.32,39.16 103.9,39.16 104.33,38.73 104.33,37.39 105.03,36.7 105.03,36.49 105.24,36.28 JDIMM1.47
DDR_A_DQS3: length 57.7
  IN4 w0.102: v3(108.77,31.27) 108.77,31.07 108.84,31 109.14,31 109.2,31.06 109.2,32.18 108.44,32.94 108.44,41.8 110.08,43.44 110.08,53.35 110.78,54.05 110.78,64.93 117.37,71.52 117.37,75.49 117.87,75.99 117.87,76.44 118.22,76.8 118.65,76.8 118.81,76.95 118.81,77.07 118.69,77.2 v3(118.47,77.2)
  BOTTOM w0.089: JCPU1.AG3 118.94,77.67 v3(118.47,77.2)
  BOTTOM w0.102: v3(108.77,31.27) 109,31.04 109.35,31.04 109.73,30.66 109.73,29.48 110.18,29.03 110.18,28.47 110.34,28.3 JDIMM1.64
DDR_A_DQS4: length 54
  IN4 w0.102: v3(135.62,38.71) 135.9,38.99 136.08,38.99 136.27,39.18 136.27,40.55 139.51,43.79 139.51,48.18 139.61,48.28 140,48.28 140.25,48.53 140.25,48.96 140,49.22 139.61,49.22 139.51,49.32 139.51,49.63 139.64,49.76 140.02,49.76 140.25,49.99 140.25,50.49 140.02,50.71 139.64,50.71 139.54,50.82 139.54,51.12 139.64,51.22 140.02,51.22 140.25,51.45 140.25,51.93 140.02,52.16 139.64,52.16 139.54,52.26 139.54,52.57 139.64,52.67 140.02,52.67 140.25,52.9 140.25,53.38 140.02,53.61 139.64,53.61 139.51,53.74 139.51,53.99 139.64,54.12 140.02,54.12 140.25,54.35 140.25,54.83 140.02,55.06 139.64,55.06 139.51,55.18 139.51,55.44 139.64,55.57 140.02,55.57 140.25,55.79 140.25,56.28 140.02,56.5 139.64,56.5 139.54,56.61 139.54,56.91 139.64,57.01 140.02,57.01 140.25,57.24 140.25,69.8 139.5,70.55 139.5,74.63 139.09,75.04 139.09,76.45 138.74,76.8 138.13,76.8 138.07,76.86 138.07,77.13 138.14,77.2 v3(138.47,77.2)
  BOTTOM w0.089: v3(138.47,77.2) JCPU1.H3
  BOTTOM w0.102: v3(135.62,38.71) 135.35,38.98 134.94,38.98 134.64,38.68 JDIMM1.137
DDR_A_DQS5: length 56.9
  IN4 w0.102: v3(141.47,78.2) 141.47,77.87 141.54,77.8 141.77,77.8 142.09,77.48 142.09,76.94 142.23,76.8 142.75,76.8 143.09,76.46 143.09,72.01 143.88,71.22 143.88,65.71 144.51,65.07 144.51,43.74 141.07,40.3 141.07,31.4 140.4,30.72 139.85,30.72 v3(139.64,30.51)
  BOTTOM w0.089: JCPU1.E3 141,77.73 v3(141.47,78.2)
  BOTTOM w0.102: JDIMM1.154 139.74,28.19 139.58,28.35 139.58,28.93 139.12,29.38 139.12,30.69 139.22,30.79 139.37,30.79 v3(139.64,30.51)
DDR_A_DQS6: length 59.9
  IN4 w0.102: v3(146.07,38.71) 146.35,38.99 146.53,38.99 146.75,39.21 146.75,40.93 146.98,41.16 147.53,41.16 148.21,41.84 148.21,42.55 148.3,42.64 148.88,42.64 149.13,42.89 149.13,43.4 148.88,43.65 148.21,43.65 148.11,43.76 148.11,44.06 148.21,44.16 149.17,44.16 149.42,44.42 149.42,44.85 149.17,45.1 148.21,45.1 148.11,45.2 148.11,45.51 148.21,45.61 149.17,45.61 149.42,45.86 149.42,46.34 149.19,46.57 149.04,46.57 148.91,46.7 148.91,46.95 149.04,47.08 149.17,47.08 149.42,47.33 149.42,47.76 149.17,48.02 149.01,48.02 148.91,48.12 148.91,48.42 149.01,48.52 149.17,48.52 149.42,48.78 149.42,49.21 149.17,49.46 149.04,49.46 148.91,49.59 148.91,50.07 149.01,50.17 149.17,50.17 149.42,50.43 149.42,50.86 149.17,51.11 149.01,51.11 148.91,51.22 148.91,51.52 149.01,51.62 149.17,51.62 149.42,51.88 149.42,52.31 149.17,52.56 149.01,52.56 148.91,52.66 148.91,71.06 148.91,71.24 146.83,73.31 146.83,78.59 145.73,79.69 145.4,79.69 145.07,80.02 145.07,80.45 145.03,80.48 145.05,80.5 144.96,80.58 144.73,80.82 143.85,80.82 v3(143.47,81.2)
  BOTTOM w0.089: JCPU1.C6 143,80.73 v3(143.47,81.2)
  BOTTOM w0.102: v3(146.07,38.71) 145.85,38.93 145.68,38.93 145.53,38.78 145.53,37.25 145.11,36.83 144.72,36.83 144.66,36.77 144.66,36.57 144.84,36.4 JDIMM1.171
DDR_A_DQS7: length 71.7
  IN4 w0.102: v3(143.47,87.2) 143.47,87.05 143.6,86.92 143.83,86.92 144.09,86.66 144.09,86.02 144.31,85.8 144.8,85.8 145.08,85.51 145.08,84.96 145.24,84.8 148.86,84.8 151.41,82.25 151.41,81.87 155.84,77.44 155.84,74.68 152.99,71.83 152.99,41.57 151.54,40.12 151.54,31.3 151.02,30.78 150.63,30.78 v3(150.36,30.51)
  BOTTOM w0.089: JCPU1.C12 143,86.73 v3(143.47,87.2)
  BOTTOM w0.102: JDIMM1.188 149.94,28.39 149.73,28.59 149.73,30.43 149.99,30.69 150.18,30.69 v3(150.36,30.51)
DDR_A_DQS#0: length 75.6
  IN4 w0.102: v3(111.47,89.2) 111.47,88.92 111.41,88.85 111.11,88.85 110.86,88.6 110.86,88.04 110.63,87.81 109.09,87.81 103.45,82.17 103.45,79.93 102.71,79.19 100.83,79.19 98.96,77.32 98.96,74.68 100.65,72.99 100.65,70.3 98.51,68.16 98.51,56.12 94.36,51.97 94.36,42.33 92.7,40.68 92.7,30.99 92.97,30.72 93.28,30.72 93.41,30.6 v3(93.41,30.51)
  BOTTOM w0.089: v3(111.47,89.2) 111.94,89.67 JCPU1.AP15
  BOTTOM w0.102: v3(93.41,30.51) 93.63,30.74 93.84,30.74 94.11,30.46 94.11,28.94 94.3,28.75 94.3,28.46 94.14,28.3 JDIMM1.10
DDR_A_DQS#1: length 66.9
  IN4 w0.102: v3(111.47,82.2) 111.47,82.69 111.39,82.78 111.24,82.78 111.06,82.59 111.06,81.96 110.7,81.6 110.33,81.6 110.08,81.35 110.08,80.95 109.72,80.59 109.11,80.59 108.91,80.38 108.91,73.19 103.86,68.14 103.86,66.84 103.63,66.61 102.43,66.61 102.33,66.51 102.33,66.21 102.43,66.11 103.61,66.11 103.86,65.85 103.86,65.42 103.61,65.17 102.43,65.17 102.33,65.06 102.33,64.76 102.43,64.66 103.41,64.66 103.66,64.4 103.66,63.97 103.41,63.72 102.43,63.72 102.33,63.62 102.33,63.31 102.43,63.21 102.8,63.21 103.05,62.96 103.05,62.52 102.8,62.27 102.43,62.27 102.33,62.17 102.33,61.86 102.43,61.76 102.8,61.76 103.05,61.51 103.05,61.08 102.8,60.82 102.43,60.82 102.33,60.72 102.33,60.42 102.43,60.31 102.8,60.31 103.05,60.06 103.05,59.63 102.8,59.37 102.43,59.37 102.33,59.27 102.33,58.97 102.43,58.87 102.82,58.87 103.05,58.64 103.05,55.3 98.41,50.66 98.41,39.39 98.01,38.98 97.66,38.98 v3(97.39,38.71)
  BOTTOM w0.089: v3(111.47,82.2) 111.94,82.67 JCPU1.AP8
  BOTTOM w0.102: v3(97.39,38.71) 97.67,38.99 98.47,38.99 98.68,38.78 98.68,37.46 99.42,36.72 99.42,36.5 99.24,36.32 JDIMM1.27
DDR_A_DQS#2: length 65.1
  IN4 w0.102: v3(116.47,82.2) 116.06,82.2 116.02,82.16 116.02,81.84 115.78,81.6 115.32,81.6 115.09,81.37 115.09,80.94 114.74,80.59 114.29,80.59 114.09,80.39 114.09,76.94 113.73,76.58 113.29,76.58 113.08,76.38 113.08,74.79 113.18,74.69 113.5,74.69 113.76,74.44 113.76,73.95 113.5,73.7 112.71,73.7 112.61,73.59 112.61,73.29 112.71,73.19 113.21,73.19 113.46,72.93 113.46,72.5 113.21,72.25 112.71,72.25 112.61,72.15 112.61,71.65 107.43,66.47 107.43,55.44 106.73,54.74 106.73,51.82 106.47,51.57 105.11,51.57 104.98,51.44 104.98,51.19 105.11,51.06 105.48,51.06 105.73,50.81 105.73,50.37 105.48,50.12 104.46,50.12 104.33,49.99 104.33,49.74 104.46,49.61 105.31,49.61 105.56,49.36 105.56,48.92 105.31,48.67 103.58,48.67 103.46,48.54 103.46,48.29 103.58,48.16 104.28,48.16 104.54,47.91 104.54,47.48 104.28,47.22 103.58,47.22 103.46,47.1 103.46,40.97 103.74,40.68 103.74,39.21 103.51,38.98 103.27,38.98 v3(103,38.71)
  BOTTOM w0.089: v3(116.47,82.2) 116.94,82.67 JCPU1.AJ8
  BOTTOM w0.102: JDIMM1.45 104.64,36.3 104.8,36.46 104.8,36.6 104.1,37.3 104.1,38.63 103.81,38.93 103.22,38.93 v3(103,38.71)
DDR_A_DQS#3: length 57.7
  IN4 w0.102: v3(119.47,77.2) 119.17,77.2 119.03,77.05 119.03,76.86 118.74,76.58 118.31,76.58 118.09,76.35 118.09,75.9 117.58,75.4 117.58,71.43 111,64.84 111,53.96 110.29,53.26 110.29,43.35 108.65,41.71 108.65,33.03 109.42,32.27 109.42,30.97 109.23,30.78 109.04,30.78 v3(108.77,30.51)
  BOTTOM w0.089: JCPU1.AF3 119.94,77.67 v3(119.47,77.2)
  BOTTOM w0.102: JDIMM1.62 109.74,28.3 109.95,28.51 109.95,28.94 109.5,29.39 109.5,30.57 109.26,30.81 109.07,30.81 v3(108.77,30.51)
DDR_A_DQS#4: length 54.1
  IN4 w0.102: v3(135.62,39.47) 135.88,39.21 135.99,39.21 136.06,39.27 136.06,40.64 139.3,43.88 139.3,48.26 139.52,48.49 139.91,48.49 140.03,48.62 140.03,48.87 139.91,49 139.52,49 139.3,49.23 139.3,49.72 139.55,49.97 139.93,49.97 140.03,50.08 140.03,50.4 139.93,50.5 139.55,50.5 139.32,50.73 139.32,51.21 139.55,51.44 139.93,51.44 140.03,51.54 140.03,51.84 139.93,51.95 139.55,51.95 139.32,52.17 139.32,52.66 139.55,52.89 139.93,52.89 140.03,52.99 140.03,53.29 139.93,53.39 139.55,53.39 139.3,53.65 139.3,54.08 139.55,54.33 139.93,54.33 140.03,54.43 140.03,54.74 139.93,54.84 139.55,54.84 139.3,55.09 139.3,55.53 139.55,55.78 139.93,55.78 140.03,55.88 140.03,56.19 139.93,56.29 139.55,56.29 139.32,56.52 139.32,57 139.55,57.23 139.93,57.23 140.03,57.33 140.03,69.71 139.28,70.46 139.28,74.54 138.87,74.95 138.87,76.36 138.65,76.58 138.04,76.58 137.85,76.77 137.85,77.05 137.71,77.2 v3(137.47,77.2)
  BOTTOM w0.089: v3(137.47,77.2) JCPU1.J3
  BOTTOM w0.102: JDIMM1.135 134.04,36.53 134.41,36.9 134.41,38.78 134.84,39.21 135.35,39.21 v3(135.62,39.47)
DDR_A_DQS#5: length 56.9
  IN4 w0.102: v3(139.64,31.27) 139.64,31.09 139.79,30.94 140.31,30.94 140.86,31.49 140.86,40.39 144.3,43.83 144.3,64.98 143.66,65.62 143.66,71.13 142.87,71.92 142.87,76.38 142.66,76.58 142.14,76.58 141.87,76.85 141.87,77.4 141.68,77.59 141.42,77.59 141.35,77.52 141.35,77.32 v3(141.47,77.2)
  BOTTOM w0.089: JCPU1.E2 141,76.73 v3(141.47,77.2)
  BOTTOM w0.102: JDIMM1.152 139.14,28.26 139.35,28.47 139.35,28.83 138.89,29.28 138.89,30.79 139.12,31.01 139.38,31.01 v3(139.64,31.27)
DDR_A_DQS#6: length 59.9
  IN4 w0.102: v3(143.47,80.2) 143.38,80.29 143.38,80.44 143.54,80.6 144.64,80.6 144.75,80.49 144.75,80.46 144.85,80.36 144.85,80.04 144.8,79.99 145.31,79.47 145.64,79.47 146.62,78.5 146.62,73.22 148.69,71.15 148.69,52.57 148.92,52.35 149.08,52.35 149.21,52.22 149.21,51.96 149.08,51.84 148.92,51.84 148.69,51.61 148.69,51.13 148.92,50.9 149.08,50.9 149.21,50.77 149.21,50.52 149.08,50.39 148.92,50.39 148.69,50.16 148.69,49.5 148.95,49.25 149.08,49.25 149.21,49.12 149.21,48.87 149.08,48.74 148.92,48.74 148.69,48.51 148.69,48.03 148.92,47.8 149.08,47.8 149.21,47.67 149.21,47.42 149.08,47.29 148.95,47.29 148.69,47.04 148.69,46.61 148.95,46.35 149.1,46.35 149.2,46.25 149.2,45.95 149.08,45.83 148.12,45.83 147.89,45.6 147.89,45.11 148.12,44.89 149.08,44.89 149.21,44.76 149.21,44.51 149.08,44.38 148.12,44.38 147.89,44.15 147.89,43.67 148.12,43.44 148.79,43.44 148.92,43.31 148.92,42.98 148.79,42.85 148.21,42.85 147.99,42.63 147.99,41.93 147.44,41.38 146.89,41.38 146.54,41.02 146.54,39.3 146.44,39.21 146.33,39.21 v3(146.07,39.47)
  BOTTOM w0.089: JCPU1.C5 143,79.73 v3(143.47,80.2)
  BOTTOM w0.102: JDIMM1.169 144.24,36.43 144.44,36.63 144.44,36.87 144.63,37.06 145.02,37.06 145.3,37.35 145.3,38.88 145.58,39.16 145.82,39.16 146.07,39.4 v3(146.07,39.47)
DDR_A_DQS#7: length 71.7
  IN4 w0.102: v3(143.47,86.2) 143.47,86.58 143.6,86.71 143.74,86.71 143.87,86.57 143.87,85.93 144.22,85.58 144.71,85.58 144.87,85.42 144.87,84.87 145.15,84.59 148.77,84.59 151.2,82.16 151.2,81.78 155.62,77.35 155.62,74.77 152.78,71.92 152.78,41.66 151.32,40.21 151.32,31.39 150.93,30.99 150.64,30.99 v3(150.36,31.27)
  BOTTOM w0.089: v3(143.47,86.2) 143,85.73 JCPU1.C11
  BOTTOM w0.102: v3(150.36,31.27) 150.36,31.23 150.05,30.92 149.9,30.92 149.51,30.52 149.51,28.5 149.34,28.34 JDIMM1.186
DDR_A_MA0: length 59.2
  IN4 w0.089: 127.96,73.63 127.96,74.75 127.1,75.61 127.1,81.82 v3(127.47,82.2)
  IN4 w0.165: 127.96,73.63 127.96,63.81 126.86,62.71 126.86,49.76 126.56,49.46 126.56,47.11 123.27,43.82 123.27,38.18 123.66,37.79 123.66,34.75 123.71,34.69 123.71,30.64 123.21,30.14 v3(123.21,30.13)
  BOTTOM w0.089: JCPU1.V8 127.94,82.67 v3(127.47,82.2)
  BOTTOM w0.165: JDIMM1.98 122.94,28.13 123.72,28.91 123.72,29.62 v3(123.21,30.13)
DDR_A_MA1: length 69.1
  IN4 w0.089: 126.45,73.63 126.45,74.25 125.88,74.82 125.88,75.57 125.79,75.66 125.44,75.66 125.35,75.74 125.35,75.92 125.44,76.01 125.79,76.01 125.88,76.1 125.88,76.28 125.79,76.37 125.44,76.37 125.35,76.46 125.35,76.63 125.44,76.72 125.79,76.72 125.88,76.81 125.88,77.37 125.79,77.46 125.69,77.46 125.6,77.55 125.6,77.73 125.69,77.82 125.79,77.82 125.88,77.91 125.88,78.6 125.75,78.73 124.64,78.73 124.53,78.84 124.53,79 124.64,79.11 124.98,79.11 125.1,79.23 125.1,80.51 124.97,80.64 122.66,80.64 122.47,80.44 v3(122.47,80.2)
  IN4 w0.165: v3(121.52,39.85) 121.06,39.85 120.94,39.98 120.94,40.94 121.06,41.07 121.6,41.07 121.78,41.25 121.78,41.73 121.62,41.9 120.82,41.9 120.69,42.02 120.69,42.43 120.82,42.56 121.62,42.56 121.78,42.72 121.78,43.05 121.62,43.22 120.37,43.22 120.24,43.34 120.24,43.75 120.37,43.88 121.62,43.88 121.78,44.04 121.78,44.37 121.62,44.54 120.37,44.54 120.24,44.66 120.24,45.07 120.37,45.2 121.62,45.2 121.78,45.36 121.78,45.69 121.62,45.86 120.37,45.86 120.24,45.98 120.24,46.39 120.37,46.52 121.62,46.52 122.25,47.15 122.25,50.7 125.38,53.83 125.38,63.33 126.45,64.41 126.45,73.63
  BOTTOM w0.089: v3(122.47,80.2) 122.94,80.67 JCPU1.AC6
  BOTTOM w0.165: v3(121.52,39.85) 123.69,39.85 123.8,39.75 123.8,38.89 123.69,38.79 123.05,38.79 122.95,38.69 122.95,36.92 122.64,36.62 JDIMM1.97
DDR_A_MA2: length 78.8
  IN4 w0.089: 127.44,73.63 127.44,75 126.91,75.53 126.91,82.16 127.34,82.6 128.39,82.6 128.52,82.73 128.52,83.15 v3(128.47,83.2)
  IN4 w0.165: 127.44,73.63 127.44,64 126.37,62.92 126.37,49.97 126.06,49.66 126.06,47.31 122.77,44.02 122.77,38.41 122.61,38.25 122.28,38.25 122.11,38.08 122.11,37.75 122.28,37.59 123.03,37.59 123.16,37.46 123.16,37.05 123.03,36.93 121.05,36.93 120.92,36.8 120.92,36.39 121.05,36.27 123.03,36.27 123.16,36.14 123.16,35.73 123.03,35.61 121.05,35.61 120.92,35.48 120.92,35.07 121.05,34.94 123.03,34.94 123.16,34.82 123.16,34.41 123.03,34.28 122.01,34.28 121.88,34.16 121.88,33.75 122.01,33.62 122.61,33.62 122.77,33.46 122.77,33.13 122.61,32.96 122.14,32.96 122.02,32.84 122.02,29.26 122.14,29.14 122.59,29.14 122.72,29.26 122.72,31.53 122.84,31.65 v3(123.21,31.65)
  BOTTOM w0.089: v3(128.47,83.2) JCPU1.V9
  BOTTOM w0.165: JDIMM1.96 122.34,28.29 122.62,28.58 122.62,31.07 v3(123.21,31.65)
DDR_A_MA3: length 79.2
  IN4 w0.089: v3(129.46,83.2) 128.84,83.82 126.05,83.82 125.92,83.7 125.92,79.78 126.08,79.62 126.08,76.79 126.17,76.7 126.6,76.7 126.68,76.62 126.68,76.44 126.6,76.35 126.17,76.35 126.08,76.26 126.08,76.08 126.17,75.99 126.6,75.99 126.68,75.9 126.68,75.73 126.6,75.64 126.17,75.64 126.08,75.55 126.08,75.3 126.21,75.17 126.82,75.17 126.95,75.05 126.95,73.63
  IN4 w0.165: v3(121.52,38.33) 121.66,38.33 122.28,38.95 122.28,44.23 122.62,44.57 122.62,45.79 122.75,45.92 123.96,45.92 124.09,46.04 124.09,46.45 123.96,46.58 123.13,46.58 123,46.71 123,47.23 123.13,47.36 125.05,47.36 125.18,47.49 125.18,47.89 125.05,48.02 122.87,48.02 122.75,48.15 122.75,48.55 122.87,48.68 125.35,48.68 125.48,48.81 125.48,49.21 125.35,49.34 122.87,49.34 122.75,49.47 122.75,49.95 122.87,50.08 125.5,50.08 125.63,50.21 125.63,50.69 125.5,50.81 123.72,50.81 123.6,50.94 123.6,51.35 123.72,51.47 125.71,51.47 125.87,51.64 125.87,51.97 125.71,52.13 125.04,52.13 124.92,52.26 124.92,52.67 125.04,52.8 125.71,52.8 125.87,52.96 125.87,63.13 126.95,64.2 126.95,73.63
  BOTTOM w0.089: JCPU1.U9 128.94,83.72 v3(129.46,83.2)
  BOTTOM w0.165: JDIMM1.95 122.04,36.2 121.43,36.81 121.43,37.02 121.53,37.12 122.35,37.12 122.45,37.23 122.45,38.55 122.35,38.65 121.84,38.65 v3(121.52,38.33)
DDR_A_MA4: length 70.1
  IN4 w0.089: v3(123.47,79.2) 123.54,79.2 125.07,77.67 125.07,74.88 125.96,74 125.96,73.63
  IN4 w0.165: 125.96,73.63 125.96,64.61 124.88,63.54 124.88,54.03 121.76,50.91 121.76,47.61 121.16,47.01 119.87,47.01 119.75,46.89 119.75,42.36 120.21,41.89 120.21,39.56 120.38,39.39 120.88,39.39 121.01,39.27 121.01,38.86 120.88,38.73 119.98,38.73 119.86,38.61 119.86,38.2 119.98,38.07 120.96,38.07 121.08,37.95 121.08,37.54 120.96,37.41 120.38,37.41 120.21,37.25 120.21,34.6 120.38,34.44 120.87,34.44 121,34.31 121,33.91 120.87,33.78 119.87,33.78 119.75,33.65 119.75,33.24 119.87,33.12 120.88,33.12 121.01,32.99 121.01,32.58 120.88,32.46 119.87,32.46 119.75,32.33 119.75,32.08 119.91,31.91 120.27,31.91 120.4,31.79 120.4,31.38 120.27,31.25 119.91,31.25 119.75,31.09 119.75,30.72 119.89,30.58 120.96,30.58 121.08,30.71 121.08,31.53 121.21,31.65 v3(121.52,31.65)
  BOTTOM w0.089: v3(123.47,79.2) JCPU1.AC5
  BOTTOM w0.165: JDIMM1.92 121.14,28.29 122.13,29.28 122.13,31.05 v3(121.52,31.65)
DDR_A_MA5: length 71.7
  IN4 w0.089: 124.97,73.63 124.97,74.1 124.69,74.38 124.69,76.57 124.27,76.99 124.27,77.08 124.6,77.41 124.6,77.57 124.48,77.69 124.32,77.69 124.05,77.43 123.93,77.43 123.8,77.55 123.8,77.68 124.1,77.98 124.1,78.1 123.59,78.61 123.14,78.61 122.91,78.85 122.91,79.51 122.78,79.63 122.6,79.63 122.47,79.51 v3(122.47,79.2)
  IN4 w0.165: v3(118.75,39.85) 119.1,39.85 119.22,39.98 119.22,41.48 119.1,41.61 118.88,41.61 118.75,41.73 118.75,47.82 118.94,48.01 120.64,48.01 120.77,48.13 120.77,48.58 120.64,48.7 118.56,48.7 118.43,48.83 118.43,49.24 118.56,49.36 120.64,49.36 120.77,49.49 120.77,49.9 120.64,50.03 118.55,50.03 118.42,50.15 118.42,50.56 118.55,50.69 120.66,50.69 120.77,50.79 120.77,51.25 120.6,51.42 119.64,51.42 119.51,51.54 119.51,51.95 119.64,52.08 121.52,52.08 121.65,52.2 121.65,52.61 121.52,52.74 119.57,52.74 119.45,52.86 119.45,53.27 119.57,53.4 122.84,53.4 123.89,54.44 123.89,63.95 124.97,65.03 124.97,73.63
  BOTTOM w0.089: JCPU1.AC4 v3(122.47,79.2)
  BOTTOM w0.165: v3(118.75,39.85) 119.57,40.67 120.53,40.67 120.84,40.36 JDIMM1.91
DDR_A_MA6: length 70.4
  IN4 w0.089: 125.46,73.63 125.46,74.05 124.88,74.63 124.88,77.59 123.67,78.8 123.22,78.8 123.1,78.93 123.1,79.7 122.97,79.82 122.22,79.82 122.1,79.95 122.1,81.55 121.97,81.68 121.57,81.68 121.45,81.55 v3(121.45,81.28)
  IN4 w0.165: 125.46,73.63 125.46,64.82 124.38,63.74 124.38,54.24 121.26,51.11 121.26,47.82 120.96,47.51 119.42,47.51 119.25,47.35 119.25,42.15 119.72,41.69 119.72,39.17 119.36,38.81 119.36,38.27 119.19,38.1 119.19,37.3 119.36,37.13 119.59,37.13 119.72,37.01 119.72,36.6 119.59,36.47 118.65,36.47 118.52,36.35 118.52,35.84 118.65,35.71 119.59,35.71 119.72,35.58 119.72,35.18 119.59,35.05 118.65,35.05 118.52,34.92 118.52,34.51 118.65,34.39 119.12,34.39 119.25,34.26 119.25,29.39 119.38,29.26 120.96,29.26 121.08,29.39 121.08,30 121.21,30.13 v3(121.52,30.13)
  BOTTOM w0.089: JCPU1.AD6 121.94,80.78 v3(121.45,81.28)
  BOTTOM w0.165: JDIMM1.90 120.54,29.15 v3(121.52,30.13)
DDR_A_MA7: length 70.5
  IN4 w0.089: 123.98,73.63 123.98,76.66 122.47,78.17 v3(122.47,78.2)
  IN4 w0.165: 123.98,73.63 123.98,65.44 122.9,64.36 122.9,55.88 122.77,55.76 117.56,55.76 117.36,55.55 117.36,48.5 117.69,48.17 117.69,38.81 117.6,38.73 117.22,38.73 117.09,38.6 117.09,38.16 117.22,38.03 117.9,38.03 118.03,37.9 118.03,37.17 117.9,37.04 116.39,37.04 116.26,36.92 116.26,36.51 116.39,36.38 117.9,36.38 118.03,36.26 118.03,35.85 117.9,35.72 116.46,35.72 116.33,35.6 116.33,35.19 116.46,35.06 117.9,35.06 118.03,34.94 118.03,34.34 117.9,34.22 117.48,34.22 117.35,34.09 117.35,33.56 117.48,33.44 118.5,33.44 118.63,33.31 118.63,32.9 118.5,32.78 117.48,32.78 117.35,32.65 117.35,32.12 117.48,32 118.63,32 118.75,31.87 v3(118.75,31.65)
  BOTTOM w0.089: v3(122.47,78.2) JCPU1.AC3
  BOTTOM w0.165: v3(118.75,31.65) 119.72,30.69 119.72,28.45 119.34,28.07 JDIMM1.86
DDR_A_MA8: length 71.1
  IN4 w0.089: v3(121.48,80.24) 121.36,80.24 121.23,80.11 121.23,79.75 121.36,79.62 121.51,79.62 121.63,79.5 121.76,79.5 121.89,79.62 122.03,79.62 122.14,79.52 122.14,79.37 122.02,79.25 122.02,79.12 122.54,78.6 122.6,78.6 123.01,78.19 123.01,77.98 124.47,76.52 124.47,73.63
  IN4 w0.165: 124.47,73.63 124.47,65.23 123.39,64.15 123.39,55.39 123.27,55.26 118.43,55.26 118.3,55.13 118.3,54.73 118.43,54.6 122.69,54.6 122.81,54.47 122.81,54.07 122.69,53.94 118.02,53.94 117.85,53.77 117.85,53.44 118.02,53.28 118.77,53.28 118.94,53.11 118.94,52.78 118.77,52.62 118.02,52.62 117.85,52.45 117.85,52.12 118.02,51.96 118.77,51.96 118.94,51.79 118.94,51.46 118.77,51.3 118.02,51.3 117.85,51.13 117.85,48.71 118.19,48.37 118.19,38.45 118.3,38.33 v3(118.75,38.33)
  BOTTOM w0.089: v3(121.48,80.24) 121.94,79.78 JCPU1.AD5
  BOTTOM w0.165: v3(118.75,38.33) 118.75,38.11 118.86,38.01 119.18,38.01 119.28,38.11 119.28,39.57 119.39,39.68 120.14,39.68 120.24,39.57 JDIMM1.89
DDR_A_MA9: length 70
  IN4 w0.089: v3(122.47,77.2) 122.72,77.2 122.85,77.07 122.85,74.09 122.98,73.96 122.98,73.63
  IN4 w0.165: 122.98,73.63 122.98,65.85 121.91,64.77 121.91,62.34 121.74,62.18 120.78,62.18 120.65,62.05 120.65,61.64 120.78,61.51 121.74,61.51 121.91,61.35 121.91,60.89 121.78,60.76 116.49,60.76 116.37,60.64 116.37,60.23 116.49,60.1 121.78,60.1 121.91,59.98 121.91,59.57 121.78,59.44 116.49,59.44 116.37,59.32 116.37,58.91 116.49,58.78 118.82,58.78 118.95,58.65 118.95,58.25 118.82,58.12 116.49,58.12 116.37,57.99 116.37,48.09 116.7,47.76 116.7,40.29 v3(116.26,39.85)
  BOTTOM w0.089: v3(122.47,77.2) JCPU1.AC2
  BOTTOM w0.165: v3(116.26,39.85) 116.93,40.53 117.99,40.53 118.26,40.26 118.26,37.16 119.04,36.38 JDIMM1.85
DDR_A_MA10: length 72.8
  IN4 w0.089: v3(128.43,81.24) 128.46,81.24 128.59,81.11 128.59,80.89 128.46,80.76 128.02,80.76 127.89,80.89 127.89,81.72 128.02,81.85 128.91,81.85 129.03,81.72 129.03,79.11 129.35,78.79 130.75,78.79 130.85,78.69 130.85,75.46 131,75.3 131.37,75.3 131.53,75.13 131.53,74.73 131.41,74.6 130.56,74.6
  IN4 w0.165: v3(126.22,38.33) 126.99,39.11 126.99,41.45 130.52,44.98 130.52,63.73 130.69,63.9 131.24,63.9 131.36,64.02 131.36,64.43 131.24,64.56 130.69,64.56 130.52,64.72 130.52,65.05 130.69,65.22 131.68,65.22 131.81,65.34 131.81,65.75 131.68,65.88 130.64,65.88 130.51,66 130.51,66.46 130.64,66.59 131.68,66.59 131.81,66.71 131.81,67.12 131.68,67.25 130.64,67.25 130.51,67.37 130.51,67.78 130.64,67.91 131.68,67.91 131.81,68.03 131.81,68.44 131.68,68.57 130.64,68.57 130.51,68.69 130.51,69.1 130.64,69.23 131.68,69.23 131.81,69.35 131.81,69.76 131.68,69.89 130.64,69.89 130.51,70.01 130.51,70.42 130.64,70.55 131.68,70.55 131.81,70.67 131.81,71.08 131.68,71.21 130.69,71.21 130.52,71.37 130.52,71.7 130.69,71.87 131.68,71.87 131.81,72 131.81,72.4 131.68,72.53 130.69,72.53 130.52,72.69 130.52,73.02 130.69,73.19 131.68,73.19 131.81,73.32 131.81,73.72 131.68,73.85 130.56,73.85 130.43,73.98 130.43,74.48 130.56,74.6
  BOTTOM w0.089: v3(128.43,81.24) 127.94,80.75 JCPU1.V6
  BOTTOM w0.165: v3(126.22,38.33) 125.64,37.75 JDIMM1.107
DDR_A_MA11: length 68.8
  IN4 w0.089: v3(122.47,75.2) 122.49,75.18 122.49,73.63
  IN4 w0.165: v3(118.75,30.13) 118.75,29.92 118.63,29.79 116.98,29.79 116.85,29.92 116.85,30.56 117.02,30.72 117.95,30.72 118.11,30.89 118.11,31.22 117.95,31.38 117.02,31.38 116.85,31.55 116.85,33.97 115.77,35.06 115.77,40.74 116.21,41.18 116.21,47.55 115.87,47.89 115.87,61.18 116,61.3 120.03,61.3 120.16,61.43 120.16,61.84 120.03,61.97 116,61.97 115.87,62.09 115.87,62.73 116,62.86 121.29,62.86 121.41,62.98 121.41,64.97 122.49,66.05 122.49,73.63
  BOTTOM w0.089: JCPU1.AC1 122.94,75.67 v3(122.47,75.2)
  BOTTOM w0.165: JDIMM1.84 118.74,28.26 119.21,28.73 119.21,29.91 118.99,30.13 v3(118.75,30.13)
DDR_A_MA12: length 71.5
  IN4 w0.089: 123.48,73.63 123.48,74.35 123.04,74.79 123.04,77.18 122.62,77.6 122.54,77.6 121.88,78.26 121.88,78.73 v3(121.42,79.19)
  IN4 w0.165: 123.48,73.63 123.48,65.64 122.4,64.56 122.4,59.07 122.28,58.95 119.57,58.95 119.45,58.82 119.45,58.41 119.57,58.29 122.15,58.29 122.28,58.16 122.28,57.75 122.15,57.63 117.41,57.63 117.29,57.5 117.29,57.09 117.41,56.97 122.28,56.97 122.4,56.84 122.4,56.38 122.28,56.25 117.35,56.25 116.86,55.76 116.86,48.3 117.2,47.96 117.2,40.09 116.84,39.73 116.84,39.05 116.26,38.47 v3(116.26,38.33)
  BOTTOM w0.089: JCPU1.AD4 121.88,78.73 v3(121.42,79.19)
  BOTTOM w0.165: v3(116.26,38.33) 116.81,38.88 116.81,39.24 116.91,39.35 117.66,39.35 117.76,39.24 117.76,38.2 117.66,38.1 117.13,38.1 117.03,38 117.03,37.53 117.13,37.43 117.66,37.43 117.76,37.33 117.76,36.95 118.44,36.28 JDIMM1.83
DDR_A_MA13: length 65.3
  IN4 w0.089: 134.29,73.63 134.29,73.85 133.07,75.07 133.07,82.13 132.63,82.57 128.79,82.57 v3(128.44,82.23)
  IN4 w0.165: 134.29,73.63 134.29,63.35 134.91,62.73 134.91,49.69 134.74,49.52 133.23,49.52 133.1,49.4 133.1,48.89 133.27,48.72 134.78,48.72 134.91,48.6 134.91,48.19 134.78,48.06 133.27,48.06 133.1,47.9 133.1,47.57 133.27,47.4 134.78,47.4 134.91,47.27 134.91,46.87 134.78,46.74 133.27,46.74 133.1,46.58 133.1,43.98 129.99,40.87 129.99,40.45 v3(130.59,39.85)
  BOTTOM w0.089: v3(128.44,82.23) 127.94,81.73 JCPU1.V7
  BOTTOM w0.165: JDIMM1.119 129.24,37.03 129.43,37.22 129.43,40.54 129.53,40.64 130.04,40.64 130.15,40.54 130.15,40.3 v3(130.59,39.85)
DDR_A_MA14: length 70.1
  IN4 w0.089: v3(121.47,78.16) 121.36,78.16 121.23,78.04 121.23,77.75 121.36,77.62 121.97,77.62 122.1,77.5 122.1,76.57 121.97,76.44 121.72,76.44 121.59,76.32 121.59,74.25 121.5,74.16 121.5,73.63
  IN4 w0.165: 121.5,73.63 121.5,69.86 121.33,69.69 121.33,69.46 121.48,69.31 121.48,69.08 121.24,68.85 121.01,68.85 120.87,68.99 120.63,68.99 120.4,68.76 120.4,68.52 120.68,68.25 120.68,68.07 120.39,67.78 120.21,67.78 119.93,68.06 119.7,68.06 119.47,67.82 119.47,67.59 119.88,67.17 119.88,66.99 119.6,66.71 119.42,66.71 119,67.12 118.77,67.12 114.88,63.24 114.88,51.56 114.75,51.43 114.38,51.43 114.17,51.22 114.17,50.78 114.34,50.61 114.71,50.61 114.88,50.45 114.88,50.12 114.71,49.95 114.34,49.95 114.17,49.79 114.17,49.46 114.34,49.29 114.71,49.29 114.88,49.13 114.88,48.8 114.71,48.63 114.34,48.63 114.17,48.47 114.17,48.14 114.34,47.97 114.71,47.97 114.88,47.81 114.88,47.48 114.71,47.31 114.34,47.31 114.17,47.15 114.17,46.82 114.34,46.65 115.09,46.65 115.22,46.52 115.22,46.12 115.09,45.99 114.34,45.99 114.17,45.83 114.17,45.5 114.34,45.33 115.09,45.33 115.22,45.2 115.22,44.8 115.09,44.67 114.34,44.67 114.17,44.51 114.17,44.17 114.34,44.01 115.09,44.01 115.22,43.88 115.22,41.59 114.78,41.15 114.78,34.11 115.64,33.25 115.64,31.78 115.76,31.65 v3(116.26,31.65)
  BOTTOM w0.089: JCPU1.AD3 121.9,77.73 v3(121.47,78.16)
  BOTTOM w0.165: JDIMM1.80 117.54,29.82 117.98,30.25 117.98,31.9 117.88,32.01 116.61,32.01 v3(116.26,31.65)
DDR_A_MA15: length 68.6
  IN4 w0.089: v3(121.47,77.25) 121.47,77.31 121.6,77.43 121.78,77.43 121.91,77.31 121.91,76.83 121.78,76.7 121.49,76.7 121.36,76.57 121.36,74.41 121,74.05 121,73.63
  IN4 w0.165: 121,73.63 121,70.06 114.38,63.44 114.38,52.13 113.68,51.42 113.68,43.62 113.84,43.45 114.59,43.45 114.72,43.33 114.72,42.92 114.59,42.79 113.84,42.79 113.68,42.63 113.68,42.3 113.84,42.13 114.4,42.13 114.52,42 114.52,41.6 114.4,41.47 113.84,41.47 113.68,41.31 113.68,40.7 113.86,40.53 114.12,40.53 114.28,40.36 114.28,40.03 114.12,39.87 113.83,39.87 113.68,39.71 113.68,39.38 113.86,39.21 114.12,39.21 114.28,39.04 114.28,38.71 114.12,38.55 113.83,38.55 113.68,38.39 113.68,38.06 113.86,37.89 114.12,37.89 114.28,37.72 114.28,37.39 114.12,37.22 113.83,37.22 113.68,37.07 113.68,36.74 113.86,36.56 114.12,36.56 114.28,36.4 114.28,36.07 114.12,35.9 113.83,35.9 113.68,35.75 113.68,35.42 113.86,35.24 114.12,35.24 114.28,35.08 114.28,34.57 114.12,34.4 113.83,34.4 113.7,34.28 113.7,33.87 113.83,33.74 114.12,33.74 114.28,33.58 114.28,33.33 114.41,33.2 114.98,33.2 115.14,33.04 115.14,32.06 115.01,31.93 114.92,31.93 114.79,31.8 114.79,31.3 114.92,31.17 115.57,31.17 115.7,31.05 115.7,30.41 115.57,30.28 114.54,30.28 114.41,30.15 114.41,29.52 114.54,29.39 115.64,29.39 116.03,29.79 116.14,29.79 116.26,29.92 v3(116.26,30.13)
  BOTTOM w0.089: v3(121.47,77.25) 121.94,76.78 JCPU1.AD2
  BOTTOM w0.165: v3(116.26,30.13) 116.94,29.45 JDIMM1.78
DDR_A_RAS#: length 69.8
  IN4 w0.089: v3(129.43,80.2) 129.83,79.8 131.4,79.8 131.85,79.35 131.85,75.49 132.8,74.53 132.8,73.63
  IN4 w0.165: v3(126.32,30.13) 126.32,30.1 125.86,29.64 125.86,28.88 125.99,28.76 128.24,28.76 128.37,28.88 128.37,29.29 128.24,29.42 127.64,29.42 127.51,29.55 127.51,29.96 127.64,30.08 128.24,30.08 128.37,30.21 128.37,35.92 128.53,36.08 130.62,36.08 130.75,36.21 130.75,36.62 130.62,36.74 128.53,36.74 128.37,36.91 128.37,39.73 127.99,40.11 127.99,41.04 131.58,44.64 131.58,62.85 132.8,64.06 132.8,73.63
  BOTTOM w0.089: v3(129.43,80.2) 128.94,80.69 JCPU1.U6
  BOTTOM w0.165: v3(126.32,30.13) 126.89,29.56 126.89,28.53 126.54,28.17 JDIMM1.110
DDR_A_WE#: length 65.8
  IN4 w0.089: v3(129.47,81.2) 130.07,80.6 131.6,80.6 132.06,80.14 132.06,75.54 133.3,74.3 133.3,73.63
  IN4 w0.165: v3(128.94,39.85) 128.5,40.29 128.5,40.86 132.11,44.47 132.11,53.72 132.24,53.84 132.93,53.84 133.1,54.01 133.1,54.34 132.93,54.5 132.21,54.5 132.08,54.63 132.08,55.04 132.21,55.17 132.93,55.17 133.1,55.33 133.1,55.66 132.93,55.83 132.24,55.83 132.11,55.95 132.11,56.36 132.24,56.49 132.93,56.49 133.1,56.65 133.1,56.98 132.93,57.15 132.21,57.15 132.08,57.27 132.08,57.68 132.21,57.81 132.93,57.81 133.1,57.97 133.1,58.3 132.93,58.47 132.21,58.47 132.08,58.59 132.08,59 132.21,59.13 132.93,59.13 133.1,59.29 133.1,59.62 132.93,59.79 132.24,59.79 132.11,59.92 132.11,60.32 132.24,60.45 132.93,60.45 133.1,60.61 133.1,60.94 132.93,61.11 132.21,61.11 132.08,61.24 132.08,61.64 132.21,61.77 132.93,61.77 133.1,61.93 133.1,62.26 132.93,62.43 132.55,62.43 132.42,62.56 132.42,62.98 132.55,63.11 132.97,63.11 133.3,63.44 133.3,73.63
  BOTTOM w0.089: v3(129.47,81.2) JCPU1.U7
  BOTTOM w0.165: JDIMM1.113 127.44,36.5 127.69,36.75 127.69,37.81 127.54,37.96 127.3,37.96 127.2,38.06 127.2,38.85 127.3,38.95 127.55,38.95 127.79,39.19 127.79,40.39 127.9,40.5 128.45,40.5 128.56,40.39 128.56,39.96 128.66,39.85 v3(128.94,39.85)
DDR_B_BS0: length 81.9
  IN1 w0.089: v3(131.47,81.2) 130.88,80.61 130.88,80.08 130.6,79.8 129.27,79.8 128.1,78.62 128.1,74.84 128.41,74.53 128.41,73.63
  IN1 w0.165: 128.41,73.63 128.41,63.41 128.76,63.07 128.76,57.68 126.29,55.21 126.29,54.02 126.16,53.89 125.03,53.89 124.91,53.77 124.91,53.36 125.03,53.23 126.11,53.23 126.24,53.11 126.24,52.7 126.11,52.57 125.03,52.57 124.91,52.45 124.91,52.04 125.03,51.91 126.18,51.91 126.3,51.79 126.3,51.38 126.18,51.25 125.03,51.25 124.91,51.13 124.91,50.72 125.03,50.59 126.16,50.59 126.29,50.47 126.29,41.51 126.76,41.04 126.76,28.43 126.59,28.27 126.11,28.27 125.98,28.14 125.98,27.73 126.11,27.61 126.59,27.61 126.76,27.44 126.76,27.11 126.59,26.95 126.11,26.95 125.98,26.82 125.98,26.41 126.11,26.29 126.59,26.29 126.76,26.12 126.76,23.61 126.59,23.44 126.47,23.44 126.3,23.28 126.3,22.95 126.47,22.78 126.59,22.78 126.76,22.62 126.76,22.29 126.59,22.12 126.15,22.12 126.02,21.99 126.02,21.59 126.15,21.46 126.59,21.46 126.76,21.3 126.76,19.24 126.63,19.11 126.19,19.11 126.06,19.24 v3(126.06,19.45)
  BOTTOM w0.089: v3(131.47,81.2) JCPU1.R7
  BOTTOM w0.165: JDIMM2.109 126.24,21.14 126.66,20.71 126.66,20.05 v3(126.06,19.45)
DDR_B_BS1: length 83.6
  IN1 w0.089: 128.91,73.63 128.91,75.01 128.87,75.05 128.87,79.13 129.34,79.6 130.67,79.6 131.07,80 131.07,80.33 131.41,80.66 131.47,80.66 131.87,81.07 131.87,81.6 v3(132.47,82.2)
  IN1 w0.165: v3(126.06,17.17) 126.06,16.95 126.19,16.82 127.12,16.82 127.25,16.95 127.25,17.72 127.09,17.88 126.62,17.88 126.49,18.01 126.49,18.42 126.62,18.54 127.09,18.54 127.25,18.71 127.25,52.17 127.42,52.33 129.19,52.33 129.35,52.5 129.35,52.83 129.19,52.99 127.42,52.99 127.25,53.16 127.25,53.68 127.38,53.81 129.13,53.81 129.26,53.93 129.26,54.51 129.09,54.68 128.39,54.68 128.26,54.8 128.26,55.21 128.39,55.34 129.09,55.34 129.26,55.5 129.26,55.83 129.09,56 128.43,56 128.31,56.12 128.31,56.53 128.43,56.66 129.09,56.66 129.26,56.82 129.26,63.27 128.91,63.62 128.91,73.63
  BOTTOM w0.089: v3(132.47,82.2) JCPU1.P8
  BOTTOM w0.165: v3(126.06,17.17) 125.55,16.65 125.55,15.46 125.94,15.06 JDIMM2.108
DDR_B_BS2: length 80.2
  IN1 w0.089: 119.34,73.63 119.34,74.67 119.07,74.94 119.07,82.33 120.43,83.69 123.96,83.69 v3(124.47,84.2)
  IN1 w0.165: 119.34,73.63 119.34,63.22 113.73,57.61 113.73,42.29 113.21,41.77 113.21,33.72 112.69,33.2 112.69,29.08 113.21,28.56 113.21,26.73 113.84,26.09 113.84,20.87 115.54,19.17 115.54,18.37 v3(115.98,17.93)
  BOTTOM w0.089: v3(124.47,84.2) JCPU1.AA9
  BOTTOM w0.165: v3(115.98,17.93) 116.54,18.49 116.54,20.38 117.24,21.07 JDIMM2.79
DDR_B_CAS#: length 83.7
  IN1 w0.089: 130.36,73.63 130.36,74.51 129.91,74.96 129.91,78.16 130.34,78.6 130.67,78.6 131.07,79 131.07,79.33 131.34,79.6 131.4,79.6 132.06,80.26 132.06,80.79 v3(132.47,81.2)
  IN1 w0.165: 130.36,73.63 130.36,48.55 130.23,48.42 128.37,48.42 128.24,48.29 128.24,47.89 128.37,47.76 130.23,47.76 130.36,47.63 130.36,47.23 130.23,47.1 128.37,47.1 128.24,46.97 128.24,46.57 128.37,46.44 130.23,46.44 130.36,46.31 130.36,45.9 130.23,45.78 128.37,45.78 128.24,45.65 128.24,45.24 128.37,45.12 130.18,45.12 130.3,44.99 130.3,44.58 130.18,44.46 128.37,44.46 128.24,44.33 128.24,36.69 128.41,36.53 129.45,36.53 129.58,36.4 129.58,36 129.45,35.87 128.41,35.87 128.24,35.7 128.24,35.37 128.41,35.21 129.45,35.21 129.58,35.08 129.58,34.67 129.45,34.55 128.41,34.55 128.24,34.38 128.24,29.11 128.41,28.95 128.68,28.95 128.84,28.78 128.84,28.45 128.68,28.29 128.41,28.29 128.24,28.12 128.24,27.79 128.41,27.63 128.88,27.63 129,27.5 129,27.09 128.88,26.97 128.41,26.97 128.24,26.8 128.24,26.47 128.41,26.31 128.88,26.31 129,26.18 129,25.77 128.88,25.65 128.41,25.65 128.24,25.48 128.24,24.4 128.37,24.27 v3(128.89,24.27)
  BOTTOM w0.089: v3(132.47,81.2) JCPU1.P7
  BOTTOM w0.165: v3(128.89,24.27) 128.04,23.43 JDIMM2.115
DDR_B_D0: length 88.4
  IN1 w0.089: v3(110.47,92.2) 109.96,91.69 109,91.69 108.74,91.43
  IN1 w0.102: 108.74,91.43 96.29,78.99 96.29,54.27 94.99,52.97 94.99,50.76 93.56,49.32 93.56,42.89 91.35,40.68 91.35,36.02 91.45,35.92 92.04,35.92 92.14,35.81 92.14,35.51 92.04,35.41 91.45,35.41 91.35,35.31 91.35,26.36 91.19,26.2 91.19,25.29 91.66,24.81 91.66,23.61 91.56,23.5 91.19,23.5 91.06,23.38 91.06,23.12 91.19,23 91.56,23 91.66,22.89 91.66,22.59 91.53,22.47 91.17,22.47 91.04,22.34 91.04,22.01 91.17,21.88 91.53,21.88 91.63,21.78 91.63,21.47 91.53,21.37 91.17,21.37 91.04,21.25 91.04,20.14 91.19,19.99 v3(91.56,19.99)
  BOTTOM w0.089: v3(110.47,92.2) 110.94,92.67 JCPU1.AR18
  BOTTOM w0.102: v3(91.56,19.99) 92.64,21.07 JDIMM2.5
DDR_B_D1: length 87.2
  IN1 w0.089: 108.74,91.9 109.04,92.2 v3(109.47,92.2)
  IN1 w0.102: 108.74,91.9 95.99,79.15 95.99,54.4 94.69,53.1 94.69,50.88 93.25,49.45 93.25,43.01 91.04,40.8 91.04,26.49 90.88,26.33 90.88,24.32 90.74,24.18 90.74,19.29 v3(91.56,18.47)
  BOTTOM w0.089: JCPU1.AT18 109.94,92.67 v3(109.47,92.2)
  BOTTOM w0.102: JDIMM2.7 93.24,20.15 v3(91.56,18.47)
DDR_B_D2: length 92.8
  IN1 w0.089: 108.85,87.68 108.96,87.8 109.6,87.8 110.06,88.26 110.06,88.32 110.53,88.79 111.59,88.79 111.88,89.08 111.88,89.41 112.26,89.79 112.59,89.79 112.88,90.08 112.88,90.81 113.27,91.2 v3(113.47,91.2)
  IN1 w0.102: v3(94.95,19.99) 94.95,19.8 95.08,19.68 95.23,19.68 95.35,19.8 95.35,20.18 95.39,20.22 95.59,20.22 95.71,20.35 95.71,20.58 95.59,20.71 95.48,20.71 95.35,20.84 95.35,23.3 95.23,23.43 94.95,23.43 94.82,23.55 94.82,24.58 95.13,24.88 95.74,24.88 95.87,25.01 95.87,25.52 95.74,25.65 94.81,25.65 94.68,25.78 94.68,26.03 94.81,26.16 95.74,26.16 95.87,26.29 95.87,26.54 95.74,26.67 94.74,26.67 94.62,26.79 94.62,27.05 94.74,27.17 95.74,27.17 95.87,27.3 95.87,27.56 95.74,27.68 95.25,27.68 95.12,27.81 95.12,28.06 95.25,28.19 95.74,28.19 95.87,28.32 95.87,34.56 95.77,34.66 95.38,34.66 95.26,34.79 95.26,35.04 95.38,35.17 95.77,35.17 95.87,35.27 95.87,35.68 95.74,35.8 95.38,35.8 95.26,35.93 95.26,41.12 96.01,41.87 96.01,48.3 97.44,49.74 97.44,51.95 98.79,53.3 98.79,77.82 108.66,87.68 108.85,87.68
  BOTTOM w0.089: JCPU1.AM17 113.94,91.67 v3(113.47,91.2)
  BOTTOM w0.102: JDIMM2.15 95.64,20.68 v3(94.95,19.99)
DDR_B_D3: length 92
  IN1 w0.089: v3(113.47,92.2) 113.85,91.82 113.85,91.04 113.56,90.75 113.5,90.75 113.07,90.33 113.07,90 112.67,89.6 112.34,89.6 112.07,89.33 112.07,89 111.67,88.6 111.34,88.6 110.87,88.13 110.87,88.07 110.4,87.6 109.23,87.6 108.85,87.22
  IN1 w0.102: 108.85,87.22 108.66,87.22 99.1,77.66 99.1,53.18 97.75,51.83 97.75,49.61 96.31,48.18 96.31,41.74 95.56,40.99 95.56,36.92 96.17,36.31 96.17,24.41 95.66,23.9 95.66,23.09 95.76,22.99 96.04,22.99 96.14,22.89 96.14,22.59 96.04,22.48 95.76,22.48 95.66,22.38 95.66,22.08 95.76,21.98 96.04,21.98 96.14,21.88 96.14,21.57 96.04,21.47 95.76,21.47 95.66,21.37 95.66,21.06 95.76,20.96 96.04,20.96 96.14,20.86 96.14,20.12 96.01,19.99 95.79,19.99 95.66,19.87 95.66,19.58 95.79,19.45 96.27,19.45 96.39,19.32 96.39,19.07 96.27,18.94 95.79,18.94 95.66,18.82 95.66,18.69 95.44,18.47 v3(94.95,18.47)
  BOTTOM w0.089: JCPU1.AM18 113.94,92.67 v3(113.47,92.2)
  BOTTOM w0.102: JDIMM2.17 96.24,19.76 v3(94.95,18.47)
DDR_B_D4: length 88.6
  IN1 w0.089: v3(110.47,91.2) 110.07,91.2 109.67,90.8 109.04,90.8 108.74,90.5
  IN1 w0.102: v3(91.56,15.42) 92.65,15.42 92.78,15.55 92.78,15.83 92.65,15.95 92.4,15.95 92.27,16.08 92.27,25.06 91.8,25.54 91.8,25.95 91.96,26.11 91.96,27.64 92.78,28.46 92.78,41.24 94.16,42.63 94.16,49.07 95.6,50.5 95.6,52.72 96.9,54.02 96.9,78.66 108.74,90.5
  BOTTOM w0.089: v3(110.47,91.2) 110.94,91.67 JCPU1.AR17
  BOTTOM w0.102: v3(91.56,15.42) 92.1,15.42 92.34,15.18 JDIMM2.4
DDR_B_D5: length 87.8
  IN1 w0.089: v3(109.47,91.2) 108.97,91.2 108.74,90.96
  IN1 w0.102: 108.74,90.96 96.6,78.82 96.6,54.14 95.3,52.84 95.3,50.63 93.86,49.19 93.86,42.76 91.65,40.55 91.65,36.53 91.78,36.4 92.34,36.4 92.47,36.27 92.47,28.59 91.65,27.77 91.65,26.23 91.49,26.08 91.49,25.41 91.97,24.94 91.97,17.07 91.84,16.94 v3(91.56,16.94)
  BOTTOM w0.089: v3(109.47,91.2) 109.94,91.67 JCPU1.AT17
  BOTTOM w0.102: JDIMM2.6 92.94,15.56 v3(91.56,16.94)
DDR_B_D6: length 92.1
  IN1 w0.089: v3(112.47,91.2) 111.88,90.61 111.88,90.08 111.59,89.79 110.26,89.79 109.88,89.41 109.88,89.08 109.6,88.8 109.02,88.8 108.85,88.62
  IN1 w0.102: v3(94.95,15.42) 94.19,16.18 94.19,18.62 94.08,18.72 93.61,18.72 93.51,18.82 93.51,19.13 93.61,19.23 94.08,19.23 94.19,19.33 94.19,19.63 94.08,19.74 93.61,19.74 93.51,19.84 93.51,20.14 93.61,20.24 94.08,20.24 94.19,20.34 94.19,20.65 94.08,20.75 93.61,20.75 93.51,20.85 93.51,21.16 93.61,21.26 94.08,21.26 94.19,21.36 94.19,24.69 93.79,25.09 93.79,27.73 95.26,29.2 95.26,33.75 94.65,34.36 94.65,41.37 95.4,42.12 95.4,48.56 96.83,49.99 96.83,52.21 98.18,53.56 98.18,78.15 108.66,88.62 108.85,88.62
  BOTTOM w0.089: JCPU1.AN17 112.94,91.67 v3(112.47,91.2)
  BOTTOM w0.102: v3(94.95,15.42) 95.6,15.42 95.94,15.08 JDIMM2.16
DDR_B_D7: length 91
  IN1 w0.089: v3(112.47,92.2) 112.85,91.82 112.85,91.04 112.4,90.6 112.34,90.6 112.07,90.33 112.07,90 111.67,89.6 110.34,89.6 110.07,89.33 110.07,89 109.67,88.6 109.29,88.6 108.85,88.15
  IN1 w0.102: v3(94.95,16.94) 94.75,16.94 94.52,17.17 94.52,21.24 94.62,21.34 94.9,21.34 95,21.44 95,21.74 94.9,21.85 94.62,21.85 94.52,21.95 94.52,22.29 94.62,22.4 94.83,22.4 94.93,22.5 94.93,22.8 94.83,22.9 94.62,22.9 94.52,23.01 94.52,24.85 94.31,25.06 94.31,27.68 95.56,28.93 95.56,34.23 95.43,34.35 95.08,34.35 94.95,34.48 94.95,41.25 95.7,42 95.7,48.43 97.14,49.87 97.14,52.08 98.49,53.43 98.49,77.99 108.66,88.15 108.85,88.15
  BOTTOM w0.089: JCPU1.AN18 112.94,92.67 v3(112.47,92.2)
  BOTTOM w0.102: v3(94.95,16.94) 96.54,15.35 JDIMM2.18
DDR_B_D8: length 77.9
  IN1 w0.089: v3(109.47,86.2) 109,86.2 108.74,85.93
  IN1 w0.102: v3(97.49,19.23) 96.68,20.04 96.68,24.07 97.29,24.68 97.29,28.34 96.68,28.95 96.68,36.52 96.07,37.13 96.07,40.78 96.82,41.53 96.82,47.97 98.26,49.4 98.26,51.62 99.61,52.97 99.61,61.39 105.12,66.9 105.12,82.32 108.74,85.93
  BOTTOM w0.089: v3(109.47,86.2) 109.94,86.67 JCPU1.AT12
  BOTTOM w0.102: JDIMM2.21 97.44,21.38 97,20.93 97,19.72 v3(97.49,19.23)
DDR_B_D9: length 79.1
  IN1 w0.089: v3(110.47,86.2) 110.07,85.8 109.04,85.8 108.74,85.5
  IN1 w0.102: v3(97.49,20.75) 97.04,20.75 96.98,20.81 96.98,21.44 97.09,21.54 97.44,21.54 97.54,21.64 97.54,21.95 97.44,22.05 97.09,22.05 96.98,22.15 96.98,22.45 97.09,22.56 97.44,22.56 97.54,22.66 97.54,22.96 97.44,23.06 97.09,23.06 96.98,23.17 96.98,23.95 97.59,24.55 97.59,28.56 96.98,29.16 96.98,34.49 97.09,34.59 97.46,34.59 97.59,34.72 97.59,34.97 97.46,35.1 97.09,35.1 96.98,35.2 96.98,35.51 97.09,35.61 97.46,35.61 97.59,35.74 97.59,35.99 97.46,36.12 97.09,36.12 96.98,36.22 96.98,36.65 96.37,37.26 96.37,40.66 97.12,41.41 97.12,47.84 98.56,49.28 98.56,51.49 99.91,52.84 99.91,61.26 105.43,66.78 105.43,82.19 108.74,85.5
  BOTTOM w0.089: v3(110.47,86.2) 110.94,86.67 JCPU1.AR12
  BOTTOM w0.102: JDIMM2.23 98.04,21.31 v3(97.49,20.75)
DDR_B_D10: length 83.2
  IN1 w0.089: 108.85,80.65 109,80.8 109.6,80.8 109.87,81.07 109.87,81.13 110.54,81.8 110.6,81.8 110.87,82.07 110.87,82.13 111.53,82.79 111.59,82.79 111.88,83.08 111.88,83.14 112.54,83.8 112.6,83.8 112.85,84.04 112.85,85.82 v3(112.47,86.2)
  IN1 w0.102: v3(100.79,20.75) 100.64,20.91 100.64,23.5 100.13,24.01 100.13,27.49 100.69,28.05 100.69,36.45 100.21,36.94 100.21,39.9 99.58,40.53 99.58,43.34 99.68,43.45 100.61,43.45 100.71,43.55 100.71,43.85 100.61,43.95 99.68,43.95 99.58,44.06 99.58,44.36 99.68,44.46 100.61,44.46 100.71,44.56 100.71,44.87 100.61,44.97 99.68,44.97 99.58,45.07 99.58,45.38 99.68,45.48 100.61,45.48 100.71,45.58 100.71,45.88 100.61,45.99 99.7,45.99 99.58,46.11 99.58,46.54 99.7,46.66 101.53,46.66 101.77,46.9 101.77,49.01 103.18,50.42 103.18,52.72 103.28,52.82 103.71,52.82 103.81,52.92 103.81,53.23 103.71,53.33 103.28,53.33 103.18,53.43 103.18,54.37 103.3,54.49 103.7,54.49 103.83,54.62 103.83,61.71 107.95,65.84 107.95,79.76 108.85,80.65
  BOTTOM w0.089: v3(112.47,86.2) 112.94,86.67 JCPU1.AN12
  BOTTOM w0.102: JDIMM2.33 101.04,21 v3(100.79,20.75)
DDR_B_D11: length 83.7
  IN1 w0.089: 108.85,79.86 108.85,80.1 109.35,80.61 110.41,80.61 110.87,81.07 110.87,81.13 111.54,81.8 111.6,81.8 112.01,82.21 112.01,82.27 112.54,82.8 112.6,82.8 113.07,83.27 113.07,84.8 v3(113.47,85.2)
  IN1 w0.102: v3(100.79,19.23) 101.16,19.23 101.26,19.34 101.26,21.19 101,21.45 101,23.87 100.43,24.43 100.43,26.38 100.53,26.48 100.87,26.48 101,26.61 101,26.86 100.87,26.99 100.53,26.99 100.43,27.09 100.43,27.36 100.56,27.49 100.87,27.49 101,27.61 101,36.58 100.51,37.06 100.51,40.4 100.41,40.51 100.05,40.51 99.95,40.61 99.95,40.89 100.08,41.01 100.9,41.01 101.02,41.14 101.02,41.4 100.9,41.52 100.01,41.52 99.88,41.65 99.88,41.9 100.01,42.03 100.9,42.03 101.02,42.16 101.02,42.41 100.9,42.54 100.01,42.54 99.88,42.67 99.88,42.92 100.01,43.05 100.9,43.05 101.02,43.17 101.02,46.23 101.15,46.36 101.66,46.36 102.07,46.77 102.07,48.89 103.48,50.3 103.48,52.16 104.13,52.82 104.13,61.59 108.26,65.71 108.26,79.27 108.85,79.86
  BOTTOM w0.089: v3(113.47,85.2) 113.94,85.67 JCPU1.AM11
  BOTTOM w0.102: JDIMM2.35 101.64,20.08 v3(100.79,19.23)
DDR_B_D12: length 78.3
  IN1 w0.102: v3(97.49,16.18) 98.29,16.98 98.29,36.21 96.98,37.51 96.98,40.4 97.73,41.15 97.73,47.59 99.17,49.02 99.17,51.24 100.52,52.59 100.52,61.01 106.04,66.52 106.04,81.59 108.87,84.42 108.87,84.6 v3(109.47,85.2)
  BOTTOM w0.089: v3(109.47,85.2) 109.94,85.67 JCPU1.AT11
  BOTTOM w0.102: JDIMM2.22 97.74,15.04 98,15.29 98,15.67 v3(97.49,16.18)
DDR_B_D13: length 79.9
  IN1 w0.089: 108.85,85.14 109.28,85.57 110.02,85.57 110.39,85.2 v3(110.47,85.2)
  IN1 w0.102: v3(97.49,17.71) 97.89,18.11 97.89,36.17 96.68,37.39 96.68,40.53 97.43,41.28 97.43,47.71 98.87,49.15 98.87,51.36 100.22,52.71 100.22,61.14 105.73,66.65 105.73,82.02 108.85,85.14
  BOTTOM w0.089: v3(110.47,85.2) 110.94,85.67 JCPU1.AR11
  BOTTOM w0.102: v3(97.49,17.71) 97.94,17.26 97.94,16.86 98.34,16.45 JDIMM2.24
DDR_B_D14: length 84.7
  IN1 w0.089: v3(113.47,86.2) 113.1,86.57 112.32,86.57 112.06,86.31 112.06,85.25 111.4,84.6 111.34,84.6 111.07,84.33 111.07,84.27 110.6,83.8 110.54,83.8 109.87,83.13 109.87,83.07 109.4,82.6 109.34,82.6 108.85,82.1
  IN1 w0.102: 108.85,82.1 107.34,80.6 107.34,66.09 103.22,61.97 103.22,57.84 103.12,57.74 102.63,57.74 102.53,57.63 102.53,57.33 102.63,57.23 103.12,57.23 103.22,57.13 103.22,56.25 103.09,56.12 102.63,56.12 102.53,56.02 102.53,55.71 102.63,55.61 103.09,55.61 103.19,55.51 103.19,55.21 103.09,55.1 102.63,55.1 102.57,55.04 102.57,50.68 98.97,47.08 98.97,37.27 99.52,36.72 99.52,34.67 100.08,34.11 100.08,28.3 99.52,27.74 99.52,23.75 100.03,23.24 100.03,16.25 100.09,16.18 v3(100.79,16.18)
  BOTTOM w0.089: v3(113.47,86.2) 113.94,86.67 JCPU1.AM12
  BOTTOM w0.102: v3(100.79,16.18) 101.34,15.63 JDIMM2.34
DDR_B_D15: length 83.2
  IN1 w0.089: v3(112.47,85.2) 112.07,84.8 112.07,84.27 111.6,83.8 111.54,83.8 110.87,83.13 110.87,83.07 110.6,82.8 110.54,82.8 109.87,82.13 109.87,82.07 109.6,81.8 109.3,81.8 108.85,81.35
  IN1 w0.102: v3(100.79,17.71) 100.46,17.71 100.33,17.83 100.33,23.37 99.82,23.88 99.82,27.61 100.39,28.18 100.39,34.57 100.29,34.68 99.95,34.68 99.82,34.8 99.82,35.06 99.95,35.18 100.29,35.18 100.39,35.29 100.39,35.61 100.26,35.74 99.95,35.74 99.82,35.87 99.82,36.85 99.27,37.4 99.27,46.84 99.4,46.97 100.88,46.97 101,47.09 101,47.35 100.88,47.48 100.3,47.48 100.18,47.6 100.18,47.86 100.3,47.98 101.33,47.98 101.46,48.11 101.46,49.14 102.87,50.55 102.87,54.67 103,54.8 103.4,54.8 103.52,54.93 103.52,61.84 107.65,65.96 107.65,80.15 108.85,81.35
  BOTTOM w0.089: JCPU1.AN11 112.94,85.67 v3(112.47,85.2)
  BOTTOM w0.102: JDIMM2.36 101.94,16.56 v3(100.79,17.71)
DDR_B_D16: length 71.4
  IN1 w0.102: v3(110.47,79.2) 110.09,78.82 110.09,75.76 109.68,75.35 109.68,65.12 105.56,61 105.56,52.22 104.9,51.57 104.9,49.5 103.49,48.09 103.49,45.09 103.42,45.02 102.74,45.02 102.62,44.89 102.62,44.64 102.74,44.51 103.39,44.51 103.52,44.38 103.52,44.13 103.39,44 102.55,44 102.45,43.9 102.45,43.59 102.55,43.49 103.39,43.49 103.52,43.37 103.52,43.11 103.39,42.98 102.55,42.98 102.45,42.88 102.45,42.58 102.55,42.48 103.39,42.48 103.52,42.35 103.52,42.1 103.39,41.97 102.55,41.97 102.45,41.87 102.45,41.56 102.55,41.46 103.05,41.46 103.17,41.33 103.17,41.08 103.05,40.95 102.55,40.95 102.45,40.85 102.45,22.35 103.33,21.46 v3(103.33,20.75)
  BOTTOM w0.089: JCPU1.AR5 110.94,79.67 v3(110.47,79.2)
  BOTTOM w0.102: v3(103.33,20.75) 102.84,21.24 JDIMM2.39
DDR_B_D17: length 72.3
  IN1 w0.102: v3(110.47,80.2) 110.47,80.28 110.34,80.41 110.01,80.41 109.89,80.28 109.89,76.12 109.38,75.61 109.38,65.25 105.25,61.12 105.25,52.35 104.6,51.7 104.6,49.63 103.19,48.22 103.19,45.46 103.09,45.36 102.24,45.36 102.14,45.26 102.14,22.18 102.43,21.89 102.43,21.25 102.53,21.15 102.8,21.15 102.92,21.02 102.92,20.76 102.8,20.64 102.53,20.64 102.43,20.54 102.43,20.23 102.53,20.13 102.8,20.13 102.92,20 102.92,19.75 102.8,19.62 102.53,19.62 102.43,19.52 102.43,19.1 102.56,18.98 103.2,18.98 103.33,19.1 v3(103.33,19.23)
  BOTTOM w0.089: JCPU1.AR6 110.94,80.67 v3(110.47,80.2)
  BOTTOM w0.102: JDIMM2.41 103.44,21.23 103.79,20.88 103.79,19.69 v3(103.33,19.23)
