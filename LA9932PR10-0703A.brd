# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SD_D2: length 39.3
  TOP w0.102: v3(183.26,30.72) 183.71,30.28 184.02,30.28 184.19,30.12 U38.48 ; JSD1.9 v3(217.03,27.33)
  IN2 w0.127: v3(217.03,27.33) 217.03,28.04 214.46,30.61 196.2,30.61 194.84,31.97 184.51,31.97 v3(183.26,30.72)
SD_D3: length 35
  TOP w0.102: JSD1.1 v3(215.53,27.33) ; U38.47 v3(184.59,30.59)
  IN2 w0.127: v3(184.59,30.59) 185.48,31.48 190.72,31.48 192.03,30.18 206.18,30.18 206.52,29.84 213.02,29.84 215.52,27.33 v3(215.53,27.33)
SD_UHS2_D0N: length 25.7
  TOP w0.089: v3(211.91,7.02) 212.06,7.16 212.06,7.49 211.97,7.58 211.54,7.58 211.46,7.67 JSD1.12 ; RE25.2 193.14,15.19 LE4.2 193.87,15.19 194.2,15.51 194.33,15.51 v3(194.52,15.32)
  IN1 w0.089: v3(194.52,15.32) 194.85,15.65 195.27,15.65 202.35,8.56 211.38,8.56 212.24,7.7 212.24,7.35 v3(211.91,7.02)
SD_UHS2_D0N_R: length 18.9
  TOP w0.089: RE25.1 192.06,15.19 LE4.1 191.26,15.19 190.98,15.47 190.76,15.47 v3(190.61,15.32) ; v3(190.52,28.21) 190.37,28.36 190.29,28.36 190,28.06 U38.34
  IN1 w0.089: v3(190.52,28.21) 190.66,28.36 191.43,28.36 192.46,27.33 192.46,21.57 189.93,19.04 189.93,15.85 190.25,15.53 190.4,15.53 v3(190.61,15.32)
SD_UHS2_D0P: length 25.7
  TOP w0.089: v3(212.5,7.02) 212.35,7.16 212.35,7.49 212.44,7.58 212.87,7.58 212.95,7.67 212.95,8.44 JSD1.11 ; v3(194.52,15.9) 194.42,15.8 194.12,15.8 193.89,16.04 LE4.3 193.14,16.04 RE26.2
  IN1 w0.089: v3(194.52,15.9) 195.37,15.9 202.46,8.82 211.48,8.82 212.5,7.8 v3(212.5,7.02)
SD_UHS2_D0P_R: length 18.8
  TOP w0.089: v3(190.61,15.9) 190.76,15.76 190.98,15.76 191.26,16.04 LE4.4 192.06,16.04 RE26.1 ; U38.35 189.98,28.46 190.17,28.65 190.37,28.65 v3(190.52,28.8)
  IN1 w0.089: v3(190.52,28.8) 190.7,28.61 191.53,28.61 192.71,27.43 192.71,21.46 190.18,18.93 190.18,15.96 190.35,15.79 190.5,15.79 v3(190.61,15.9)
SD_UHS2_D1N: length 24.5
  TOP w0.089: v3(194.52,13.74) 194.37,13.6 194.17,13.6 193.89,13.88 LE2.3 193.14,13.88 RE4.2 ; JSD1.15 205.46,7.67 205.37,7.58 205.04,7.58 204.85,7.39 204.85,7.23 v3(205,7.08)
  IN1 w0.089: v3(205,7.08) 205,7.68 204.75,7.93 202.12,7.93 200.88,9.17 200.54,9.17 199.78,8.42 199.6,8.42 199.4,8.61 199.4,8.79 200.16,9.55 200.16,9.89 199.76,10.29 199.43,10.29 198.67,9.53 198.49,9.53 198.29,9.73 198.29,9.91 199.05,10.67 199.05,11 198.65,11.4 198.31,11.4 197.53,10.62 197.35,10.62 197.16,10.82 197.16,11 197.93,11.78 197.93,12.12 196.31,13.74 v3(194.52,13.74)
SD_UHS2_D1N_R: length 20
  TOP w0.089: v3(190.58,27.57) 190.43,27.42 190.31,27.42 190.07,27.66 U38.33 ; RE4.1 192.06,13.88 LE2.4 191.16,13.88 190.88,13.6 190.65,13.6 v3(190.51,13.74)
  IN1 w0.089: v3(190.51,13.74) 189.7,13.74 189.23,14.21 189.23,19.39 191.86,22.02 191.86,27.02 191.52,27.36 190.79,27.36 v3(190.58,27.57)
SD_UHS2_D1P: length 24.4
  TOP w0.089: v3(194.52,13.16) 194.37,13.31 194.2,13.31 193.92,13.03 LE2.2 193.14,13.03 RE3.2 ; JSD1.16 203.96,7.67 203.95,7.67 204.04,7.58 204.47,7.58 204.56,7.49 204.56,7.23 v3(204.41,7.08)
  IN1 w0.089: v3(194.52,13.16) 194.85,13.49 196.2,13.49 197.68,12.01 197.68,11.88 196.9,11.11 196.9,10.72 197.25,10.37 197.64,10.37 198.42,11.15 198.54,11.15 198.79,10.9 198.79,10.77 198.04,10.01 198.04,9.62 198.38,9.28 198.77,9.28 199.53,10.03 199.66,10.03 199.91,9.78 199.91,9.66 199.15,8.9 199.15,8.51 199.5,8.16 199.89,8.16 200.65,8.92 200.77,8.92 202.02,7.67 204.65,7.67 204.74,7.58 204.74,7.41 v3(204.41,7.08)
SD_UHS2_D1P_R: length 20.1
  TOP w0.089: U38.32 190.06,27.26 190.19,27.13 190.43,27.13 v3(190.58,26.98) ; RE3.1 192.06,13.03 LE2.1 191.16,13.03 190.88,13.31 190.65,13.31 v3(190.51,13.16)
  IN1 w0.089: v3(190.58,26.98) 190.7,27.1 191.41,27.1 191.61,26.91 191.61,22.12 188.98,19.49 188.98,14.11 189.6,13.49 190.18,13.49 v3(190.51,13.16)
SD_WPI: length 14.9
  TOP w0.102: v3(186.56,22.66) 186.99,23.08 U38.20 ; JSD1.18 197.53,27.68 197.14,27.3 v3(195.2,27.3)
  BOTTOM w0.102: v3(195.2,27.3) 194.53,27.3 191.29,24.06 v1(188.6,24.06) 187.96,24.06 v3(186.56,22.66)
SEL: length 16
  TOP w0.102: v3(274.18,175.53) 274.64,175.99 Q59.1 ; v3(272.51,175.47) 272.51,177.97 v1(271.91,178.56) 271.07,179.4 271.07,184.66 271.39,184.98 R1614.1 273.04,185.66 273.47,185.66 273.57,185.56 U2.4
  IN1 w0.102: v3(274.18,175.53) 274.12,175.47 v3(272.51,175.47)
SIO_14M: length 3.3
  TOP w0.089: RH157.2 175.35,143.92 v1(175.17,143.92) 174.99,144.1 173.83,144.1 v3(173.74,144)
  BOTTOM w0.089: UH1.F38 173.87,143.87 v3(173.74,144)
SIO_A20GATE: length 97.4
  TOP w0.089: v3(161.85,131.51) 161.85,131.28 161.41,130.84 161.41,130.04 161.1,129.73 v1(161.1,129.29) 161.1,128.21 161.24,128.07 161.24,126.62
  TOP w0.102: RPH14.3 161.36,124.77 161.36,124.78 161.36,125.21 v3(161.28,125.29) 161.24,125.33 161.24,126.62 ; U51.A45 207.43,84.25 207.43,85 v3(207.41,85.02)
  IN2 w0.127: v3(207.41,85.02) 207.65,85.02 207.96,85.33 207.96,87.94 207.43,88.47 207.43,89.82 208.41,90.8 209.51,90.8 210.61,91.89 210.61,97.07 211.27,97.73 211.27,115.49 209.18,117.58 v3(208.09,117.58)
  IN3 w0.127: v3(161.28,125.29) 161.46,125.29 163.01,123.74 164.83,123.74 165.09,123.49 167.77,123.49 168.46,122.8 168.95,122.8 169.08,122.93 169.43,122.93 169.85,122.51 171.3,122.51 171.88,121.94 173.44,121.94 174.26,121.11 175.63,121.11 176.32,120.43 176.32,120.39 177.25,119.46 185.4,119.46 188.2,116.66 196.3,116.66 196.61,116.97 201.87,116.97 202.43,117.53 208.04,117.53 v3(208.09,117.58)
  BOTTOM w0.089: UH1.AN10 162.11,131.76 v3(161.85,131.51)
SIO_EXT_SCI#: length 101.1
  TOP w0.102: RPH16.3 158.38,124.81 v3(158.37,124.81) 158.69,125.13 159.3,125.13 159.7,125.53 RH195.2 ; U51.A33 213.43,84.79 v3(213.25,84.97)
  IN2 w0.127: v3(216.28,115.93) 216.03,115.67 216.03,112.83 216.28,112.58 216.28,108.98 214.8,107.49 214.8,96.07 214.4,95.67 214.4,89.87 213.95,89.41 213.95,87.29 213.64,86.99 213.64,85.36 v3(213.25,84.97)
  IN3 w0.127: v3(216.28,115.93) 214.09,115.93 213.22,115.05 209.11,115.05 207.41,116.75 203.2,116.75 202.61,116.17 197,116.17 196.73,115.9 187.88,115.9 185.91,117.87 181.65,117.87 180.82,118.7 176.36,118.7 176.1,118.95 175.28,118.95 174.79,119.43 174.79,120.05 174.49,120.35 173.3,120.35 173.12,120.18 170.98,120.18 169.6,121.56 168.23,121.56 167.95,121.28 165.46,121.28 163.76,122.98 162.53,122.98 161.73,123.79 160.06,123.79 159.68,124.17 159.68,124.54 159.41,124.81 v3(158.37,124.81)
  BOTTOM w0.102: v3(213.25,84.97) 213.25,84.71 v1(212.85,84.32)
SIO_EXT_SMI#: length 121.9
  TOP w0.102: v3(208.92,72.05) 208.43,72.54 U51.A6
  IN1 w0.102: v3(168.91,117.71) 168.93,117.68 174.79,117.68 175.32,118.21 178.9,118.21 180.5,116.61 196.28,116.61 196.86,117.19 200.68,117.19 201.3,117.81 207.48,117.81 207.66,117.99 210.24,117.99 210.54,117.68 210.99,117.68 211.57,118.27 v3(214.38,118.27)
  IN4 w0.102: v3(218.11,101.2) 219.14,100.17 219.14,89.54 218.7,89.09 218.7,76.96 215.68,73.94 211.9,73.94 210.01,72.05 v3(208.92,72.05)
  BOTTOM w0.089: UH1.M1 170.96,126.92 171.14,126.74 171.14,126.62
  BOTTOM w0.102: RH10.1 217.84,100.92 v3(218.11,101.2) 219.21,102.29 219.21,114.31 215.24,118.27 v3(214.38,118.27) ; RPH1.3 168.41,117.22 v3(168.91,117.71) 169.31,118.11 169.31,118.87 170.35,119.91 170.35,122.71 v1(170.91,123.28) 171.52,123.88 171.52,125.7 171.14,126.08 171.14,126.62
SIO_EXT_WAKE#: length 120.4
  TOP w0.089: v3(168.34,125.25) 167.77,125.81 RPH9.2
  TOP w0.102: U46.B49 181.93,64.81 v3(181.99,64.87)
  IN2 w0.127: v3(181.99,64.87) 181.99,64.63 182.25,64.38 182.67,64.38 184.06,65.78 188.2,65.78 188.37,65.6 190.27,65.6 191.33,66.67 192.93,66.67 194.22,67.96 194.65,67.96 196.19,69.5 196.19,75.61 197.89,77.31 197.89,81.16 197.21,81.84 197.21,83.28 198.01,84.08 198.01,86.81 199.1,87.9 199.1,92.33 203.46,96.69 203.46,100.55 203.14,100.87 203.14,104.47 204.03,105.36 204.03,110.5 204.49,110.97 v3(204.54,110.97) 204.54,111.69 203.37,112.85 203.37,119.87 v3(204.08,120.58)
  IN3 w0.127: v3(168.34,125.25) 169.27,125.25 170.35,124.16 174.08,124.16 174.66,123.59 175.82,123.59 176.23,123.99 177.05,123.99 177.83,123.22 177.83,122.5 178.76,121.57 186.56,121.57 187.17,122.18 190.61,122.18 191.8,120.98 192.81,120.98 193.66,120.13 203.63,120.13 v3(204.08,120.58)
  BOTTOM w0.089: UH1.Y1 167.71,127.06 167.71,127.05 167.71,126.22 167.73,126.19 167.73,125.86 v3(168.34,125.25)
  BOTTOM w0.102: RH24.1 204.26,110.7 v3(204.54,110.97) 204.54,111.24 v1(204.15,111.62)
SIO_PWRBTN#: length 98.6
  TOP w0.102: U51.B58 205.73,79.79 v3(205.77,79.83) ; v3(207.77,103.3) v1(208.92,103.3) ; v3(172.52,120.85) 172.56,120.89 172.56,124.48 RH108.1
  IN1 w0.102: v3(172.52,120.85) 172.83,121.16 175.49,121.16 175.92,121.59 177.23,121.59 177.56,121.26 179.2,121.26 179.5,120.96 181.35,120.96 182.2,120.12 187.67,120.12 188.38,120.83 188.52,120.96 193.54,120.96 194.34,120.16 203.01,120.16 v3(203.49,120.64)
  IN4 w0.102: v3(203.49,120.64) 203.49,113.92 205.71,111.7 206.83,111.7 209.49,109.04 209.49,105.02 v3(207.77,103.3) 207.77,103.18 207.88,103.08 207.88,103.08 208.12,102.84 208.12,102.83 208.35,102.61 208.35,99.82 215.97,92.2 215.97,84.71 214.65,83.39 214.65,80.08 213.81,79.24 208.28,79.24 207.08,80.44 206.38,80.44 v3(205.77,79.83)
SIO_PWRBTN#_R: length 194.2
  TOP w0.089: 172.04,126.62 v3(172.04,127.18)
  TOP w0.102: RH108.2 172.04,126.62
  IN4 w0.089: v3(172.04,127.18) 172.04,126.62
  IN4 w0.102: v3(183.15,82.79) 184.09,83.73 184.09,90.41 183.2,91.3 183.2,96.41 182.91,96.71 v3(182.91,101.07) 182.91,101.29 181.19,103.01 181.19,107.51 175.52,113.19 175.52,117.08 174.31,118.28 174.31,118.67 173.86,119.12 173.86,121.96 173.8,122.02 173.8,124.81 172.04,126.58 172.04,126.62
  BOTTOM w0.089: UH1.K1 171.89,127.92 171.89,127.33 v3(172.04,127.18)
  BOTTOM w0.102: v3(182.91,101.07) 183.16,101.07 187.14,97.08 193.18,97.08 195.9,94.36 215.58,94.36 217.36,96.14 217.36,98.16 216.64,98.89 RH28.1 ; v3(183.15,82.79) 181.05,80.7 176.59,80.7 163.94,68.05 99.21,68.05 v1(97.92,69.34) 97.46,69.8 97.46,76.8 97.18,77.08 RC21.1
SIO_RCIN#: length 111.9
  TOP w0.089: 160.75,126.62 v1(160.75,127.24) 160.75,130.07 v3(160.85,130.16)
  TOP w0.102: U51.A27 215.97,80.04 v3(216.49,80.56) ; 160.75,126.62 160.73,126.59 160.73,124.67 160.86,124.53 RPH14.4
  IN1 w0.089: v3(160.85,130.16) 160.85,129.11 161.25,128.7 161.48,128.7 162.37,127.82 162.37,126.8 162.75,126.8 163.26,126.29 163.26,125.72 162.73,125.19 162.73,125
  IN1 w0.102: v3(212.41,117.66) 211.93,117.17 206.38,117.17 206.3,117.25 202.2,117.25 201.91,116.96 196.95,116.96 196.38,116.38 180.41,116.38 178.81,117.99 175.42,117.99 174.74,117.3 168.38,117.3 166.92,118.76 166.92,119.71 165.37,121.26 165.37,122.55 164.1,123.82 163.24,123.82 162.73,124.33 162.73,125
  IN4 w0.102: v3(212.41,117.66) 213.46,117.66 215.9,115.22 215.9,114.08 216.41,113.57 216.41,108.45 215.94,107.98 215.94,100.54 217.2,99.28 217.2,97.43 217.62,97.01 217.62,81.69 v3(216.49,80.56)
  BOTTOM w0.089: UH1.AT6 161.04,129.97 v3(160.85,130.16)
SIO_SLP_A#: length 140.2
  TOP w0.102: v3(184.81,94.88) 181.86,94.88 180.95,93.97 PR303.1 ; U46.B63 187.37,64.02 186.89,64.5 v3(186.69,64.5) ; v3(188.13,95.05) v1(191.84,95.05) 211.39,95.05 214.57,98.22 225.36,98.22 227.79,95.8 230.95,95.8 231.05,95.9 JAPS1.6
  IN1 w0.102: v3(188.13,95.05) 187.96,94.88 v3(184.81,94.88)
  IN4 w0.089: 173.7,126.62 173.7,126.98 v3(174.08,127.36)
  IN4 w0.102: v3(186.69,64.5) 185.58,64.5 184.56,65.52 183.9,65.52 183.14,66.28 181.79,66.28 180.74,67.33 180.74,74.85 184.48,78.59 185.06,78.59 185.48,79.01 186.21,79.01 187.95,80.75 187.95,90.37 188.37,90.79 188.37,94.81 v3(188.13,95.05) ; v3(184.81,94.88) 183.86,95.83 183.86,96.65 183.54,96.97 183.54,101.45 181.78,103.21 181.78,108.39 175.97,114.2 175.97,117.27 175,118.24 175,124.33 173.7,125.63 173.7,126.62
  BOTTOM w0.089: UH1.F3 173.44,128.49 173.57,128.36 173.57,128.26 173.67,128.16 173.67,127.9 173.67,127.9 173.67,127.83 174.08,127.42 v3(174.08,127.36) 174.52,126.93 175.2,126.93 175.32,127.05 177,127.05 177.22,127.27
  BOTTOM w0.102: UH2.1 179.12,127.5 177.45,127.5 177.22,127.27
SIO_SLP_LAN#: length 164.6
  TOP w0.102: U57.5 246.91,148.44 247.02,148.32 247.02,147.39 v1(246.82,147.19) 243.76,144.13 v3(242.56,144.13) ; U46.A5 192,66.06 v3(192.09,66.14) ; RH80.2 180.09,122.05 v3(180.15,121.99)
  IN2 w0.089: 176.99,126.62 176.55,127.06 176.06,127.06 174.83,128.29 173.72,128.29 173.44,128.57 173.44,129.92 v3(173.56,130.04)
  IN2 w0.127: 176.99,126.62 177.61,126 177.61,124.64 179.83,122.42 179.83,122.31 v3(180.15,121.99)
  IN3 w0.127: v3(242.56,144.13) 241.78,143.36 241.78,137.84 237.03,133.09 237.03,124.94 232.29,120.2 227.46,120.2 226.76,119.5 224.79,119.5 223.48,120.8 215.31,120.8 214.83,120.32 211.81,120.32 211.2,120.93 208.22,120.93 207.31,121.85 201.48,121.85 200.87,121.24 195.44,121.24 v3(194.77,120.56) 193.69,120.56 193.02,121.24 191.9,121.24 190.71,122.43 187.06,122.43 186.45,121.82 180.32,121.82 v3(180.15,121.99)
  IN4 w0.102: v3(194.77,120.56) 193.94,119.74 193.94,113.78 194.85,112.87 194.85,102.06 194.72,101.93 194.72,101.93 194.24,101.45 194.24,96.22 192.75,94.73 192.75,91.7 192.09,91.04 192.09,87.21 192.58,86.71 192.58,79.78 191,78.19 191,76.32 193.65,73.67 193.65,71.02 194.4,70.28 194.4,68.54 193.16,67.3 193.16,66.84 192.86,66.55 192.5,66.55 v3(192.09,66.14)
  BOTTOM w0.089: v3(173.56,130.04) 173.32,129.8 UH1.G5
SIO_SLP_S3#: length 557.1
  TOP w0.102: v3(274.07,179.57) 274.27,179.36 R153.1 ; JAPS1.2 v3(238.75,93.9) ; U46.B65 188.37,64.05 v3(187.9,64.52) ; R734.1 v3(236.67,68.57)
  TOP w0.254: v3(14.67,143.82) PR607.1 ; PR403.1 202.41,51.98 v3(203.11,51.29)
  IN1 w0.102: v3(236.67,68.57) 236.67,68.44 235.24,67.01 230.28,67.01 229.69,66.41 222.55,66.41 222.34,66.2 220.91,66.2 220.32,66.78 215.05,66.78 211.9,63.63 209.46,63.63 v3(208.68,62.84)
  IN1 w0.254: v3(208.68,62.84) 207.96,63.55 205.2,63.55 203.68,65.08 197.42,65.08 196.38,64.04 190.79,64.04 190.12,63.36 188.6,63.36 188.38,63.58 188.38,64.28 188.14,64.52 v3(187.9,64.52)
  IN2 w0.089: v3(173.1,127.22) 173.1,126.62
  IN2 w0.127: 173.1,126.62 173.1,126.48 173.49,126.09 174.45,126.09 174.72,126.36 175.51,126.36 176.15,125.71 176.15,121.8 175.8,121.44 175.8,120.55 176.29,120.05 176.29,113.94 181.98,108.25 181.98,105.06 182.23,104.81 182.23,96.53 182.23,96.53 182.23,94.39 182.23,94.39 182.23,90.85 181.28,89.89 181.28,81.73 176.69,77.13 176.69,73.46 177.74,72.41 177.74,68.1 178.7,67.14 178.7,66.78 181.17,64.31 181.17,63.72 181.72,63.17 184.85,63.17 185.36,63.68 185.36,64.53 185.75,64.92 187.5,64.92 v3(187.9,64.52)
  IN3 w0.127: v3(236.67,68.57) 238.95,70.86 238.95,93.69 v3(238.75,93.9) 238.75,104.8 245.98,112.02 245.98,132.53 248.06,134.61 249.75,134.61 v3(251.59,136.45)
  IN3 w0.254: v3(187.9,64.52) 187.36,64.52 187.28,64.43 187.28,63.33 187.07,63.12 181.54,63.12 180.09,64.57 179.02,64.57 178.48,64.02 178.48,60.23 175.62,57.37 166.92,57.37 165.04,55.49 162.47,55.49 161.67,54.69 154.92,54.69 150.39,50.16 115.44,50.16 105.77,59.83 90.54,59.83 87.49,62.88 87.49,79.93 89.32,81.76 89.32,88.14 84.99,92.47 79.91,92.47 79.52,92.87 78.27,92.87 77.58,92.18 72.33,92.18 71.64,92.87 53.71,92.87 48.97,97.61 48.97,118.58 50.43,120.04 50.43,126.47 46.61,130.3 46.61,132.97 45.58,134 44.87,134 41.9,136.97 36.63,136.97 34.18,139.42 30.95,139.42 29.89,140.48 25.93,140.48 25.1,141.32 22.67,141.32 21.99,140.64 17.85,140.64 v3(14.67,143.82)
  IN4 w0.254: v3(208.68,62.84) 206.05,62.84 204.66,61.46 204.66,52.83 v3(203.11,51.29)
  BOTTOM w0.089: UH1.H1 173.1,127.52 v3(173.1,127.22)
  BOTTOM w0.102: v3(274.07,179.57) 270.96,179.57 269.94,178.55 269.94,176.25 269.15,175.46 269.15,172 265.8,168.65 265.8,166.79 263.41,164.4 263.41,159.71 259.46,155.76 254.89,155.76 252.55,153.41 252.55,137.41 v3(251.59,136.45)
SIO_SLP_S4#: length 145.2
  TOP w0.102: v3(231.19,95.39) 231.19,95.4 JAPS1.5 ; U46.A61 188.12,61.73 v3(188.03,61.64)
  TOP w0.254: v3(183.64,88.89) v1(183.14,88.38) 182.63,87.87 181.5,87.87 181.37,87.75 PR206.1
  IN1 w0.102: v3(188.03,61.64) 187.45,61.07 187.45,60.38 186.52,59.45 185.1,59.45 184.72,59.83 184.72,61.71 182.92,63.52 181.65,63.52 178.6,66.57 178.6,73.43 180.37,75.2 180.37,80.87 181.69,82.18 181.69,85.28 182.73,86.32 182.73,87.98 v3(183.64,88.89) 191.96,88.89 193.19,90.12 202.71,90.12 203.43,90.85 205.61,90.85 205.94,90.52 209.48,90.52 210,89.99 213.54,89.99 213.85,90.31 228.63,90.31 231.93,93.61 231.93,94.66 v3(231.19,95.39)
  IN2 w0.089: v3(176.3,127.43) 176.53,127.43 177.22,126.74
  IN2 w0.127: v3(183.64,88.89) 183.25,89.28 183.25,89.96 183.22,89.99 183.22,90.33 183.25,90.36 183.25,94.81 183.25,94.81 183.25,96.11 183.25,96.11 183.25,100.01 183.9,100.66 183.9,104.58 183,105.48 183,111.08 180.75,113.33 180.75,122.27 180.28,122.74 179.88,122.74 177.87,124.75 177.87,126.1 177.22,126.74
  BOTTOM w0.089: 177.22,127.94 176.71,127.43 v3(176.3,127.43) ; UH1.C6 175.46,130.41 175.69,130.18 176.9,130.18 177.42,129.66 177.42,129.28
  BOTTOM w0.102: 177.42,129.28 177.42,128.14 177.22,127.94
SIO_SLP_S5#: length 116.2
  TOP w0.102: v3(218.44,97.74) 225.16,97.74 v2(226,96.91) 228.05,94.86 229.11,94.86 229.15,94.9 JAPS1.4 ; v3(215.84,75.56) 215.83,75.54 U51.A18
  IN3 w0.089: v3(168.26,130.81) 168.26,130.81 168.54,130.81 168.85,131.12 169.48,131.12 169.93,131.56 170.44,131.56 170.63,131.37 170.63,129.92 170.96,129.59 171.36,129.59 172.18,128.77 172.83,128.77 173.48,128.12 174.47,128.12 174.54,128.19 175.52,128.19 175.89,127.82 176.56,127.82 176.74,128.01 177.22,128.01
  IN3 w0.127: 177.22,128.01 178.43,128.01 179.15,127.28 182.43,127.28 183.13,126.58 190.46,126.58 192.6,124.45 204.15,124.45 204.51,124.81 v3(205.4,124.81)
  IN4 w0.102: v3(215.84,75.56) 216.24,75.96 217.05,75.96 218.08,76.99 218.08,96.82 218.44,97.18 v3(218.44,97.74) 217.65,98.53 217.65,112.97 217.14,113.48 217.14,116.61 215.08,118.67 213.09,118.67 206.96,124.81 v3(205.4,124.81)
  BOTTOM w0.089: v3(168.26,130.81) 168.02,130.57 UH1.Y7
SIO_SLP_SUS#: length 85.2
  TOP w0.102: U46.B6 190.12,66.31 190,66.43 189.49,66.43 v3(189.03,66.89)
  IN2 w0.089: 175.96,126.62 175.59,127 174.4,127 v3(174.14,126.74)
  IN2 w0.127: 175.96,126.62 176.98,125.61 176.98,124.47 177.4,124.05 177.4,121.59 176.43,120.62 176.43,120.28 177.8,118.9 177.8,115.92 182.74,110.98 182.74,105.38 183.64,104.48 183.64,100.76 183,100.12 183,96.21 182.99,96.21 182.99,94.71 183,94.71 183,90.46 182.97,90.44 182.97,89.88 183,89.86 183,88.82 183.4,88.41 183.4,83.76 182.23,82.59 182.23,81.6 179.33,78.7 179.33,77.29 178.89,76.85 177.87,76.85 177.45,76.43 177.45,73.78 178.59,72.64 178.59,70.47 179.21,69.84 180.02,69.84 180.85,69.01 180.85,65.97 181.46,65.35 182.75,65.35 184.28,66.88 189.02,66.88 v3(189.03,66.89)
  BOTTOM w0.089: v3(174.14,126.74) 174.06,126.74 173.68,127.12 173.68,127.53 173.32,127.9 UH1.F1
  BOTTOM w0.102: v3(189.03,66.89) 189.03,66.78 v1(188.66,66.41)
SIO_SLP_WLAN#: length 83.9
  TOP w0.102: U46.A14 192.02,70.56 v3(192.04,70.57)
  IN3 w0.089: v3(173.88,128.69) 174.5,128.69 174.63,128.57 175,128.57 175.52,129.09 176.47,129.09 176.79,129.4 178.03,129.4 178.16,129.28
  IN3 w0.127: v3(193.99,125.59) 192.54,125.59 190.34,127.79 181.99,127.79 181.33,128.45 178.98,128.45 178.16,129.28
  IN4 w0.102: v3(192.04,70.57) 191.68,70.93 191.68,73.03 190.2,74.51 190.2,78.43 191.9,80.13 191.9,86.43 191.2,87.13 191.2,91.75 192.01,92.56 192.01,95.04 193.56,96.58 193.56,101.74 193.74,101.92 193.74,101.95 193.76,101.95 194,102.18 194,102.52 193.76,102.76 193.74,102.76 193.74,103.06 194.16,103.49 194.16,112.12 192.44,113.84 192.44,124.04 v3(193.99,125.59)
  BOTTOM w0.089: v3(173.88,128.69) 174.39,128.69 UH1.D2
  BOTTOM w0.102: v1(194.82,125.4) 194.63,125.59 v3(193.99,125.59)
SLEEVE: length 5.4
  IN2 w1.524: 278.35,156.49 280.51,154.33 282.86,154.33
  vias: v2(284.57,154.94) v3(275.88,156.72) v3(276.47,156.72) v3(277.05,156.72) v3(283.95,154.93) v3(283.96,154.33) v3(284.57,154.36)
SLICE_BAT_ON: length 401.2
  TOP w0.102: U46.A31 182.62,74.25 183.85,75.49 185.79,75.49 v3(185.84,75.54) 186.11,75.54 186.64,76.08 RP5.1
  TOP w0.254: v3(224.16,85.59) 224.6,86.03 PU801.2 225.49,86.03 225.7,86.24 225.7,86.87 225.3,87.27 225.3,88.89 225.87,89.46 229.48,89.46 230.82,88.12 232.22,88.12 235.97,84.37 235.97,80.93 235.1,80.06 233,80.06 232.74,80.32 PQ806.5 ; PR890.2 114.54,156.15 v3(116.21,154.49) ; PU807.1 180.48,46.93 v3(179.96,46.41) ; PR850.2 38.74,149.13 v1(38.33,149.53) 38.17,149.7 v3(38.17,150.36)
  IN1 w0.254: v3(185.84,75.54) 185.84,75.9 190.29,80.34 190.8,80.34 v3(191.25,80.8) 191.5,81.05 191.5,82.01 194.35,84.85 196.95,84.85 198.05,85.94 200.84,85.94 201.89,87 221.76,87 223.11,85.65 224.09,85.65 v3(224.16,85.59) ; v3(116.26,158.9) 116.21,158.84 v3(116.21,154.49)
  IN2 w0.254: v3(41.72,158.87) 43.12,158.87 44.77,157.22 44.77,153.81 41.99,151.03 41.05,151.03 40.19,150.17 38.36,150.17 v3(38.17,150.36) ; v3(191.25,80.8) 191.42,80.96 191.42,84.95 191.77,85.3 191.77,91.13 194.48,93.84 194.48,100.75 195.35,101.63 195.35,102.36 196.06,103.07 196.06,118.22 196.47,118.63 196.47,125.59 198.86,127.98 198.86,141.69 197,143.54 197,147.26 196.57,147.69 196.57,149.25 194.4,151.43 192.47,151.43 187.2,156.7 182.42,156.7 173.77,165.35 171.76,165.35 168.62,162.21 164.65,162.21 164.36,161.92 164.36,161.69 161.53,158.86 154.42,158.86 151.43,161.85 151.11,161.85 145.02,161.85 142.17,158.99 138.29,158.99 136.68,157.38 133.9,157.38 132.92,158.36 130.89,158.36 130.31,157.79 128.52,157.79 127.37,156.64 121.68,156.64 120.29,158.04 117.12,158.04 v3(116.26,158.9) ; v3(170.88,58.94) 170.88,56.95 172.69,55.14 175.89,55.14 178.49,52.53 178.49,48.98 179.33,48.15 179.33,47.04 v3(179.96,46.41)
  IN3 w0.254: v3(185.84,75.54) 185.54,75.54 185.36,75.37 185.36,73.85 184.53,73.02 181.59,73.02 179.61,71.03 177.85,71.03 176.3,69.48 176.3,61.77 173.48,58.94 v3(170.88,58.94) ; v3(116.21,154.49) 115.9,154.18 115.12,154.18 114.8,153.86 108.16,153.86 102.9,148.61 93.43,148.61 93.33,148.7 86.53,148.7 86.02,148.2 81.78,148.2 81.12,147.54 81.12,146.71 80.26,145.85 76.46,145.85 75.57,144.96 68.84,144.96 64.68,149.11 57.86,149.11 56.87,150.1 56.83,150.1 49.87,150.1 44.18,155.79 44.18,156.34 41.72,158.8 v3(41.72,158.87)
SLICE_BAT_PRES#: length 443.4
  TOP w0.102: v3(182.55,71.68) 182.37,71.86 U46.B33 ; RP3.6 192.79,70.98 192.47,71.3 v3(192.47,71.43)
  TOP w0.254: v3(174.56,23.26) 174.96,23.26 175.2,23.02 PD820.1 175.2,21.67 176.51,20.36 176.51,19.5 177.13,18.87 PU808.1 ; v3(180.19,40.8) 180.57,40.8 180.9,40.46 180.9,39.77 181.27,39.4 182.47,39.4 PQ827.2 ; PR882.1 v3(177.99,48.69) ; v3(186.56,48.76) 187.07,49.27 187.07,50.78 187.4,51.11 187.4,52.24 187.76,52.59 191.06,52.59 191.79,51.87 PU805.1 ; PU800.21 41.32,145.96 41.53,146.17 v3(41.72,146.17) ; v3(179.07,72.52) 176.99,72.52 176.98,72.51 PQ807.5 ; PU801.1 224.55,86.68 v3(224.16,86.29) ; PR26.1 171.58,167.5 171.96,167.12 v3(171.96,164.33)
  IN1 w0.254: v3(224.16,86.29) 223.9,86.03 223.27,86.03 221.9,87.4 198.41,87.4 196.24,85.23 196.01,85.23 193.88,85.23 190.87,82.22 v3(190.87,81.32) ; v3(155.01,162.55) 155.01,159.38 152.58,156.95 147.43,156.95 146.22,158.16 142.74,158.16 141.92,157.34 141.92,154.73 147.39,149.27 147.39,146.01 v3(146.8,145.42)
  IN2 w0.254: v3(41.72,146.17) 42.55,146.99 44.55,146.99 48.92,151.36 65.66,151.36 69.42,147.6 78.24,147.6 79.19,148.55 79.19,149.41 81.77,151.99 89.84,151.99 91.66,150.17 103.25,150.17 105.65,152.57 114.44,152.57 115.19,151.82 131.05,151.82 131.41,151.46 132.55,151.46 132.69,151.6 136.5,151.6 137.09,151.02 139.64,151.02 145.24,145.42 v3(146.8,145.42) ; v3(171.96,164.33) 173.66,164.33 182.05,155.94 186.88,155.94 192.15,150.67 194.08,150.67 194.98,149.77 194.98,148.17 196.24,146.91 196.24,141.43 198.1,139.58 198.1,128.29 195.71,125.91 195.71,118.95 195.3,118.54 195.3,103.39 194.59,102.67 194.59,101.94 193.71,101.07 193.71,94.16 190.89,91.33 190.89,85.78 190.7,85.6 190.34,85.23 190.34,81.85 v3(190.87,81.32) ; v3(174.56,23.26) 174.56,35.87 179.24,40.54 179.94,40.54 v3(180.19,40.8) 180.19,44.96 178.69,46.46 178.69,48 v3(177.99,48.69) 177.99,52.35 v3(176.29,54.05)
  IN3 w0.254: v3(155.01,162.55) 155.84,162.55 156.29,162.11 157.1,162.11 157.59,162.6 161.56,162.6 161.93,162.23 166.05,162.23 167,163.19 170.18,163.19 171.32,164.33 v3(171.96,164.33)
  IN4 w0.254: v3(176.29,54.05) 176.86,54.63 178.86,54.63 180.91,56.68 180.91,63.92 178.35,66.49 178.35,71.79 v3(179.07,72.52) ; v3(190.87,81.32) 190.46,80.91 190.46,79.73 189.3,78.56 189.3,77.31 188.31,76.32 187.01,76.32 186.57,75.88 186.57,75.13 187.01,74.69 187.01,73.59 186.12,72.7 183.57,72.7 v3(182.55,71.68)
  BOTTOM w0.102: JDOCK1.143 155.34,162.22 v3(155.01,162.55) 154.84,162.38 JDOCK1.141
  BOTTOM w0.254: v3(177.99,48.69) 186.5,48.69 v3(186.56,48.76) ; v3(192.47,71.43) 191.77,72.13 191.77,72.21 191.27,72.71 183.69,72.71 182.66,71.68 v3(182.55,71.68) 182.55,71.69 182.06,72.18 180.71,72.18 180.41,71.87 v1(179.71,71.87) v3(179.07,72.52)
SLICE_PERF_EN: length 138.8
  TOP w0.102: U51.B37 212.68,82.49 v3(213.02,82.15)
  TOP w0.254: v3(185.08,48.16) 185.08,50.1 PR881.2 ; PR884.2 v3(190.26,40.13) PR885.2 ; PR883.1 223.2,96.51 227.83,91.87 229.15,91.87 v3(235.46,85.56)
  IN2 w0.254: v3(185.08,48.16) 184.48,47.56 184.48,45.12 185.42,44.19 189.73,44.19 190.21,43.71 190.21,40.19 v3(190.26,40.13)
  IN3 w0.254: v3(235.46,85.56) 235.46,84.39 235.93,83.93 235.93,73.56 231.52,69.16 231.52,67.81 224.35,60.63 218.61,60.63 217.91,59.93 194.48,59.93 192.62,58.07 192.19,58.07 185.08,50.96 v3(185.08,48.16)
  BOTTOM w0.102: v3(213.02,82.15) 213.02,81.86 213.48,81.4 214.89,81.4 215.04,81.24 217.77,81.24 218.88,80.14 222.45,80.14 223.52,81.21 228.81,81.21 232.24,84.64 234,84.64 v1(234.51,85.14) 234.92,85.56 v3(235.46,85.56)
SLP_ME_CSW_DEV#: length 100.6
  TOP w0.102: RH223.1 171.31,115.74 v3(171.32,115.73) ; RH222.1 172.28,118.82 v3(172.28,118.98) ; v3(184.77,63.92) 184.87,63.83 U46.B58
  IN1 w0.089: v3(165.72,131.98) 165.17,132.53 165.17,133.02 164.91,133.28 163.7,133.28 163.2,132.77 163.2,130.04 162.82,129.66 162.82,128.77 163.45,128.13 163.45,125.36 163.7,125.1 163.7,125
  IN1 w0.102: 163.7,125 163.7,124.53 165.62,122.61 165.62,121.33 167.38,119.57 171.69,119.57 172.28,118.99 v3(172.28,118.98)
  IN2 w0.127: v3(171.32,115.73) 172.53,116.93 172.53,118.18 172.28,118.43 v3(172.28,118.98) ; v3(184.77,63.92) 184.77,63.89 184.31,63.43 181.82,63.43 181.42,63.83 181.42,65.04 180.6,65.86 180.6,68.78 179.79,69.59 178.99,69.59 178.33,70.24 178.33,72.53 177.19,73.67 177.19,76.54 177.76,77.1 178.79,77.1 179.08,77.4 179.08,78.81 181.98,81.7 181.98,82.69 183.01,83.73 183.01,86.34 182.74,86.61 182.74,89.75 182.72,89.78 182.72,90.54 182.74,90.57 182.74,94.6 182.74,94.6 182.74,96.32 182.74,96.32 182.74,100.22 183.39,100.87 183.39,104.37 182.49,105.27 182.49,110.87 179.45,113.91 v3(178.94,113.91)
  BOTTOM w0.089: v3(165.72,131.98) 166.1,132.36 UH1.AD11
  BOTTOM w0.102: v3(178.94,113.91) v1(177.23,113.91) 175.11,113.91 173.78,115.24 171.81,115.24 v3(171.32,115.73)
SM_RCOMP0: length 9.6
  TOP w0.254: v3(111.47,77.2) 111.95,76.72 111.95,75.68
  TOP w0.381: RC58.1 112.52,69.88 111.95,70.45 v1(111.95,73.48) 111.95,75.41 111.95,75.42 111.95,75.68
  BOTTOM w0.305: JCPU1.AP3 111.94,77.67 v3(111.47,77.2)
SM_RCOMP1: length 9.8
  TOP w0.381: RC61.1 109.92,69.53 v1(109.92,70.13) 109.92,76.64 v3(110.47,77.19)
  BOTTOM w0.305: JCPU1.AR3 110.94,77.66 v3(110.47,77.19)
SM_RCOMP2: length 8.8
  TOP w0.381: RC63.1 111.63,69.32 110.83,70.12 v1(110.83,71.88) 110.83,75.56 v3(111.47,76.2)
  BOTTOM w0.305: JCPU1.AP2 111.94,76.67 v3(111.47,76.2)
SML1_SMBCLK: length 105.3
  TOP w0.089: v3(172.16,130.11) 172.16,129.96 172.4,129.73 173.03,129.73 173.29,129.47 173.29,127.56 173.47,127.38 173.47,126.64 173.47,126.63 173.47,126.62
  TOP w0.102: 173.47,126.62 173.47,126.32 174.31,125.47 174.31,125.21 174.12,125.02 RPH12.2 ; v3(208.08,74.86) 208.18,74.76 U51.B6
  IN4 w0.089: 171.58,126.62 171.58,126.67 171.58,126.67 171.58,128.83 170.82,129.59 170.82,131.07 171,131.25 171.29,131.25 171.58,130.95 171.58,130.36 171.83,130.11 v3(172.16,130.11)
  IN4 w0.102: 171.58,126.62 171.58,125.92 172.94,124.57 172.94,122.39 173.55,121.78 173.55,120.4 172.94,119.79 172.94,115.34 180.34,107.93 180.34,103.37 182.5,101.21 182.5,96.79 182.86,96.43 182.86,90.9 183.15,90.61 183.15,87.92 183.62,87.46 183.62,83.84 182.74,82.96 182.74,81.5 181.27,80.03 180.56,80.03 178.44,77.91 178.44,77.7 v3(178.61,77.52)
  BOTTOM w0.089: UH1.K6 171.82,130.11 v3(172.16,130.11)
  BOTTOM w0.102: v3(178.61,77.52) 178.41,77.32 178.41,77.17 178.53,77.05 178.91,77.05 180.07,78.21 183.91,78.21 185.19,76.93 197.44,76.93 198.97,75.4 200.41,75.4 201.47,76.47 204.61,76.47 205.53,75.56 207.44,75.56 208.08,74.91 v3(208.08,74.86)
SML1_SMBDATA: length 109.3
  TOP w0.089: v3(171.13,132.06) 171.13,131.79 171.85,131.07 172.34,131.07 172.54,130.88 172.54,130.03 172.62,129.94 173.12,129.94 173.51,129.55 173.51,127.65 173.69,127.47 173.69,126.64 173.7,126.63 173.7,126.62
  TOP w0.102: 173.7,126.62 173.7,126.41 174.54,125.57 174.54,125.21 174.62,125.14 RPH12.1 ; U51.A5 207.93,72.73 v3(207.77,72.57)
  IN4 w0.089: v3(171.13,132.06) 171.13,131.55 171.04,131.46 170.91,131.46 170.6,131.16 170.6,129.5 171.36,128.74 171.36,126.67 171.36,126.67 171.36,126.62
  IN4 w0.102: v3(178.03,77.52) 178.21,77.7 178.21,78 180.47,80.26 181.18,80.26 182.51,81.6 182.51,83.06 183.39,83.93 183.39,87.36 182.92,87.83 182.92,90.51 182.63,90.81 182.63,96.34 182.27,96.69 182.27,101.11 181.37,102.02 181.37,102.02 180.11,103.27 180.11,107.84 172.71,115.24 172.71,119.89 173.32,120.5 173.32,121.69 172.71,122.3 172.71,124.47 171.36,125.83 171.36,126.62
  BOTTOM w0.089: UH1.N11 171.01,132.06 v3(171.13,132.06)
  BOTTOM w0.102: v3(207.77,72.57) v1(207.77,73.52) 207.77,74.29 207.58,74.47 207.58,75.09 207.35,75.33 205.43,75.33 204.52,76.24 201.57,76.24 200.5,75.17 198.87,75.17 197.35,76.7 185.09,76.7 183.81,77.98 180.16,77.98 179.01,76.83 178.44,76.83 178.18,77.08 178.18,77.37 v3(178.03,77.52)
SNUB_1.05V: length 2.2
  TOP w0.102: PR304.1 163.64,102.86 v1(164.21,103.43)
SNUB_1.5VSP: length 3.1
  TOP w0.102: v1(200.28,60.76) 200.34,60.7 PR401.1
  TOP w0.508: PC407.2 200.33,59.25 PR401.1
SNUB_1.35V: length 2.7
  TOP w0.102: v1(163.07,78.03) 163.7,78.67 PR202.1
SNUB_3V: length 1.9
  TOP w0.102: PR109.1 v1(203.06,33.2)
SNUB_5V: length 1.3
  TOP w0.102: PC119.2 205.96,41.43 v1(205.92,41.39)
SNUB_CHARGER: length 2.1
  TOP w0.102: v1(66.3,152.45) 65.66,153.09 PC715.2
SNUB_GPU_P1: length 1.7
  BOTTOM w0.102: PC631.2 v1(23.88,153.91)
SNUB_GPU_P2: length 1.8
  BOTTOM w0.102: v1(8.83,166.49) 8.38,166.04 PC607.2
SNUB_PCIE: length 3.5
  BOTTOM w0.102: v1(100.59,135.44) 100.74,135.28 PR680.1
  BOTTOM w0.508: PC667.2 103.84,135.28 PR680.1
SNUB_V1: length 1.8
  TOP w0.102: v1(127.89,126.61) 127.45,127.05 PC543.2
SNUB_V2: length 2.4
  TOP w0.102: PC524.2 116.4,127.37 v1(116.08,127.05)
SOFT_START_GC: length 72.9
  TOP w0.254: v3(38.48,138.29) 38.82,138.63 PU800.2 ; v3(2.54,174.68) v2(3.33,174.68) 3.75,174.68 4.14,174.28 PR23.2
  IN3 w0.254: v3(38.48,138.29) 35.49,141.29 32.85,141.29 31.21,142.93 27.67,142.93 26.65,143.94 17.02,143.94 16.19,143.94 14.93,145.2 11.77,145.2 11.4,145.57 4.64,152.33 4.64,152.96 4.64,152.96 4.64,165.39 7.3,168.06 7.3,170.35 7.18,170.47 7.18,172.14 6.22,173.09 5.21,173.09 3.62,174.68 v3(2.54,174.68)
SP_TPM_LPC_EN: length 80
  TOP w0.102: v3(183.9,63.93) 183.87,63.9 U46.B56 ; v3(218.12,101.78) 218.12,101.78 v1(218.12,102.42) R1169.1 ; v3(183.86,60.49) 183.83,60.47 R772.2
  IN1 w0.102: v3(208.26,104.41) 208.86,103.81 209.62,103.81 211.65,101.78 v3(218.12,101.78)
  IN2 w0.127: v3(208.26,104.41) 208.26,97.94 203.07,92.76 203.07,89.7 203.48,89.29 203.48,86.88 200.47,83.87 200.47,76.53 202.53,74.47 202.53,71.3 201.43,70.2 201.43,67.79 199.36,65.72 190.75,65.72 190.37,65.35 184.57,65.35 184.36,65.14 184.36,64.4 v3(183.9,63.93)
  IN4 w0.102: v3(183.86,60.49) 184.08,60.49 184.6,61.01 184.6,63.24 v3(183.9,63.93)
SP_TPM_LPC_EN_R: length 4.5
  TOP w0.102: U39.28 v1(217.21,105.84) 217.21,104.74 R1667.2 R1169.2 R3771.2
SPI_CLK32: length 13.1
  TOP w0.102: RPH7.3 230.69,133.28 230.8,133.17 230.8,125.26 230.68,125.14 230.13,125.14 230,125.01 v3(230,124.3) 230,123.8 229.87,123.68 229.33,123.68 229.2,123.8 229.2,124.17 229.07,124.3 U53.6
SPI_CLK64: length 12.8
  TOP w0.102: RPH7.1 229.69,133.39 229.41,133.11 229.41,132.57 229.29,132.44 228.92,132.44 228.79,132.57 228.79,133.89 228.67,134.01 228.33,134.01 228.2,133.89 228.2,132.53 228.08,132.4 227.78,132.4 227.65,132.53 227.65,133.89 227.52,134.01 227.14,134.01 227.01,133.89 v2(227.01,133.68) 227.01,130.8 227.4,130.42 U52.6
SPI_DIN32: length 23.2
  TOP w0.102: RPH11.6 232.99,133.44 232.88,133.34 232.88,126.65 233.01,126.52 239.96,126.52 240.08,126.39 240.08,123.04 239.33,122.29 v2(238.53,122.29) 237.25,122.29 236.51,123.03 U53.2
SPI_DIN64: length 21.7
  TOP w0.102: U52.2 236.68,129.15 236.81,129.02 236.81,128.82 236.93,128.69 237.21,128.69 237.34,128.82 237.34,129.8 237.47,129.92 237.83,129.92 237.96,129.8 237.96,128.78 238.09,128.65 238.43,128.65 238.56,128.78 238.56,129.78 238.69,129.91 239.05,129.91 239.18,129.78 239.18,128.74 239.31,128.62 239.61,128.62 239.74,128.74 239.74,132.37 239.24,132.87 v2(237.82,132.87) 235.34,132.87 235.24,132.97 235.24,133.92 235.11,134.05 234.76,134.05 234.63,133.92 234.63,133 234.51,132.87 234.11,132.87 233.99,133 RPH11.8
SPI_DO32: length 13
  TOP w0.102: R901.1 226.07,125.87 225.95,126 224.97,126 224.84,126.13 224.84,126.43 224.97,126.56 v2(225.35,126.56) 228.75,126.56 228.88,126.43 228.88,126.24 228.75,126.11 226.66,126.11 226.53,125.99 226.53,124.87 226.66,124.74 226.91,124.74 227.04,124.87 227.04,125.44 227.17,125.57 U53.5
SPI_DO64: length 12.9
  TOP w0.102: RPH7.2 v3(230.19,127.73) 230.19,127.37 230.07,127.24 229.62,127.24 229.49,127.37 229.49,131.56 229.36,131.69 U52.5
SPI_PCH_CLK: length 34.1
  TOP w0.102: RPH7.6 230.69,135.68 v3(230.63,135.74) ; RPH7.8 229.69,134.75 229.57,134.62 226.85,134.62 226.73,134.74 226.73,134.91 226.85,135.03 228.8,135.03 228.93,135.16 228.93,135.34 228.8,135.47 v3(228.57,135.47) 226.08,135.47 225.44,134.83 225.44,133.19 225.34,133.09 225.03,133.09 224.93,133.19 v2(224.93,134.18) 224.93,134.83 224.83,134.93 224.52,134.93 224.42,134.83 224.42,133.19 224.32,133.09 224.02,133.09 223.92,133.19 223.92,134.83 223.81,134.93 220.38,134.93 219.96,134.51 216.16,134.51 215.53,135.13 RH181.1 214.9,136.01 213.27,136.01 212.76,135.5 JSPI1.7
  IN1 w0.102: v3(230.63,135.74) 228.84,135.74 v3(228.57,135.47)
SPI_PCH_CS0#: length 37.1
  TOP w0.102: R7.1 239.97,128.13 240.1,128.26 240.1,132.51 238.63,133.98 237.86,133.98 235.81,136.02 v3(234.27,136.02) ; JSPI1.9 214,134.5 214.24,134.74 214.9,134.74 RH182.1 v2(217.76,134.1) 219.2,134.1 v3(219.46,133.85)
  IN1 w0.102: v3(234.27,136.02) 231.46,133.21 220.09,133.21 v3(219.46,133.85)
SPI_PCH_CS0#_R: length 12.8
  TOP w0.102: R7.2 237.73,127.64 237.86,127.51 239.27,127.51 239.4,127.38 239.4,127.04 239.27,126.91 v2(238.18,126.91) 234.35,126.91 234.23,127.04 234.23,127.26 234.35,127.38 236.88,127.38 237.01,127.51 237.01,127.75 236.88,127.88 U52.1
SPI_PCH_CS1#: length 44.4
  TOP w0.102: R936.1 240.45,122.82 240.45,132.66 238.78,134.33 238.01,134.33 235.91,136.43 230.49,136.43 230.46,136.4 224.43,136.4 223.18,137.64 v2(219.44,137.64) 216.59,137.64 215.53,138.7 RH177.1 215.08,139.64 213.88,139.64 212.75,138.5 JSPI1.1
SPI_PCH_CS1#_R: length 13
  TOP w0.102: R936.2 v3(237.03,121.02) 230.53,121.02 230.4,121.15 230.4,121.63 230.53,121.76 U53.1
SPI_PCH_DIN: length 32
  TOP w0.102: RPH11.3 232.99,135.64 v3(232.81,135.82) 233.06,136.07 233.64,136.07 234.1,135.61 234.47,135.61 234.6,135.49 234.6,134.99 234.73,134.86 234.98,134.86 235.11,134.99 235.11,135.49 235.23,135.61 235.59,135.61 235.71,135.49 235.71,135.16 235.84,135.04 236.29,135.04 236.42,134.91 236.42,134.55 236.29,134.42 234.11,134.42 233.99,134.55 RPH11.1 ; JSPI1.5 212.76,136.5 213.35,137.1 215.08,137.1 RH179.1 216.16,136.64 v1(216.6,136.21) v3(216.97,135.83)
  IN1 w0.102: v3(216.97,135.83) 219.15,135.83 219.96,136.64 231.98,136.64 v3(232.81,135.82)
SPI_PCH_DO: length 40.4
  TOP w0.102: RPH7.7 230.19,135.91 230.07,136.04 223,136.04 222.91,136.13 222.91,136.96 222.78,137.09 222.53,137.09 222.4,136.96 222.4,135.88 222.28,135.75 v3(221.81,135.75) v2(220.75,135.75) 219.65,135.75 219.55,135.85 219.55,136.45 219.42,136.58 219.17,136.58 219.04,136.45 219.04,135.85 218.94,135.75 218.64,135.75 218.54,135.85 218.54,137.18 218.43,137.28 218.13,137.28 218.03,137.18 218.03,135.85 217.93,135.75 217.55,135.75 217.43,135.88 217.43,137.16 217.3,137.29 216.16,137.29 RH178.1 214.96,138.48 213.73,138.48 212.75,137.5 JSPI1.3 ; v3(221.3,134.04) 221.3,132.44 224.49,129.25 224.49,125.5 R901.2
  IN1 w0.102: v3(221.81,135.75) 221.3,135.25 v3(221.3,134.04)
SPI_PCH_DO2: length 28.6
  TOP w0.102: JSPI1.11 214.86,133.5 RH183.1 219.27,132.83 v2(219.66,133.23) 220.05,133.61 v3(220.05,134) ; RPH11.2 233.49,134.61 233.36,134.48 232.64,134.48 232.49,134.64 RPH11.4 232.49,135.55 v3(232.22,135.82)
  IN1 w0.102: v3(232.22,135.82) 231.75,136.29 222.92,136.29 222.82,136.18 222.82,135.18 222.7,135.05 222.44,135.05 222.32,135.18 222.32,136.18 222.21,136.29 220.17,136.29 220.05,136.16 v3(220.05,134)
SPI_PCH_DO2_32: length 16.8
  TOP w0.102: R3665.2 RH186.1 237.21,123.56 236.48,124.3 U53.3 234.51,124.3 234.38,124.17 234.38,123.94 234.25,123.82 232.61,123.82 232.49,123.94 v3(232.49,125.28) RPH11.5
SPI_PCH_DO2_64: length 18.2
  TOP w0.102: RPH11.7 233.49,133.28 233.26,133.05 233.26,127.07 233.39,126.94 233.71,126.94 233.83,127.07 233.83,128.15 233.94,128.25 234.29,128.25 234.42,128.38 234.42,128.63 234.29,128.76 233.94,128.76 233.83,128.86 233.83,129.17 233.94,129.27 v3(234.05,129.27) 234.32,129.27 234.44,129.4 234.44,129.65 234.32,129.78 233.94,129.78 233.83,129.88 233.83,130.71 233.96,130.84 234.24,130.84 234.37,130.71 234.37,130.51 234.46,130.42 U52.3 RH180.1 R3664.2
SPI_PCH_DO3: length 34.9
  TOP w0.102: RPH7.5 231.19,135.87 v3(231.21,135.88) ; JSPI1.13 213.69,132.5 214,132.2 214.9,132.2 RH184.1 216.36,132.39 219.84,132.39 220.71,133.26 v3(220.71,134.03) 220.71,134.44 220.84,134.57 223.27,134.57 223.39,134.44 223.39,134.18 223.27,134.05 v2(222.56,134.05) 222.25,134.05 222.12,133.92 222.12,133.67 222.25,133.54 223.33,133.54 223.46,133.42 223.46,130.85 R3669.2
  IN1 w0.102: v3(220.71,134.03) 221.14,133.59 229.68,133.59 231.21,135.12 v3(231.21,135.88)
SPI_PCH_DO3_32: length 16.7
  TOP w0.102: R3666.2 226.07,122.84 226.26,123.03 v1(226.79,123.03) U53.7 231.01,123.03 231.41,123.43 231.41,133.38 231.19,133.6 RPH7.4
SPI_PCH_DO3_64: length 13.1
  TOP w0.102: U52.7 227.08,129.15 226.95,129.28 226.95,130 226.4,130.55 226.4,132.51 226.28,132.63 224.6,132.63 224.47,132.51 v2(224.47,131.89) 224.47,131.31 224.6,131.18 224.93,131.18 225.05,131.31 225.05,131.94 225.18,132.07 225.62,132.07 225.74,131.94 225.74,130.37 R3668.2 R3669.1
SPI_WP#_SEL: length 119.3
  TOP w0.102: v3(192.05,69.65) 191.96,69.56 U46.A12 ; v3(234.25,132.14) 234.59,132.48 239.05,132.48 239.38,132.15 239.38,130.56 239.24,130.42 RH180.2 ; RH186.2 239.42,123.56 239.7,123.84 v2(239.7,125.44) 239.7,125.82 239.42,126.1 234.1,126.1 v3(234.1,126.1)
  IN2 w0.127: v3(192.05,69.65) 191.76,69.65 191.47,69.94 191.47,71.02 192.15,71.7 192.15,73.77 192.88,74.5 192.88,75.53 194.02,76.68 194.02,79.75 194.15,79.87 194.15,83.29 195.86,85.01 195.86,91.97 198.88,94.99 198.88,105.78 199.71,106.61 199.71,116.62 201.13,118.05 201.13,121.92 202.16,122.95 v3(202.16,126.11)
  IN3 w0.127: v3(234.25,132.14) 234.72,131.67 234.72,126.73 v3(234.1,126.1) 231.56,123.56 220.66,123.56 220.24,123.98 211.19,123.98 209.06,126.11 v3(202.16,126.11)
SPKR: length 140
  TOP w0.089: v3(162.75,131.37) 163.19,131.81 163.19,133.27 RH34.2
  TOP w0.102: R1119.2 261.9,150.4 C1559.1 v1(258.8,150.4) 254.03,150.4 250.64,153.79 250.64,154.55 249.86,155.32 249.86,156.76 v3(249.67,156.95)
  IN3 w0.089: 177.22,127.71 177.21,127.71 176.97,127.48 176.97,127.39 176.57,126.99 176.13,126.99 175.12,128 174.62,128 174.55,127.93 173.4,127.93 172.75,128.58 172.1,128.58 171.83,128.85 163,128.85 162.37,129.48 162.37,130.99 v3(162.75,131.37)
  IN3 w0.127: 177.22,127.71 178.36,127.71 179.05,127.03 182.33,127.03 183.03,126.33 190.36,126.33 192.49,124.2 204.32,124.2 204.51,124.39 207.46,124.39 209.01,122.84 212.1,122.84 212.46,122.48 213.34,122.48 213.93,121.89 233.27,121.89 236.53,125.15 236.53,134.18 237.93,135.59 238.82,135.59 241.27,138.05 241.27,149.19 245.24,153.15 246.25,153.15 249.67,156.57 v3(249.67,156.95)
  BOTTOM w0.089: v3(162.75,131.37) 163.14,131.76 UH1.AL10
SRN: length 47.3
  TOP w0.254: PR719.2 50.74,158.11 v3(51.44,157.41)
  BOTTOM w0.254: PR716.2 86.63,156.2 86.36,155.93 86.36,153.26 84.8,151.69 80.76,151.69 79.8,152.64 73.69,152.64 73.38,152.33 67.67,152.33 66.11,150.76 56.43,150.76 v1(55.06,152.14) 51.44,155.76 v3(51.44,157.41) 50.85,157.99 PC722.2 50.85,159.03 PC723.1
SRP: length 45.4
  TOP w0.254: PR718.2 52.01,157.77 v3(52.01,157.22)
  BOTTOM w0.254: PR716.3 85.7,156.2 85.98,155.92 85.98,153.41 84.64,152.07 80.91,152.07 79.96,153.03 73.53,153.03 73.22,152.71 67.51,152.71 65.95,151.15 57.41,151.15 v1(53.26,155.29) 52.01,156.55 v3(52.01,157.22) 52.01,157.86 PC722.1 51.75,158.12 PC721.2
SRTCRST#: length 9.2
  TOP w0.089: v3(177.27,131.44) 177.78,130.92 178.79,130.92
  TOP w0.102: v1(180.74,127) 180.32,127.42 180.25,127.42 RH42.2 179.7,127.97 CH6.2 179.7,129.18 179.93,129.41 ME1.2 179.93,130.46 179.47,130.92 178.79,130.92
  BOTTOM w0.089: UH1.B9 175.43,131.77 176.78,131.77 177.11,131.44 177.22,131.44
  BOTTOM w0.102: 177.22,131.44 v3(177.27,131.44)
STSTART_DCBLOCK_GC: length 8.9
  TOP w0.254: PR811.2 44.08,149.79 44.83,149.79 45.02,149.6 v1(45.02,149.28) 45.02,144.2 44.05,143.23 PU800.16
SUS_ON: length 83.2
  TOP w0.102: v3(226.05,66) v2(226.77,66) 230.04,66 231.08,67.05 R1607.1 ; v3(186.43,60.02) 186.51,59.94 RP6.4 ; v3(185.83,64) 185.87,63.97 U46.B60
  TOP w0.254: v3(182.17,85.18) 181.57,85.78 PR210.1
  IN1 w0.102: v3(226.05,66) 226.01,65.97 215.1,65.97 212.15,63.02 209.98,63.02 209.01,62.05 207.6,62.05 206.78,62.87 204.92,62.87 203.53,64.25 197.57,64.25 196.67,63.35 193.15,63.35 192.24,62.44 190.23,62.44 189.99,62.68 188.02,62.68 187.4,63.3 186.69,63.3 185.99,64 v3(185.83,64) 185.83,65.37 184.98,66.23 184.98,67.75 183.39,69.33 181.94,69.33 181.02,70.26 181.02,72.91 180.67,73.26 180.67,74.34 183.97,77.64 183.97,83.38 v3(182.17,85.18)
  IN4 w0.102: v3(186.43,60.02) 186.21,60.24 186.21,62.13 185.83,62.51 v3(185.83,64)
SUS_STAT#/LPCPD#: length 77.2
  TOP w0.102: v1(215.9,105.65) 216.42,105.14 v3(216.42,104.39) 216.64,104.39 217.23,103.8 R1667.1 ; v3(171.66,119) 171.59,119 RH73.2
  IN2 w0.089: v3(169.23,130.08) 169.23,128.95 170.81,127.37 170.81,126.62
  IN2 w0.127: v3(216.68,115.33) 216.69,115.33 216.69,113.57 217.34,112.92 217.34,111.34 216.95,110.96 216.95,107.94 216.42,107.41 v3(216.42,104.39) ; 170.81,126.62 170.81,125.84 170.65,125.68 170.65,125.04 172.42,123.28 172.42,121.38 172.05,121.01 172.05,119.98 171.66,119.6 v3(171.66,119)
  IN3 w0.127: v3(171.66,119) 171.86,118.8 171.86,118.8 172.1,118.56 172.46,118.56 173.15,117.87 175.21,117.87 175.46,118.13 180.68,118.13 181.44,117.36 185.7,117.36 187.84,115.23 198.48,115.23 199.16,115.92 202.72,115.92 203.3,116.5 207.24,116.5 208.94,114.8 213.32,114.8 214.2,115.67 215.46,115.67 215.8,115.33 v3(216.68,115.33)
  BOTTOM w0.089: v3(169.23,130.08) 168.75,130.56 UH1.U7
SUSACK#: length 79.9
  TOP w0.102: U46.A58 186.62,61.83 186.56,61.78 186.56,61.46 v3(186.98,61.05)
  IN4 w0.102: v3(186.56,122.67) 186.56,121.45 185.98,120.87 185.98,108.84 187.69,107.13 187.69,100.27 188.6,99.36 188.6,90.7 188.18,90.28 188.18,80.65 186.3,78.78 185.57,78.78 185.15,78.36 184.57,78.36 181.07,74.85 181.07,74.12 181.67,73.51 181.67,73.28 181.04,72.65 181.04,67.79 181.71,67.12 184.08,67.12 186.12,65.08 186.69,65.08 187.1,64.67 187.1,62.54 187.39,62.25 187.39,61.46 v3(186.98,61.05)
  BOTTOM w0.102: v3(186.56,122.67) v1(184.89,122.66) 184.05,122.66 182.62,122.66 181.18,122.66 180.8,123.04 RH101.1
SUSACK#_R: length 24.6
  IN4 w0.089: 171.13,126.62 171.13,127.55 170.2,128.48 v3(170.2,129.73)
  IN4 w0.102: v3(172.28,119.58) 172.28,119.78 173.06,120.57 173.06,121.62 172.48,122.2 172.48,124.38 171.13,125.73 171.13,126.62
  BOTTOM w0.089: UH1.R6 169.97,129.73 v3(170.2,129.73)
  BOTTOM w0.102: 177.55,121.97 178.82,121.97 179.88,123.04 RH101.2 ; 177.55,121.97 177.29,121.72 177.29,120.26 177.01,119.97 175.1,119.97 174.74,120.34 v1(173.55,120.34) 173.31,120.34 172.55,119.58 v3(172.28,119.58) ; 177.55,121.97 177.55,122.92 RH91.2
SUSCLK: length 1.9
  TOP w0.089: v3(168.22,130.16) 168.76,130.71 T68.1
  BOTTOM w0.089: v3(168.22,130.16) 167.97,130.16 UH1.Y6
SW1: length 9.3
  IN2 w1.016: 206.03,46.19 201.11,41.27 199.33,41.27
  BOTTOM w0.102: v4(197.8,41.01) v1(197.8,41.6)
  vias: v4(198.44,41.01) v4(206.38,47.17) v4(207.01,47.17)
SW2: length 10.3
  IN2 w1.016: 207.96,33.9 207.3,33.24 200.43,33.24 199.14,34.53
  BOTTOM w0.102: v4(197.83,35.18) v1(197.83,34.56)
  vias: v4(198.48,35.18) v4(208.98,34.09) v4(209.62,34.09)
SW_1.35V: length 13
  IN1 w1.016: 160.4,89.21 172.91,89.21 173.29,88.83
  vias: v1(158.5,91.11) v3(174.55,87.89) v3(175.13,87.89) v4(158.5,89.97) v4(158.5,89.33) v4(158.5,88.7) v4(158.5,88.06) v4(158.5,87.43) v4(158.5,86.79) v4(158.5,86.16) v4(158.5,85.52) v4(158.5,84.89) v4(158.5,84.25) v4(159.13,89.97) v4(159.13,89.33) v4(159.13,88.7) v4(159.13,88.06) v4(159.13,87.43) v4(159.13,86.79) v4(159.13,86.16) v4(159.13,85.52) v4(159.13,84.89) v4(159.13,84.25)
SW_+1.05VSP: length 8.3
  IN2 w1.016: 164.15,96.51 164.66,96 172.28,96
  vias: v1(160.85,98.99) v3(173.34,95.68) v3(173.93,95.68) v4(161.23,97.91) v4(161.23,97.27) v4(161.23,96.64) v4(161.23,96) v4(161.23,95.37) v4(161.86,96.89) v4(161.86,96.26) v4(162.5,96.89) v4(162.5,96.26) v4(163.13,96.89) v4(163.13,96.26)
SW_LAN_TX0+: length 16.8
  TOP w0.089: v3(264.08,187.78) 263.95,187.91 263.74,187.91 R575.1 ; v3(253.31,183.04) 253.31,183.03 253.16,182.88 253.16,181.61 253.26,181.52 U32.24
  IN1 w0.089: v3(253.31,183.04) 252.98,183.37 252.98,183.51 253.19,183.72 255.76,183.72 257.71,185.66 260.42,185.66 262.87,188.12 263.75,188.12 v3(264.08,187.78)
SW_LAN_TX0+_R: length 3.6
  TOP w0.089: R575.2 262.54,187.62 C500.1 261.37,187.92 260.79,187.92 260.3,187.43 T156.1
SW_LAN_TX0-: length 17
  TOP w0.089: v3(264.08,188.37) 263.99,188.28 263.91,188.2 263.78,188.2 R576.1 ; v3(252.73,183.04) 252.87,182.89 252.87,181.55 252.76,181.43 U32.25
  IN1 w0.089: v3(264.08,188.37) 262.76,188.37 260.31,185.92 257.6,185.92 255.66,183.97 253.08,183.97 252.73,183.62 v3(252.73,183.04)
SW_LAN_TX0-_R: length 3.6
  TOP w0.089: T156.2 260.31,188.7 260.8,188.21 261.35,188.21 C500.2 262.54,188.53 R576.2
SW_LAN_TX1+: length 26.9
  TOP w0.089: v3(264.12,192.57) 264.41,192.86 264.41,193.14 264.18,193.37 263.98,193.37 263.82,193.21 263.39,193.21 263.27,193.09 263.27,192.89 R577.1 ; v3(251.3,182.38) 251.05,182.13 251.05,181.72 251.26,181.52 U32.28
  IN1 w0.089: v3(251.3,182.38) 250.97,182.05 250.97,181.84 251.4,181.41 254.44,181.41 258,184.97 262.36,184.97 264.92,187.53 264.92,191.25 264.45,191.72 264.45,192.24 v3(264.12,192.57)
SW_LAN_TX1+_R: length 3.9
  TOP w0.089: T156.5 260.26,192.51 260.75,193 261.42,193 C501.1 261.98,193.06 262.2,193.06 262.55,192.71 R577.2
SW_LAN_TX1-: length 26.9
  TOP w0.089: v3(264.7,192.57) 264.7,193.27 264.3,193.67 R578.1 ; v3(250.71,182.38) 250.76,182.33 U32.29
  IN1 w0.089: v3(264.7,192.57) 264.7,191.83 265.18,191.35 265.18,187.43 262.46,184.71 258.1,184.71 254.55,181.16 251.29,181.16 250.71,181.74 v3(250.71,182.38)
SW_LAN_TX1-_R: length 3.9
  TOP w0.089: T156.6 260.28,193.78 260.76,193.29 261.3,193.29 C501.2 261.99,193.35 262.23,193.35 R578.2
SW_LAN_TX2+: length 37.7
  TOP w0.089: T156.7 260.4,195.05 260.48,195.13 260.48,195.63 260.65,195.81 260.96,195.81 v3(261.25,195.51) ; v3(248.52,182.72) 248.52,182.42 248.67,182.27 248.67,181.5 248.76,181.41 U32.33
  IN1 w0.089: v3(248.52,182.72) 248.52,182.49 248.73,182.28 248.73,181.6 249.87,180.46 254.83,180.46 258.39,184.01 262.75,184.01 266.07,187.33 266.07,191.91 262.13,195.84 261.58,195.84 v3(261.25,195.51)
SW_LAN_TX2-: length 37.7
  TOP w0.089: T156.8 260.36,196.32 260.59,196.1 v3(261.25,196.1) ; v3(248.1,182.31) 248.22,182.31 248.38,182.15 248.38,181.38 248.26,181.26 U32.34
  IN1 w0.089: v3(261.25,196.1) 262.24,196.1 266.32,192.01 266.32,187.22 262.86,183.76 258.5,183.76 254.94,180.2 249.77,180.2 248.48,181.49 248.48,182.17 248.34,182.31 v3(248.1,182.31)
SW_LAN_TX3+: length 48.3
  TOP w0.089: T156.11 260.74,200.13 260.82,200.21 260.82,200.69 260.93,200.81 261.24,200.81 v3(261.53,200.52) ; v3(246.64,182.43) 246.64,182.13 246.74,182.04 246.74,181.43 246.76,181.42 U32.37
  IN1 w0.089: v3(261.53,200.52) 261.86,200.85 264.17,200.85 267.02,198 267.02,186.93 263.15,183.06 258.79,183.06 254.39,178.66 249.64,178.66 246.76,181.54 246.76,182.08 246.64,182.2 v3(246.64,182.43)
SW_LAN_TX3-: length 48.4
  TOP w0.089: U32.38 246.26,181.47 246.45,181.66 246.45,181.92 246.34,182.02 v3(246.23,182.02) ; T156.12 260.36,201.4 260.66,201.11 v3(261.53,201.11)
  IN1 w0.089: v3(246.23,182.02) 246.46,182.02 246.51,181.97 246.51,181.43 249.53,178.41 254.49,178.41 258.89,182.81 263.25,182.81 267.27,186.83 267.27,198.11 264.28,201.11 v3(261.53,201.11)
SYS_LED_MASK#: length 206.7
  TOP w0.102: v3(179.01,62.54) 178.79,62.32 173.94,62.32 173.06,61.45 168.78,61.45 167.93,60.59 167.93,59.41 167.78,59.26 RP18.5 ; v3(182.63,65.83) 182.11,65.3 181.28,65.3 U46.B48 ; v3(252.16,155.18) 252.92,154.42 252.92,153.16 254.27,151.82 259.87,151.82 260.1,152.05 260.1,152.4 259.97,152.53 259.97,155.18 260.33,155.54 260.33,156.58 260.33,156.58 260.33,162.93 260.99,163.59 260.99,172.01 262.3,173.33 262.3,175.96 261.23,177.03 260.22,177.03 259.72,176.52 Q325.5 Q325.2 258.07,177.15 258.07,177.47 257.73,177.81 Q326.2 ; Q84.5 226.23,112.41 v3(226.48,112.66) 226.88,113.06 U58.1
  IN1 w0.102: v3(226.48,112.66) 225.87,113.27 219.22,113.27 218.51,112.56 209.24,112.56 208.05,111.37 204.1,111.37 203.7,110.98 202.86,110.98 v3(202.42,111.42)
  IN2 w0.127: v3(202.42,111.42) 202.38,111.37 202.38,100.55 202.69,100.24 202.69,96.64 198.39,92.34 198.39,87.99 197.41,87.01 197.41,84.3 196.46,83.35 196.46,79.41 196.18,79.13 196.18,76.68 195.63,76.13 195.63,70.02 194.33,68.72 193.75,68.72 192.95,67.93 190.64,67.93 190.05,67.33 190.05,67.33 187.21,67.33 187.01,67.13 183.95,67.13 182.64,65.83 v3(182.63,65.83)
  IN3 w0.127: v3(226.48,112.66) 226.95,113.13 226.95,115.28 229.71,118.04 234.82,118.04 240.2,123.42 240.2,133.6 247.94,141.34 247.94,144.11 250.2,146.37 250.2,150.16 250.93,150.89 250.93,153.01 250.65,153.29 250.65,154.31 251.53,155.18 v3(252.16,155.18)
  BOTTOM w0.102: v3(182.63,65.83) 182.13,65.33 181.74,65.33 180.74,64.33 180.74,63.88 v1(180.28,63.43) 179.9,63.43 v3(179.01,62.54)
