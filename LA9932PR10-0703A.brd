# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_OC2#: length 72.9
  IN3 w0.127: v3(168.58,120.44) 168.58,119.56 169.94,118.2 172.46,118.2 173.04,117.62 175.32,117.62 175.57,117.87 180.57,117.87 181.33,117.11 185.6,117.11 187.73,114.98 198.58,114.98 199.27,115.66 202.82,115.66 203.41,116.25 207.13,116.25 208.84,114.54 214.99,114.54 215.49,115.04 v3(215.49,115.05)
  BOTTOM w0.089: UH1.U2 169,128.44 169,127.42 169.28,127.14 169.28,126.62
  BOTTOM w0.102: RH6.1 216.33,106 216.99,106.66 216.99,110.21 216.43,110.77 216.43,113.69 v1(216,114.13) 215.49,114.64 v3(215.49,115.05) ; 169.28,126.62 169.28,125.92 169.66,125.54 169.66,121.34 168.76,120.44 v3(168.58,120.44) 168.58,120.16 168.19,119.76 RPH8.4
USB_OC3#: length 69.6
  TOP w0.089: RPH3.3 171.26,127.56 170.32,126.62
  TOP w0.102: 170.32,126.62 170.12,126.42 v3(170.06,126.42)
  IN3 w0.127: v3(212.87,121.55) 212.31,121.55 211.78,122.08 208.7,122.08 207.78,122.99 192.26,122.99 189.94,125.31 182.61,125.31 181.91,126.01 176.85,126.01 176.26,125.43 172.53,125.43 171.53,126.42 v3(170.06,126.42)
  BOTTOM w0.089: 170.25,126.62 170.4,126.76 170.4,127.61 170.15,127.86 UH1.P1
  BOTTOM w0.102: v3(212.87,121.55) 212.46,121.14 v1(212.46,120.2) 212.46,118.66 217.51,113.6 217.51,105.55 217.06,105.1 216.07,105.1 215.95,104.98 RH7.1 ; 170.25,126.62 v3(170.06,126.42)
USB_OC4#: length 290.4
  IN1 w0.102: v3(28.39,186.68) 28.39,173.32 34.84,166.87 39.81,166.87 50.14,156.54 53.48,156.54 55.97,154.05 68.65,154.05 68.98,154.05 70.27,152.75 76.18,152.75 76.31,152.89 76.82,153.4 79.65,153.4 81.21,151.84 90.91,151.84 91.4,151.35 102.42,151.35 104.14,153.06 112.81,153.06 115.03,150.84 117.26,150.84 119.06,149.04 v3(119.68,149.04)
  IN3 w0.127: v3(218.16,111.57) 218.16,111.65 217.36,112.45 214.57,112.45 212.29,110.18 208.16,110.18 205.82,112.51 185.73,112.51 184.75,113.49 178.67,113.49 177.9,114.25 173.7,114.25 173.51,114.44 168.7,114.44 167.01,116.13 v3(166.56,116.13)
  BOTTOM w0.089: UH1.M3 170.96,128.48 171.28,128.16 171.28,126.93 171.45,126.75 171.45,126.62
  BOTTOM w0.102: v3(119.68,149.04) 121.36,150.72 v1(124.56,150.72) 129.61,150.72 133.18,147.15 137.96,147.15 150.43,134.68 150.43,124.09 158.54,115.99 162.98,115.99 163.08,115.89 166.32,115.89 v3(166.56,116.13) ; v3(166.56,116.13) 166.56,116.53 166.75,116.72 RPH1.4 ; v3(166.56,116.13) 168.28,116.13 168.86,116.72 170.07,117.92 170.07,119.26 170.58,119.77 170.58,121.92 171.77,123.12 171.77,125.77 171.45,126.08 171.45,126.62 ; RH8.1 215.6,104.14 216.32,104.87 217.16,104.87 217.74,105.45 217.74,111.15 v3(218.16,111.57) ; v3(28.39,186.68) 13.84,186.68 10.41,183.25 JIO1.28
USB_OC5#: length 74.5
  TOP w0.089: RPH3.4 171.76,127.49 170.89,126.62
  TOP w0.102: v3(170.16,125.85) 170.89,126.58 170.89,126.62
  IN3 w0.127: v3(212.89,120.97) 212.53,120.97 211.68,121.82 208.59,121.82 207.68,122.74 201.02,122.74 200.41,122.13 192.76,122.13 189.83,125.06 182.5,125.06 181.8,125.76 178.18,125.76 177.31,124.88 175.86,124.88 175.45,124.48 175.02,124.48 174.33,125.17 172.42,125.17 171.75,125.85 v3(170.16,125.85)
  BOTTOM w0.089: UH1.T1 169.25,127.95 169.25,127.43 169.65,127.03 169.65,126.62
  BOTTOM w0.102: v3(170.16,125.85) 169.87,125.85 169.65,126.07 169.65,126.62 ; v3(212.89,120.97) 212.79,120.86 212.79,118.65 v1(218.11,113.33) 218.57,112.87 218.57,104.26 217.26,102.95 RH9.1
USB_OC6#: length 80.7
  IN3 w0.127: v3(217.61,114.86) 216.22,114.86 215.65,114.29 208.66,114.29 207.9,115.05 199.38,115.05 198.79,114.47 187.52,114.47 185.39,116.6 181.12,116.6 180.36,117.36 178.05,117.36 177.43,116.74 175.26,116.74 174.88,117.11 172.83,117.11 172.25,117.69 169.51,117.69 168.91,118.29 v3(168.9,118.29)
  BOTTOM w0.089: 170.88,126.62 170.88,126.67 170.75,126.8 170.75,127.82 170.66,127.91 170.66,128.4 UH1.N2
  BOTTOM w0.102: 170.88,126.62 170.88,125.4 v3(171.07,125.21) 171.07,124.77 170.12,123.82 170.12,120 168.9,118.79 v3(168.9,118.29) 168.32,117.72 RPH1.2 ; RH17.1 217.01,101.93 218.86,103.79 v1(218.86,103.84) 218.86,113.61 v3(217.61,114.86)
USB_PWR_SHR_EN#: length 208.1
  TOP w0.102: RP4.5 191.12,60.54 192.16,61.58 192.16,61.85 v1(192.41,62.09) 192.57,62.26 192.57,63.2 192.79,63.41 193.99,63.41 R806.2 195.05,64.47 v3(195.05,64.52) ; v3(276.32,180.12) 276.32,180.03 R1626.1 275.29,179 Q59.2 ; U46.B10 190.12,68.31 190,68.19 189.61,68.19 189.22,68.58 v3(189.22,68.6)
  IN1 w0.102: v3(189.22,68.6) 189.22,68.33 189.36,68.19 190.57,68.19 191.01,67.74 191.01,66.41 191.84,65.59 193.98,65.59 v3(195.05,64.52)
  IN2 w0.127: v3(195.05,64.52) 199.23,64.52 202.19,67.48 202.19,69.48 203.96,71.25 203.96,75.68 203.33,76.32 202.21,76.32 201.23,77.29 201.23,83.18 204.24,86.18 204.24,89.18 204.24,89.18 204.24,89.61 203.84,90.01 203.84,92.44 209.26,97.86 209.26,98.28 209.26,106.88 207.78,108.36 207.78,111.12 208.09,111.43 208.09,114.76 206.8,116.05 206.8,126.23 204.9,128.13 204.9,134.19 204.07,135.03 v3(204.07,139.63)
  IN4 w0.102: v3(276.32,180.12) 276.95,179.49 276.95,176.7 272.45,172.2 261.75,172.2 253.75,164.2 253.75,159.18 252.87,158.3 251.91,158.3 248.81,155.21 234.21,155.21 229.72,150.71 224.45,150.71 223.94,150.21 207.79,150.21 206.61,149.02 206.61,146.74 204.07,144.21 v3(204.07,139.63)
USB_PWR_SHR_VBUS_EN: length 190
  TOP w0.102: v3(182.58,64.88) 182.58,64.71 182.31,64.44 181.8,64.44 181.67,64.31 U46.B50 ; v3(193.57,69.66) 194.13,69.66 194.45,69.98 RP3.8 ; Q48.2 277.01,183.9 276.86,184.05 276.86,184.79 276.66,184.99 276.11,184.99 275.65,185.46 v3(275.57,185.46) 275.15,185.46 275.07,185.37 U2.1
  IN3 w0.127: v3(193.57,69.66) 194.03,69.21 197.97,69.21 199,68.18 207.63,68.18 208.22,67.58 214.27,67.58 216.32,69.62 219.11,69.62 219.52,70.03 219.52,70.71 227.93,79.12 227.93,88.58 229.47,90.11 229.47,104.89 234.2,109.63 234.2,114.52 242.25,122.57 242.25,132.13 246.18,136.05 246.18,137.28 250.76,141.87 250.76,145.14 251.47,145.84 251.47,149.6 253.96,152.08 254.64,152.08 254.86,152.31 254.86,153.63 262.13,160.89 262.13,164.45 v3(262.52,164.83)
  BOTTOM w0.102: v3(262.52,164.83) 261.71,165.63 261.71,166.85 262.71,167.84 262.71,168.67 267.55,173.52 267.55,176.13 268.33,176.9 268.33,179.44 270.45,181.56 274.32,181.56 275.12,182.36 275.12,185 v3(275.57,185.46) ; v3(182.58,64.88) 183.19,64.88 v1(183.5,65.19) 183.9,65.59 185.99,65.59 188.6,68.19 192.85,68.19 193.57,68.91 v3(193.57,69.66)
USB_SIDE_EN#: length 312.9
  TOP w0.102: U46.A33 180.08,71.56 179.73,71.91 v3(179.73,72.54) 180.4,73.21 RP2.7
  IN3 w0.127: v3(179.73,72.54) 179.73,71.69 179.39,71.35 177.72,71.35 175.9,69.53 175.9,61.81 173.5,59.41 167.08,59.41 165.79,58.13 164.87,58.13 164.47,58.54 159.99,58.54 158.43,56.98 155.68,56.98 149.94,51.23 115.89,51.23 106.22,60.91 90.99,60.91 88.57,63.33 88.57,79.49 90.4,81.32 90.4,88.59 85.44,93.55 80.36,93.55 79.97,93.94 77.82,93.94 77.13,93.26 73.72,93.26 73.29,93.69 54.81,93.69 49.96,98.54 v3(49.96,98.61)
  IN4 w0.102: v3(3.89,183.12) 3.89,182.88 1.35,180.34 1.35,174.82 2.55,173.61 5.41,173.61 7.12,171.91 7.12,166.87 5.65,165.41 5.65,146.68 11.67,140.66 11.67,140.64 12.62,139.69 21.85,139.69 22.51,140.35 26.01,140.35 26.54,139.82 30,139.82 30.71,139.11 32.75,139.11 44.9,126.96 44.9,124.23 45.94,123.19 45.94,102.63 v3(49.96,98.61)
  BOTTOM w0.102: v3(3.89,183.12) 5.06,184.29 5.06,185.33 5.15,185.42 5.15,185.6 5.29,185.75 JIO1.38 8.04,185.75 v1(8.19,185.6)
USBP0+: length 124.9
  TOP w0.102: v3(270.07,169.09) 270.26,169.28 270.26,172.39 272.99,175.12 272.99,180.77 274.22,182 274.22,182.35 274.07,182.5 U2.6
  IN1 w0.114: v3(270.07,169.09) 270.22,168.94 270.22,168.74 270.12,168.65 266.58,168.65 265.22,167.28 265.22,166.63 262.96,164.37 262.96,163.89 260.76,161.69 260.76,160.73 258.86,158.83 252.38,158.83 249.09,155.54 233.58,155.54 233.58,155.54 232.19,155.54 232.19,155.54 231.99,155.54 229.64,153.19 228.18,151.73 220.83,151.73 216.89,147.79 193.01,147.79 192.5,147.28 191.4,147.28 190.89,147.79 183.73,147.79 181.54,145.6 179.64,145.6 179.33,145.28 179.33,144.88 v3(179.15,144.71)
  BOTTOM w0.089: 176.6,143.63 176.6,143.34 176.19,142.93 175.67,142.93 175.49,142.76 175.22,142.76 174.94,143.04 UH1.D37
  BOTTOM w0.102: v3(179.15,144.71) 178.83,145.02 178.37,145.02 177.53,144.18 177.15,144.18 176.6,143.63
USBP0-: length 124.8
  TOP w0.102: v3(270.66,169.09) 270.47,169.28 270.47,172.31 273.2,175.04 273.2,180.69 274.43,181.92 274.43,182.33 274.57,182.47 U2.7
  IN1 w0.114: v3(179.74,144.71) 179.56,144.88 179.56,145.19 179.74,145.37 181.64,145.37 183.83,147.56 190.8,147.56 191.31,147.05 192.6,147.05 193.1,147.56 216.98,147.56 220.93,151.5 228.27,151.5 229.87,153.09 232.09,155.31 232.28,155.31 249.19,155.31 249.32,155.45 252.47,158.6 258.95,158.6 260.99,160.63 260.99,161.6 263.18,163.79 263.18,164.27 265.44,166.53 265.44,167.19 266.68,168.42 270.22,168.42 270.45,168.65 270.45,168.88 v3(270.66,169.09)
  BOTTOM w0.089: 176.39,143.72 176.39,143.42 176.1,143.13 175.7,143.13 175.58,143.25 175.45,143.25 175.35,143.14 UH1.B37
  BOTTOM w0.102: 176.39,143.72 177.06,144.39 177.44,144.39 178.29,145.23 178.96,145.23 179.07,145.12 179.48,145.12 179.74,144.87 v3(179.74,144.71)
USBP0_D+: length 2.4
  TOP w0.102: U2.3 274.07,185.55 274.28,185.76 274.28,186.15 274.02,186.41 L51.4 273.94,186.87 R740.1
USBP0_D-: length 2.4
  TOP w0.102: U2.2 274.57,185.68 274.49,185.76 274.49,185.96 274.87,186.34 L51.1 274.96,186.87 R736.1
USBP0_R_D+: length 22.7
  TOP w0.102: v3(276.53,195.89) 276.71,195.7 276.71,194.53 v4(276.28,194.09) 275.59,193.4 275.59,192.52 274.47,191.4 274.47,190.76 274.37,190.66 D72.2 274.34,189.92 274.34,189.31 274.02,188.99 L51.3 273.94,188.4 R740.2
  IN1 w0.114: v3(276.53,195.89) 276.71,196.07 276.71,198.53 277.84,199.67 277.84,206.66 JUSB1.3
USBP0_R_D-: length 22.8
  TOP w0.102: v3(277.11,195.89) 276.93,195.7 276.93,194.44 276.66,194.17 276.66,194.15 276.24,193.73 276.21,193.73 275.8,193.32 275.8,192.43 274.68,191.31 274.68,190.76 274.78,190.66 D72.3 274.55,189.67 274.55,189.29 274.87,188.97 L51.2 274.96,188.4 R736.2
  IN1 w0.114: JUSB1.2 278.07,206.69 278.07,199.57 276.93,198.44 276.93,196.07 v3(277.11,195.89)
USBP1+: length 131.1
  TOP w0.102: R3690.1 282.45,183.65 L107.1 280.79,181.98 279.91,181.98 278.91,180.98 278.91,178.79 279.03,178.66 279.03,177.58 277.27,175.82 275.99,175.82 273.52,173.35 273.52,170.06 273.29,169.83 272.65,169.83 272.4,170.08 272.4,170.17 272.4,170.17 272.4,170.34 v3(272.25,170.49)
  IN1 w0.114: v3(178.33,146.83) 178.49,146.99 178.49,147.28 179.72,148.51 190.5,148.51 190.94,148.95 203.79,148.95 204.24,149.41 216.89,149.41 217.49,149.41 220.62,152.54 227.97,152.54 231.69,156.27 231.89,156.27 231.89,156.27 233.88,156.27 233.88,156.27 247.23,156.27 248.56,157.6 250.12,157.6 251.23,158.71 251.23,160.35 256.9,166.02 260.51,166.02 264.45,169.95 272.26,169.95 272.43,170.13 272.43,170.31 v3(272.25,170.49)
  BOTTOM w0.089: UH1.C38 175.35,143.45 175.66,143.76 175.78,143.76
  BOTTOM w0.102: v3(178.33,146.83) 177.59,146.09 177.59,145.58 176.7,144.69 176.7,144.61 175.85,143.76 175.78,143.76
USBP1-: length 131
  TOP w0.102: v3(272.84,170.49) 272.61,170.26 272.61,170.17 272.73,170.04 273.2,170.04 273.31,170.15 273.31,173.43 275.9,176.03 277.18,176.03 278.82,177.67 278.82,178.57 278.7,178.7 278.7,181.07 279.82,182.19 280.7,182.19 281.56,183.05 281.56,183.23 281.29,183.51 281.29,183.69 L107.4 281.85,184.25 R3689.1
  IN1 w0.114: v3(272.84,170.49) 272.66,170.31 272.66,170.03 272.35,169.73 264.54,169.73 260.61,165.79 256.99,165.79 251.46,160.26 251.46,158.61 250.22,157.37 248.66,157.37 247.46,156.17 247.33,156.04 233.78,156.04 231.79,156.04 228.06,152.31 220.72,152.31 217.58,149.18 216.79,149.18 204.34,149.18 203.89,148.73 191.03,148.73 190.59,148.28 179.81,148.28 178.72,147.18 178.72,147.02 v3(178.91,146.83)
  BOTTOM w0.089: 176.21,143.82 176.21,143.5 176.05,143.34 175.87,143.34 175.8,143.4 UH1.A38
  BOTTOM w0.102: 176.21,143.82 176.91,144.52 176.91,144.6 177.8,145.49 177.8,146 178.16,146.36 178.44,146.36 v3(178.91,146.83)
USBP1_D+: length 23.2
  TOP w0.102: R3690.2 283.22,184.41 L107.2 283.72,184.91 283.72,185.36 283.98,185.62 284.36,185.62 D89.3 285.41,185.2 285.57,185.37 286.02,185.37 286.88,186.22 289.18,186.22 289.2,186.21 289.84,186.21 289.85,186.22 290.49,186.22 290.79,186.53 292.04,186.53 292.15,186.41 v4(292.51,186.41) 292.86,186.41 293.28,186.83 293.28,194.64 292.34,195.59 291.83,195.59 291.52,195.9 JUSB2.3
USBP1_D-: length 23.2
  TOP w0.102: JUSB2.2 291.52,195.18 291.72,195.38 292.25,195.38 293.07,194.56 293.07,186.92 292.79,186.64 292.22,186.64 292.13,186.74 290.7,186.74 290.4,186.43 v4(289.52,186.43) 286.79,186.43 285.93,185.58 285.57,185.58 285.41,185.74 D89.2 284.74,185.83 283.9,185.83 283.64,185.58 283.18,185.58 L107.3 282.62,185.01 282.5,185.01
USBP2+: length 125.8
  TOP w0.102: R3710.1 280.96,175.78 L110.1 280.02,175.78 279.91,175.89 279.7,175.89 278.88,175.06 276.25,175.06 275.27,174.09 275.27,172.67 275.29,172.65 275.29,172 275.27,171.99 275.27,170.17 274.94,169.83 274.42,169.83 274.24,170.02 274.24,170.3 v3(274.05,170.49)
  IN1 w0.114: v3(178.52,143.46) 178.63,143.56 178.63,143.95 178.85,144.17 181.52,144.17 183.36,146.01 184.41,147.06 190.59,147.06 190.81,146.84 190.81,146.84 191.1,146.55 192.8,146.55 193.31,147.06 217.29,147.06 220.71,150.49 222.89,150.49 223.18,150.78 228.76,150.78 232.35,154.37 232.35,154.69 232.49,154.82 233.28,154.82 242.99,154.82 243.41,154.4 243.51,154.3 247.7,154.3 248.23,154.82 249.39,154.82 252.14,157.57 253.43,157.57 253.97,158.11 259.16,158.11 261.48,160.43 261.48,161.39 264.02,163.93 264.72,163.93 268.71,167.92 270.42,167.92 271.72,169.22 273.81,169.22 274.23,169.64 274.23,170.31 v3(274.05,170.49)
  BOTTOM w0.089: 177.22,143.35 177.21,143.35 176.34,142.48 176.07,142.48 175.93,142.33 175.65,142.33 175.45,142.53 175,142.53 UH1.C36
  BOTTOM w0.102: v3(178.52,143.46) 177.78,143.46 177.67,143.35 177.22,143.35
USBP2-: length 125.8
  TOP w0.102: v3(274.63,170.49) 274.45,170.3 274.45,170.11 274.51,170.04 274.85,170.04 275.06,170.26 v4(275.06,172.34) 275.06,174.18 276.16,175.27 278.79,175.27 279.62,176.1 279.87,176.1 279.95,176.18 279.95,176.54 280.04,176.63 L110.4 281,176.63 R3711.1
  IN1 w0.114: v3(274.63,170.49) 274.46,170.31 274.46,169.54 273.9,168.99 271.81,168.99 270.52,167.69 268.8,167.69 264.82,163.71 264.12,163.71 261.71,161.3 261.71,160.33 259.25,157.88 254.06,157.88 253.53,157.34 252.24,157.34 249.49,154.59 248.32,154.59 247.8,154.07 243.42,154.07 243.18,154.3 242.89,154.59 233.18,154.59 232.58,154.59 232.58,154.28 228.86,150.55 223.27,150.55 222.98,150.26 220.81,150.26 217.39,146.83 193.4,146.83 192.9,146.32 191.01,146.32 190.58,146.75 190.5,146.83 184.51,146.83 183.52,145.85 181.62,143.94 178.94,143.94 178.86,143.86 178.86,143.71 v3(179.11,143.46)
  BOTTOM w0.089: 177.22,143.56 177.21,143.56 177.2,143.56 177.14,143.56 177.02,143.44 177.02,143.44 176.26,142.67 176.02,142.67 175.96,142.74 175.91,142.74 UH1.A36
  BOTTOM w0.102: 177.22,143.56 177.59,143.56 177.69,143.67 178.09,143.67 178.29,143.87 178.83,143.87 179.11,143.59 v3(179.11,143.46)
USBP2_D+: length 21.1
  TOP w0.102: JUSB3.3 291.52,176.33 291.68,176.17 292.15,176.17 292.46,176.48 292.46,179.9 291.21,181.16 289.68,181.16 288.18,179.66 288.18,177.57 287.86,177.26 287.55,177.26 D90.2 286.41,176.88 286.31,176.99 285.9,176.99 284.97,176.06 283.13,176.06 282.85,175.78 L110.2 282.04,175.78 R3710.2
USBP2_D-: length 21.2
  TOP w0.102: R3711.2 282,176.63 L110.3 282.82,176.63 283.19,176.27 284.88,176.27 285.81,177.2 286.31,177.2 286.41,177.3 D90.3 287,177.47 287.78,177.47 287.97,177.66 287.97,179.74 289.59,181.37 291.3,181.37 292.67,179.99 292.67,176.39 292.23,175.95 291.85,175.95 291.52,175.62 JUSB3.2
USBP3+: length 76.5
  IN4 w0.114: v3(180.22,146.87) 180.41,147.05 180.41,157.01 178.51,158.91 178.15,158.91 176.45,160.61 174.41,160.61 174,160.2 172.78,160.2 171.93,161.05 163.62,161.05 161.83,162.84 161.83,167.67 161.6,167.9 157.46,167.9 157.32,168.04 156.08,168.04 154.79,166.74 140.52,166.74 138.84,168.42 136.81,168.42 136.4,168.83 136.4,170.7 v3(136.3,170.8)
  BOTTOM w0.089: UH1.C34 175.38,141.82 175.69,142.14 175.98,142.14 176.14,142.3 176.55,142.3 176.66,142.41 177.13,142.41 177.14,142.41 177.2,142.41 177.21,142.42 177.22,142.42
  BOTTOM w0.102: 177.22,142.42 177.97,142.42 178.06,142.5 178.84,142.5 179.41,143.08 179.92,143.08 180.22,143.37 v3(180.22,146.87) ; JDOCK1.72 136.34,170.3 136.48,170.44 136.48,170.61 v3(136.3,170.8)
USBP3-: length 76.5
  IN4 w0.114: v3(180.85,146.87) 180.63,147.09 180.63,157.11 178.6,159.14 178.25,159.14 176.55,160.84 174.32,160.84 173.9,160.43 172.87,160.43 172.03,161.27 163.72,161.27 162.05,162.94 162.05,167.76 161.69,168.12 157.56,168.12 157.42,168.27 155.99,168.27 154.69,166.97 140.62,166.97 138.94,168.65 136.91,168.65 136.63,168.93 136.63,170.55 v3(136.88,170.8)
  BOTTOM w0.089: 177.22,142.21 176.74,142.21 176.63,142.1 176.22,142.1 176.09,141.96 176.09,141.91 176.16,141.84 176.16,141.74 176.11,141.69 175.93,141.69 UH1.A34
  BOTTOM w0.102: v3(136.88,170.8) 136.7,170.61 136.7,170.44 136.84,170.3 JDOCK1.74 ; 177.22,142.21 178.06,142.21 178.14,142.29 178.92,142.29 179.5,142.87 180.01,142.87 180.43,143.29 180.43,146.49 180.8,146.87 v3(180.85,146.87)
USBP4+: length 44.2
  IN1 w0.114: v3(180.05,141.61) 180.05,142.18 180.3,142.43 182.31,142.43 183.32,143.44 186.62,143.44 187.29,144.1 197.95,144.1 199,145.15 200.93,145.15 201.35,145.57 204.08,145.57 205.02,144.63 v3(209.1,144.63)
  BOTTOM w0.089: 177.22,141.6 176.54,141.6 176.27,141.32 175.67,141.32 175.49,141.14 175.2,141.14 174.93,141.41 UH1.D33
  BOTTOM w0.102: JMINI2.38 210.4,148.47 210.39,148.47 210.08,148.23 210.08,147.65 208.41,145.98 208.41,144.37 208.52,144.26 208.73,144.26 v3(209.1,144.63) ; 177.22,141.6 180.04,141.6 v3(180.05,141.61)
USBP4-: length 44.3
  IN1 w0.114: v3(180.63,141.61) 180.28,141.96 180.28,142.09 180.39,142.2 182.41,142.2 183.41,143.21 186.72,143.21 187.38,143.87 198.04,143.87 199.09,144.92 201.03,144.92 201.45,145.34 203.99,145.34 204.93,144.4 208.74,144.4 v3(209.1,144.05)
  BOTTOM w0.089: UH1.B33 175.35,141.5 175.45,141.6 175.58,141.6 175.66,141.52 176.19,141.52 176.46,141.79 177.13,141.79 177.14,141.8 177.2,141.8 177.21,141.81 177.22,141.81
  BOTTOM w0.102: v3(180.63,141.61) 180.23,142.01 179.87,142.01 179.66,141.81 177.22,141.81 ; JMINI2.36 209.62,148.62 209.62,148.59 209.87,148.34 209.87,147.74 208.2,146.06 208.2,144.28 208.43,144.05 v3(209.1,144.05)
USBP5+: length 136.5
  IN1 w0.089: v3(173.03,141.08) 173.15,140.96 173.15,140.69 173.36,140.47 174.14,140.47 175.83,142.17 175.83,146.01 176.85,147.02 176.85,147.48 177.22,147.85
  IN1 w0.114: v3(259.4,167) 257.1,167 247.69,157.6 246,157.6 245.17,156.76 234.08,156.76 228.45,156.76 227,155.31 221.67,155.31 221.06,154.71 217.38,151.02 215.98,151.02 215.58,150.62 203.74,150.62 203.34,150.23 194.44,150.23 194.04,150.62 187.66,150.62 187.14,150.1 179.48,150.1 177.22,147.85
  BOTTOM w0.089: v3(173.03,141.08) 173.27,140.84 UH1.G31
  BOTTOM w0.102: v3(259.4,167) 259.52,167.12 261.09,167.12 262.22,168.25 262.22,176.61 266.68,181.07 267.36,181.07 268.75,182.47 268.75,184.5 275.85,191.59 275.85,192.73 275.96,192.84 JMINI1.38
USBP5-: length 136.5
  IN1 w0.089: 177.06,148.01 177.05,148 177.05,147.99 177.05,147.98 177.01,147.94 177,147.92 176.65,147.56 176.65,147.11 175.63,146.09 175.63,142.25 174.06,140.68 173.45,140.68 173.36,140.77 173.36,140.89 173.54,141.08 v3(173.62,141.08)
  IN1 w0.114: 177.06,148.01 179.38,150.33 187.04,150.33 187.56,150.85 194.14,150.85 194.53,150.46 203.25,150.46 203.64,150.85 215.49,150.85 215.89,151.25 217.29,151.25 219.56,153.53 221.57,155.54 226.91,155.54 228.36,156.99 231.59,156.99 231.59,156.99 234.18,156.99 245.07,156.99 245.91,157.83 247.6,157.83 257,167.23 259.04,167.23 v3(259.4,167.58)
  BOTTOM w0.089: UH1.F31 173.87,140.83 v3(173.62,141.08)
  BOTTOM w0.102: JMINI1.36 275.16,192.83 275.28,192.7 275.53,192.7 275.63,192.6 275.63,191.68 268.54,184.58 268.54,182.55 267.27,181.28 266.59,181.28 262.01,176.7 262.01,168.34 261.01,167.33 259.65,167.33 v3(259.4,167.58)
USBP6+: length 74.9
  TOP w0.102: v3(136.09,162.68) 136.29,162.89 136.29,163.16 135.91,163.55 L99.4 135.91,164.36 R1672.2
  IN4 w0.089: 175.62,148.35 175.62,148.33 175.63,148.32 175.63,142.66 174.64,141.67 172.23,141.67 172.05,141.5 172.05,141.28 v3(171.86,141.09)
  IN4 w0.114: 175.62,148.35 175.62,148.69 176.81,149.88 176.81,156.89 176.3,157.39 176.3,157.59 176.01,157.88 174.85,157.88 174.25,157.28 171.19,157.28 170.11,158.37 162.79,158.37 161.76,159.39 156.32,159.39 154.66,161.05 151.99,161.05 151.74,161.31 145.66,161.31 145.41,161.55 145.41,162.4 145.3,162.51 144.95,162.51 144.84,162.4 144.84,161.55 144.59,161.31 143.88,161.31 143.62,161.57 143.62,162.39 143.49,162.51 141.66,162.51 141.53,162.39 141.53,161.46 141.27,161.2 140.63,161.2 140.37,161.46 140.37,162.4 140.26,162.51 139.92,162.51 139.8,162.4 139.8,161.45 139.55,161.2 139.02,161.2 138.77,161.45 138.77,162.4 138.66,162.51 138.32,162.51 138.2,162.4 138.2,161.46 137.94,161.2 136.48,161.2 136.21,161.46 136.21,162.55 136.22,162.55 v3(136.09,162.68)
  BOTTOM w0.089: UH1.L31 171.86,140.97 v3(171.86,141.09)
USBP6-: length 74.9
  TOP w0.102: v3(136.67,162.68) 136.5,162.85 136.5,163.29 136.76,163.55 L99.1 136.76,164.36 R1673.2
  IN4 w0.089: 175.85,148.35 175.85,148.33 175.83,148.32 175.83,142.58 174.72,141.47 172.31,141.47 172.25,141.41 172.25,141.28 v3(172.44,141.09)
  IN4 w0.114: v3(136.67,162.68) 136.44,162.45 136.44,161.56 136.57,161.43 137.85,161.43 137.97,161.56 137.97,162.49 138.22,162.74 138.75,162.74 139,162.49 139,161.55 139.12,161.43 139.46,161.43 139.57,161.55 139.57,162.49 139.82,162.74 140.35,162.74 140.6,162.49 140.6,161.56 140.73,161.43 141.17,161.43 141.3,161.56 141.3,162.48 141.56,162.74 143.59,162.74 143.85,162.48 143.85,161.66 143.98,161.53 144.5,161.53 144.61,161.65 144.61,162.49 144.86,162.74 145.39,162.74 145.64,162.49 145.64,161.65 145.75,161.53 151.83,161.53 152.08,161.28 154.75,161.28 156.41,159.62 161.86,159.62 162.88,158.59 170.2,158.59 171.29,157.51 174.15,157.51 174.75,158.11 176.11,158.11 176.53,157.69 176.53,157.49 177.04,156.98 177.04,149.79 175.85,148.59 175.85,148.35
  BOTTOM w0.089: UH1.K31 172.44,140.95 v3(172.44,141.09)
USBP6_R_D+: length 5.1
  TOP w0.102: R1672.1 135.91,165.57 L99.3 135.91,166.29 136.23,166.61 136.23,166.68 135.97,166.95 135.3,166.95 135.07,167.19 135.07,167.37 v3(134.86,167.57)
  BOTTOM w0.102: JDOCK1.66 134.84,168.2 135.05,167.99 135.05,167.76 v3(134.86,167.57)
USBP6_R_D-: length 5.1
  TOP w0.102: R1673.1 136.76,165.57 L99.2 136.76,166.29 136.44,166.61 136.44,166.8 v4(136.25,166.99) 136.08,167.16 135.39,167.16 135.28,167.27 135.28,167.4 v3(135.45,167.57)
  BOTTOM w0.102: v3(135.45,167.57) 135.26,167.76 135.26,168.12 135.34,168.2 JDOCK1.68
USBP7+: length 207.7
  TOP w0.102: v3(71.27,154.3) 71.46,154.11 71.46,153.89 68.29,150.72 67.25,150.72 67.24,150.74 66.64,150.74 66.62,150.72 66.42,150.72 59.48,143.78 59.48,141.36 56.76,138.64 56.76,138.46 53.7,135.39 53.7,125.91 49.01,121.23 49.01,97.31 48.91,97.21 48.91,95.75 48.77,95.6 JUSH1.18
  IN4 w0.089: 176.75,145.21 176.53,144.99 176.53,142.55 174.69,140.7 173.38,140.7 173.22,140.54 173.22,140.28 v3(173.03,140.1)
  IN4 w0.114: 176.75,145.21 176.75,147.98 177.57,148.8 177.57,157.15 177.03,157.69 177.03,157.89 176.37,158.56 176.37,158.65 175.85,159.17 175.03,159.17 173.9,158.04 171.74,158.04 170.18,159.6 162.96,159.6 162.45,160.11 157.06,160.11 155.26,161.91 152.28,161.91 152.15,162.03 147.31,162.03 146.1,163.24 133.8,163.24 133.3,163.74 129.81,163.74 129.06,164.5 126.03,164.5 124.91,163.38 123.7,163.38 121.79,161.47 118.25,161.47 115.75,158.97 107.97,158.97 100.93,151.93 91.54,151.93 89.88,153.59 83.83,153.59 83.18,154.24 76.47,154.24 75.83,153.6 71.76,153.6 71.46,153.89 71.46,154.1 v3(71.27,154.3)
  BOTTOM w0.089: v3(173.03,140.1) 173.03,139.97 UH1.H29
USBP7-: length 207.7
  TOP w0.102: v3(71.85,154.27) 71.85,154.27 71.67,154.08 71.67,153.8 68.38,150.51 v4(66.93,150.51) 66.51,150.51 59.69,143.69 59.69,141.28 56.97,138.55 56.97,138.37 53.91,135.31 53.91,125.83 49.22,121.14 49.22,97.22 49.12,97.12 49.12,95.75 49.27,95.6 JUSH1.19
  IN4 w0.089: 176.98,145.15 176.73,144.91 176.73,142.46 174.77,140.5 173.47,140.5 173.42,140.45 173.42,140.36 v3(173.68,140.1)
  IN4 w0.114: v3(71.85,154.27) 71.85,154.27 71.69,154.11 71.69,153.98 71.85,153.83 75.73,153.83 76.38,154.47 83.28,154.47 83.93,153.82 89.97,153.82 91.63,152.16 100.84,152.16 107.88,159.2 115.66,159.2 118.16,161.7 121.7,161.7 123.6,163.6 124.81,163.6 125.93,164.72 129.15,164.72 129.91,163.97 133.4,163.97 133.9,163.47 146.2,163.47 147.4,162.26 152.25,162.26 152.37,162.14 155.35,162.14 157.15,160.34 162.54,160.34 163.06,159.83 170.28,159.83 171.83,158.27 173.81,158.27 174.93,159.39 175.95,159.39 176.6,158.75 176.6,158.65 177.26,157.99 177.26,157.79 177.8,157.24 177.8,148.71 176.98,147.88 176.98,145.15
  BOTTOM w0.089: UH1.G29 173.68,140.02 v3(173.68,140.1)
USBP8+: length 116.4
  IN1 w0.114: v3(274.84,168.46) 274.98,168.32 274.98,168.17 274.84,168.03 271.56,168.03 271.01,167.49 270.72,167.2 269.01,167.2 265.02,163.21 264.32,163.21 262.21,161.09 262.21,160.13 259.46,157.38 255.69,157.38 254.71,156.4 251.99,156.4 249.69,154.1 248.53,154.1 248.2,153.77 247.96,153.53 243.25,153.53 242.69,154.1 233.48,154.1 229.01,149.63 220.89,149.63 217.55,146.29 193.93,146.29 193.12,145.49 187.34,145.49 186.22,144.36 183.22,144.36 182.01,143.15 180.01,143.15 179.94,143.09 179.93,143.09 179.05,142.2 177.59,142.2 176.86,141.48 176.86,140.99 v3(176.72,140.85)
  BOTTOM w0.089: UH1.C32 174.98,140.92 175.45,140.92 175.68,140.7 176.57,140.7 v3(176.72,140.85)
  BOTTOM w0.102: JMINI3.38 275.3,167.75 275.08,167.97 275.08,168.21 v3(274.84,168.46)
USBP8-: length 116.5
  IN1 w0.114: v3(275.43,168.46) 275.21,168.24 275.21,168.07 274.94,167.8 271.65,167.8 271.24,167.39 270.82,166.97 269.1,166.97 265.12,162.98 264.42,162.98 262.43,161 262.43,160.03 259.55,157.15 255.79,157.15 254.8,156.17 252.09,156.17 249.79,153.87 248.62,153.87 248.42,153.67 248.06,153.3 243.16,153.3 242.59,153.87 233.57,153.87 229.11,149.41 220.98,149.41 217.64,146.07 194.03,146.07 193.22,145.26 187.43,145.26 186.31,144.14 183.32,144.14 182.11,142.93 180.1,142.93 180.04,142.86 180.02,142.86 179.14,141.98 177.68,141.98 177.09,141.39 177.09,141.06 v3(177.3,140.85)
  BOTTOM w0.089: UH1.A32 175.91,140.9 176.28,140.9 176.37,140.99 176.37,141.17 176.48,141.28 176.85,141.28 177.28,140.85 v3(177.3,140.85)
  BOTTOM w0.102: v3(275.43,168.46) 275.29,168.32 275.29,168.05 275.39,167.96 276.18,167.96 276.29,168.07 276.29,168.36 276.48,168.55 JMINI3.36
USBP9+: length 228.8
  IN4 w0.114: v3(178.34,140.96) 178.72,141.33 178.72,142.24 177.64,143.32 177.64,147.21 178.84,148.42 178.84,156.9 177.75,157.99 177.75,158.19 177.07,158.87 177.07,158.97 176.15,159.89 174.73,159.89 174.28,159.44 171.99,159.44 171.11,160.32 163.26,160.32 161.13,162.45 157.74,162.45 157.55,162.26 156.24,162.26 155.48,163.03 147.33,163.03 146.4,163.96 134.1,163.96 131.61,166.45 126.27,166.45 125.95,166.77 124.49,166.77 122.59,164.87 122.59,164.81 121.57,163.78 119.53,163.78 115.44,159.69 107.67,159.69 100.63,152.65 91.84,152.65 90.18,154.31 84.15,154.31 83.49,154.97 76.17,154.97 76,154.79 69.88,154.79 69.41,154.31 60.51,154.31 59.77,155.05 58.67,155.05 58.67,155.05 58.07,155.05 54.8,155.05 50.89,158.96 50.89,160.51 49.01,162.38 46.72,162.38 40.91,168.2 36.89,168.2 35.28,169.81 31.66,169.81 26.89,174.58 26.89,186.91 26.24,187.56 25.02,187.56 v3(24.66,187.2)
  BOTTOM w0.089: 177.09,140.46 176.91,140.46 176.91,140.46 176.03,140.46 175.97,140.51 175.67,140.51 175.45,140.3 175,140.3 UH1.C30
  BOTTOM w0.102: v3(178.34,140.96) 178.31,140.96 177.81,140.46 177.09,140.46 ; JIO1.32 7.19,184.25 7.33,184.39 10.74,184.39 13.73,187.39 24.48,187.39 v3(24.66,187.2)
USBP9-: length 228.9
  IN4 w0.114: v3(24.66,187.79) 26.33,187.79 27.12,187 27.12,174.68 31.75,170.04 35.37,170.04 36.98,168.43 41,168.43 46.82,162.61 49.11,162.61 51.12,160.6 51.12,159.06 54.9,155.28 57.97,155.28 58.57,155.28 59.87,155.28 60.6,154.54 69.31,154.54 69.79,155.02 75.9,155.02 76.08,155.2 83.59,155.2 84.24,154.54 90.27,154.54 91.93,152.88 100.54,152.88 107.58,159.92 115.35,159.92 119.44,164.01 121.47,164.01 122.37,164.91 122.37,164.96 124.4,167 126.05,167 126.37,166.68 131.71,166.68 134.2,164.19 146.5,164.19 147.43,163.25 155.57,163.25 156.34,162.49 157.45,162.49 157.64,162.68 161.23,162.68 163.36,160.55 171.2,160.55 172.09,159.67 174.18,159.67 174.63,160.12 176.25,160.12 177.3,159.06 177.3,158.97 177.98,158.29 177.98,158.09 179.07,157 179.07,148.33 177.87,147.12 177.87,143.42 178.94,142.34 v3(178.94,140.96)
  BOTTOM w0.089: 177.09,140.25 177.08,140.25 177.07,140.26 176.99,140.26 176.99,140.26 175.87,140.26 UH1.A30
  BOTTOM w0.102: v3(24.66,187.79) 24.48,187.6 13.64,187.6 10.65,184.61 7.33,184.61 7.19,184.75 JIO1.34 ; 177.09,140.25 177.92,140.25 178.16,140.49 178.93,140.49 179.05,140.6 179.05,140.86 v3(178.94,140.96)
USBP10+: length 183.1
  TOP w0.102: JEXP1.5 227.9,31.15 225.78,29.03 222.09,29.03 220.88,30.24 219.86,30.24 218.4,31.7 217.76,31.7 217.57,31.5 v3(217.57,30.91)
  IN4 w0.114: v3(179.58,139.25) 179.58,138.1 180.72,136.96 180.72,131.19 177.16,127.63 177.16,125.21 179.26,123.11 179.26,122.29 178.18,121.21 178.18,118.99 179.99,117.19 179.99,113 183.65,109.33 183.65,107.89 183.89,107.65 183.89,102.8 184.74,101.95 184.74,97.72 185.78,96.68 185.78,90.65 185.29,90.16 185.29,82.35 183.02,80.09 181.77,78.83 181.06,78.83 180.06,77.83 180.06,76.65 174.92,71.52 174.92,60 174.35,59.42 174.35,55.87 173.74,55.27 173.74,51.53 173.25,51.04 173.25,42.11 173.73,41.64 174.44,41.64 175.18,40.89 175.18,35.81 178.24,32.76 193.8,32.76 196.22,30.34 210.57,30.34 211.74,31.51 217.71,31.51 217.83,31.39 217.83,31.18 v3(217.57,30.91)
  BOTTOM w0.089: 177.55,139.8 177.53,139.8 177.53,139.8 177.46,139.8 177.46,139.81 176.21,139.81 176.08,139.68 175.64,139.68 175.47,139.51 175.19,139.51 174.91,139.79 UH1.D29
  BOTTOM w0.102: 177.55,139.8 179.03,139.8 v3(179.58,139.25)
USBP10-: length 183
  TOP w0.102: JEXP1.3 228.97,30.65 228.68,30.94 227.99,30.94 225.87,28.82 222,28.82 220.79,30.03 219.77,30.03 218.31,31.49 217.85,31.49 217.78,31.41 217.78,31.29 v3(218.15,30.91)
  IN4 w0.114: v3(218.15,30.91) 218.06,31 218.06,31.49 217.81,31.74 211.64,31.74 210.47,30.57 196.31,30.57 193.9,32.98 178.33,32.98 175.41,35.91 175.41,40.99 174.53,41.87 173.82,41.87 173.48,42.21 173.48,50.94 173.97,51.43 173.97,55.17 174.57,55.77 174.57,59.32 175.15,59.9 175.15,71.42 180.29,76.56 180.29,77.74 181.15,78.6 181.86,78.6 183.25,79.99 183.25,79.99 185.52,82.26 185.52,90.06 186.01,90.56 186.01,96.77 184.97,97.81 184.97,102.04 184.12,102.89 184.12,107.74 183.88,107.99 183.88,109.43 180.21,113.09 180.21,117.28 178.41,119.08 178.41,121.12 179.49,122.19 179.49,123.21 177.39,125.31 177.39,127.53 180.95,131.09 180.95,137.05 179.81,138.2 179.81,138.89 v3(180.16,139.25)
  BOTTOM w0.089: UH1.B29 175.35,139.89 175.45,139.99 175.58,139.99 175.7,139.88 176,139.88 176.13,140.01 177.55,140.01
  BOTTOM w0.102: 177.55,140.01 179.12,140.01 179.43,139.69 179.96,139.69 180.16,139.49 v3(180.16,139.25)
USBP12+: length 80.9
  IN1 w0.102: v3(173.68,139.12) 173.55,139.26 173.55,139.41 173.64,139.5 174.37,139.5 174.8,139.93 175.02,140.15 175.03,140.15 175.04,140.16
  IN1 w0.114: 175.04,140.16 175.39,140.51 175.39,140.83 176.44,141.88 176.44,142.84 177.1,143.5 177.1,146.03 177.67,146.61 177.67,147.2 179.48,149.01 189.59,149.01 190.04,149.45 203.59,149.45 204.04,149.9 217.28,149.9 221.95,154.57 227.83,154.57 228.59,155.34 228.59,155.59 v3(228.94,155.95)
  BOTTOM w0.089: UH1.F26 173.64,138.86 173.64,139.08 v3(173.68,139.12)
  BOTTOM w0.102: v3(228.94,155.95) 228.57,156.32 228.57,159.07 227.67,159.97 227.67,161.59 228.67,162.59 228.67,166.49 229.13,166.96 229.8,166.96 229.93,166.82 229.93,166.56 229.8,166.42 229.45,166.42 229.34,166.32 L10.4 229.34,165.43 R427.1
USBP12-: length 80.9
  IN1 w0.102: v3(173.04,139.12) 173.33,139.41 173.33,139.5 173.55,139.72 174.28,139.72 174.65,140.09 174.86,140.3 174.86,140.31 174.88,140.33
  IN1 w0.114: 174.88,140.33 175.16,140.6 175.16,140.92 176.21,141.98 176.21,142.93 176.87,143.59 176.87,146.13 177.45,146.7 177.45,147.29 179.39,149.23 189.5,149.23 189.94,149.68 203.49,149.68 203.81,150 203.94,150.13 217.19,150.13 221.86,154.8 227.73,154.8 228.36,155.43 v3(228.36,155.95)
  BOTTOM w0.089: UH1.G26 173.27,138.89 v3(173.04,139.12)
  BOTTOM w0.102: v3(228.36,155.95) 228.36,158.98 227.46,159.88 227.46,161.68 228.45,162.67 228.45,166.57 229.05,167.17 229.88,167.17 230.14,166.91 L10.1 230.14,165.43 R428.1
USBP12_D+: length 3.4
  BOTTOM w0.102: L10.3 229.34,163.5 229.54,163.3 v4(229.54,162.61) 229.54,161.84 229.21,161.51 JCAM1.2
USBP12_D-: length 3.5
  BOTTOM w0.102: JCAM1.3 230.21,161.64 229.75,162.1 229.75,162.32 229.77,162.34 229.77,162.91 229.75,162.93 229.75,163.18 230.14,163.57 L10.2
USBP13+: length 40.8
  IN1 w0.089: 176.6,140.01 176.58,140.01 176.57,139.99 175.63,139.99 175.26,139.63 175.26,139.22 174.61,138.56 174.2,138.56 174.02,138.75 173.37,138.75 173.17,138.55 173.17,138.23 v3(173.04,138.1)
  IN1 w0.114: v3(187.74,139.76) 187.38,139.4 186.8,139.4 186.69,139.51 186.69,140.45 186.82,140.58 188.82,140.58 189.08,140.84 189.08,141.45 188.82,141.72 185.87,141.72 185.61,141.45 185.61,139.56 185.55,139.5 185.1,139.5 184.99,139.62 184.99,141.46 184.74,141.71 184.21,141.71 183.96,141.46 183.96,139.83 183.83,139.7 183.52,139.7 183.39,139.83 183.39,141.46 183.14,141.71 182.61,141.71 182.36,141.46 182.36,140.12 182.25,140.01 176.6,140.01
  BOTTOM w0.089: v3(173.04,138.1) 173.27,137.87 UH1.G24
  BOTTOM w0.102: v3(187.74,139.76) 187.98,139.52 189.01,139.52 189.63,138.9 189.63,136.07 189.8,135.9 190.79,135.9 190.94,136.05 190.94,136.34 190.85,136.43 190.64,136.43 190.53,136.53 L11.1 190.53,137.5 R432.1
USBP13-: length 40.5
  IN1 w0.089: 176.6,139.78 176.59,139.78 176.58,139.79 175.71,139.79 175.46,139.54 175.46,139.13 174.69,138.36 174.12,138.36 173.93,138.54 173.45,138.54 173.37,138.46 173.37,138.28 173.55,138.1 v3(173.67,138.1)
  IN1 w0.114: v3(187.74,139.17) 186.71,139.17 186.46,139.42 186.46,140.55 186.72,140.81 188.72,140.81 188.85,140.93 188.85,141.36 188.72,141.49 185.97,141.49 185.84,141.36 185.84,139.47 185.64,139.27 185.01,139.27 184.76,139.52 184.76,141.36 184.65,141.48 184.3,141.48 184.19,141.36 184.19,139.73 183.93,139.47 183.42,139.47 183.16,139.73 183.16,141.36 183.05,141.48 182.7,141.48 182.59,141.36 182.59,140.03 182.34,139.78 176.6,139.78
  BOTTOM w0.089: v3(173.67,138.1) 173.87,137.91 UH1.F24
  BOTTOM w0.102: v3(187.74,139.17) 187.88,139.31 188.92,139.31 189.41,138.82 189.41,135.98 189.71,135.69 190.87,135.69 191.15,135.96 191.15,136.3 191.38,136.53 L11.4 191.38,137.5 R433.1
USBP13_D+: length 13.5
  BOTTOM w0.102: R432.2 190.53,138.45 L11.2 190.53,139.29 190.87,139.63 190.87,140.85 190.28,141.44 189.87,141.44 189.77,141.34 D86.2 189.18,140.58 188.26,141.51 v4(187.75,141.51) 186.51,141.51 186.5,141.49 185.95,141.49 185.93,141.51 182.87,141.51 182.48,141.11 JTCH1.5
USBP13_D-: length 13.8
  BOTTOM w0.102: JTCH1.4 182.48,142.11 182.87,141.72 v4(186.22,141.72) 187.45,141.72 187.47,141.74 188.02,141.74 188.04,141.72 188.29,141.72 189.08,142.51 D86.3 189.77,141.75 189.87,141.65 190.37,141.65 191.09,140.93 191.09,139.66 191.38,139.37 L11.3 191.38,138.45 R433.2
USBRBIAS: length 3
  TOP w0.089: v1(171.79,138.75) v3(171.79,138.14) 172.45,137.48 RH187.1
  BOTTOM w0.089: UH1.K24 171.79,137.94 v3(171.79,138.14) 171.79,138.35 UH1.K26
USH_DET#: length 258.1
  TOP w0.102: v3(74.07,94.77) 74.72,94.13 74.72,92.55 72.58,90.41 62.42,90.41 v1(61.6,89.59) 60.82,88.81 48.78,88.81 46.55,91.05 42.67,91.05 40.27,93.46 JUSH1.1 ; v3(185.15,132.12) 184.66,131.63 RH202.1
  IN2 w0.089: v3(173.68,132.66) 173.68,132.33 173.42,132.07 171.9,132.07 171.71,131.88 171.71,131.26 171.78,131.19 171.78,128.84 172.53,128.09 172.53,126.69 172.6,126.62
  IN2 w0.127: 172.6,126.62 173.39,125.83 174.49,125.83 174.9,125.43 175.7,125.43 175.9,125.23 175.9,121.9 174.94,120.95 174.94,120.07 175.2,119.81 175.2,119.2 173.04,117.03 173.04,115.33 172,114.29 170.63,114.29 168.72,112.39 163.55,112.39 158.05,106.88 158.05,103.39 156.28,101.62 156.28,94.41 v3(153.54,91.68)
  IN3 w0.089: 178.75,131 176.35,131 174.69,132.66 v3(173.68,132.66)
  IN3 w0.127: v3(74.07,94.77) 77.2,94.77 77.4,94.96 80.39,94.96 80.78,94.57 85.86,94.57 86.27,94.16 90.24,94.16 92.05,92.34 92.05,80.42 91.31,79.68 91.31,66.47 92.81,64.98 107.37,64.98 114.19,58.16 146.14,58.16 156.26,68.28 156.26,77.56 153.74,80.09 153.74,91.49 v3(153.54,91.68) ; 178.75,131 178.79,131 179.39,131.6 182.5,131.6 183.53,132.63 184.65,132.63 v3(185.15,132.12)
  BOTTOM w0.089: UH1.F13 173.68,132.95 v3(173.68,132.66)
USH_PWR_ON: length 47.6
  TOP w0.102: U46.A18 189.12,74.11 189.28,74.27 v3(189.83,74.27) ; R1620.1 229.44,66.54 v2(228.67,66.54) 227.65,66.54 227.26,66.93 v3(227.26,67.36)
  IN1 w0.102: v3(227.26,67.36) 226.47,68.15 218.64,68.15 218.14,68.66 214.78,68.66 214.2,68.07 212.96,68.07 212.73,67.85 210.28,67.85 208.24,69.89 202.62,69.89 201.14,68.42 197.08,68.42 191.23,74.27 v3(189.83,74.27)
USH_PWR_STATE#: length 195.4
  TOP w0.102: R1640.1 41.72,96 42.27,95.46 JUSH1.5 42.27,92.1 42.81,91.56 47.02,91.56 48.49,90.08 56.11,90.08 v1(56.57,90.55) 56.9,90.87 72.39,90.87 73.22,91.7 v3(73.22,93.17) ; U46.A34 179.62,71.06 179.11,70.55 v3(179.11,70.54)
  IN3 w0.127: v3(179.11,70.54) 178.63,70.54 177.61,69.52 177.61,67.85 177.06,67.3 177.06,66.13 177.36,65.84 177.36,64.61 176.81,64.06 176.81,60.09 175.17,58.45 166.47,58.45 164.75,56.72 155.79,56.72 150.05,50.98 115.79,50.98 106.11,60.66 90.89,60.66 88.32,63.23 88.32,79.59 90.15,81.42 90.15,88.48 85.33,93.3 80.26,93.3 79.86,93.69 77.92,93.69 77.24,93 73.38,93 v3(73.22,93.17)
USH_SMBCLK: length 191.3
  TOP w0.102: v3(47.81,93.59) 47.63,93.77 47.63,94.02 47.77,94.16 JUSH1.16 47.77,95.76 47.91,95.9 47.91,96.78 R589.2 ; U51.A50 v3(203.46,82.04)
  BOTTOM w0.102: v3(47.81,93.59) 47.63,93.41 47.63,93.21 47.78,93.06 49.88,93.06 51.6,94.77 55.12,94.77 56.59,93.3 59.51,93.3 62.93,89.88 82.01,89.88 87.44,84.45 87.44,71.94 92.78,66.6 165.55,66.6 166.79,67.84 v3(167.6,67.84) 168.24,67.84 174.47,74.08 174.47,77.22 176.81,79.56 195.66,79.56 196.01,79.2 197.57,79.2 198.6,80.23 198.6,80.77 199.17,81.33 204.08,81.33 204.28,81.53 204.28,81.84 204.08,82.04 v3(203.46,82.04)
USH_SMBDAT: length 192.7
  TOP w0.102: U51.B53 205.46,82.29 v3(205.69,82.52) ; v3(47.22,93.59) 47.4,93.77 47.4,94.01 47.27,94.14 JUSH1.15 47.27,95.6 47.68,96.02 47.68,96.7 R585.2
  BOTTOM w0.102: v3(47.22,93.59) 47.4,93.41 47.4,93.12 47.69,92.83 49.98,92.83 51.69,94.54 55.02,94.54 56.5,93.07 59.42,93.07 62.84,89.65 81.91,89.65 87.21,84.35 87.21,71.84 92.68,66.37 165.91,66.37 v3(166.31,66.77) 166.96,67.41 168.14,67.41 168.4,67.68 168.44,67.71 174.7,73.98 174.7,77.13 176.9,79.33 195.56,79.33 195.92,78.97 197.66,78.97 198.83,80.14 198.83,80.67 199.26,81.1 204.18,81.1 204.51,81.43 204.51,81.81 205.21,82.52 v3(205.69,82.52)
V_SYS: length 274.4
  TOP w0.102: R392.2 197.46,78.35 v3(197.21,78.1)
  TOP w0.254: v3(48.83,163.81) PU700.7
  IN3 w0.127: v3(47.56,133.21) 48.83,131.94 48.83,129.78 52.6,126.01 52.6,96.26 54.92,93.94 73.39,93.94 73.83,93.51 77.02,93.51 77.71,94.2 80.07,94.2 80.47,93.81 85.54,93.81 90.66,88.69 90.66,81.21 88.82,79.38 88.82,63.44 91.1,61.17 106.32,61.17 116,51.49 149.84,51.49 155.58,57.23 158.33,57.23 159.89,58.79 164.57,58.79 164.98,58.38 165.69,58.38 166.97,59.67 173.39,59.67 175.64,61.92 175.64,70.6 180.03,74.98 181.1,74.98 182.59,76.47 186.06,76.47 186.46,76.86 194.86,76.86 196.09,78.1 v3(197.21,78.1)
  BOTTOM w0.102: v3(48.83,163.81) 48.53,163.81 48.28,163.57 v1(48.28,163.25) 48.28,160.61 49.34,159.55 49.34,152.2 44.64,147.5 44.64,143.25 45.3,142.59 45.3,138.9 47.75,136.45 47.75,133.4 v3(47.56,133.21)
  BOTTOM w0.254: v3(48.83,163.81) 49.01,163.63 49.01,163.13 49.21,162.93 PC716.2
V_SYS_R: length 10.7
  TOP w0.102: R392.1 198.77,78.93 v3(199.14,79.3) ; U51.B61 205.81,78.29 v3(206.31,78.79)
  BOTTOM w0.102: v3(199.14,79.3) 199.14,79.11 199.52,78.73 v1(200.7,78.73) 201.33,78.73 201.64,79.03 204.88,79.03 205.18,79.34 205.94,79.34 206.31,78.97 v3(206.31,78.79)
VCI_IN3#: length 15.1
  TOP w0.102: U51.B68 204.74,74.79 204.38,74.44 v3(204.38,74.23) ; v3(200.08,69.48) 198.72,69.48 197.83,68.6 197.83,66.86 198.21,66.48 RP15.1
  IN1 w0.102: v3(204.38,74.23) 204.37,74.21 204.37,71.05 203.71,70.39 202.4,70.39 201.5,69.48 v3(200.08,69.48)
  BOTTOM w0.102: v3(200.08,69.48) v1(200.08,70.23)
VCORE_NTC: length 20.2
  IN2 w0.254: v3(128.96,148.59) 128.96,148.5 129.36,148.1 129.98,148.1 135.18,142.9 135.18,142.56 135.78,141.96 v3(135.78,136.96)
  BOTTOM w0.254: v3(128.96,148.59) PR528.1 PR525.1 ; PH500.1 v1(135.83,134.61) 135.83,136.96 v3(135.78,136.96)
VCORE_VDDP: length 1.6
  BOTTOM w0.102: v1(122.1,140.55) 122.34,140.55 PR520.1
VCP: length 328.8
  TOP w0.102: v3(211.35,72.19) 211.43,72.26 U51.A12
  TOP w0.254: PR728.1 232.22,144.2 v3(232.6,143.82)
  IN1 w0.102: v3(232.6,143.82) 233.11,143.31 236.46,143.31 238.06,144.91 249.91,144.91 v3(250.34,144.48)
  IN2 w0.254: v3(232.6,143.82) 232.21,143.42 222.11,143.42 221.55,142.87 217.11,142.87 215.27,141.02 208.39,141.02 202.06,147.36 201.04,147.36 200.56,147.84 200.56,149.04 196.98,152.62 196.98,153.83 193.25,157.56 189.52,157.56 187.68,159.4 184.35,159.4 173.52,170.23 157.14,170.23 155.46,168.55 152.88,168.55 151.5,167.17 150.77,167.17 149.04,165.45 146.63,165.45 144.58,163.4 141.48,163.4 139.74,161.66 133.05,161.66 131.21,159.82 130.37,159.82 129.95,159.4 125.9,159.4 124.93,160.37 116.78,160.37 115.46,159.04 106.86,159.04 103.41,162.49 96.74,162.49 95.22,164.01 87.76,164.01 87.26,164.51 83.9,164.51 83.08,163.69 79.26,163.69 75.79,167.16 66.68,167.16 66.39,166.87 56.38,166.87 56.28,166.97 53.09,166.97 52.7,167.36 51.04,167.36 49.85,166.17 v3(46.42,166.17)
  IN3 w0.127: v3(250.34,144.48) 249.3,143.44 249.3,140.84 245.92,137.46 245.92,136.18 242,132.26 242,122.68 235.47,116.14 233.28,116.14 231.31,114.17 231.31,107.45 228.96,105.1 228.96,90.32 227.42,88.79 227.42,79.96 224.54,77.08 223.86,77.08 219.61,72.82 218.95,72.82 218.44,72.32 211.48,72.32 v3(211.35,72.19)
  BOTTOM w0.102: v3(232.6,143.82) v1(231.21,143.82)
  BOTTOM w0.254: PR710.1 46.68,165.9 v3(46.42,166.17)
VCT_LAN_R1: length 2.1
  TOP w0.102: U31.6 243.88,163.68 244.16,163.4 244.57,163.4 R152.2
VGA_ID: length 13.2
  TOP w0.102: U46.B59 185.37,63.55 185.29,63.62 185.29,64.06 v3(184.78,64.57) ; R800.2 R803.1 185.85,56.17 v1(185.99,56.31) 186.11,56.43 186.11,58.23 v3(185.55,58.79)
  IN4 w0.102: v3(185.55,58.79) 185.55,59.17 184.98,59.74 184.98,60.63 185.36,61.01 185.36,64.4 185.19,64.57 v3(184.78,64.57)
VGA_THERMDN: length 276.8
  TOP w0.254: U51.A15 212.93,73.07 213.43,72.57 214.5,72.57 v3(215.59,71.49) C287.1
  IN1 w0.254: v3(92.08,50.72) 92.7,50.72 93.47,51.49 93.47,53.01 90.86,55.63 90.86,80.54 82.83,88.57 79.82,88.57 79.14,89.26 59.2,89.26 57.75,90.71 53.63,90.71 48.68,95.65 48.68,121.36 57.47,130.15 57.47,132.13 58.76,133.43 v3(58.76,134.65)
  BOTTOM w0.089: v3(58.76,134.65) 58.76,134.4 59.31,133.85 60.93,133.85 UV1.T2
  BOTTOM w0.254: v3(92.08,50.72) 92.11,50.75 92.6,50.75 97.45,45.9 147.75,45.9 154.1,39.55 167.66,39.55 174.14,46.04 174.14,46.86 179.47,52.19 184.11,52.19 184.74,52.82 187.24,52.82 191.94,57.52 192.62,57.52 193.44,58.35 210.02,58.35 215.58,63.91 v1(215.58,64.44) 215.58,69.33 215.59,69.33 v3(215.59,71.49)
VGA_THERMDP: length 277.7
  TOP w0.254: C287.2 215.59,69.84 v3(215.08,69.33) ; U51.B16 213.18,74.55 v3(213.43,74.79)
  IN1 w0.254: v3(58.19,134.65) 58.25,134.59 58.25,133.64 56.96,132.34 56.96,130.36 48.17,121.57 48.17,95.44 53.41,90.2 57.54,90.2 58.99,88.75 78.93,88.75 79.61,88.06 82.62,88.06 90.35,80.33 90.35,55.42 92.96,52.8 92.96,51.7 92.57,51.3 v3(92.08,51.3)
  BOTTOM w0.089: v3(58.19,134.65) 59.21,133.63 60.69,133.63 60.83,133.49 61.15,133.49 61.46,133.8 UV1.T4
  BOTTOM w0.254: v3(213.43,74.79) 213.43,74.73 214.06,74.09 214.06,73.21 215.08,72.19 v3(215.08,69.33) v1(215.08,66.6) 215.08,64.13 209.8,58.85 193.23,58.85 192.41,58.03 191.73,58.03 187.03,53.33 184.53,53.33 183.9,52.7 179.26,52.7 173.64,47.07 173.64,46.25 167.45,40.06 154.31,40.06 147.96,46.41 97.66,46.41 92.81,51.26 92.11,51.26 v3(92.08,51.3)
VID0: length 5.8
  TOP w0.102: PR612.2 18.18,152.83 17.57,153.44 v1(16.61,153.44)
  TOP w0.203: 19.81,150.74 20.05,150.51 PU600.31
  TOP w0.254: PR612.2 18.61,152.45 18.99,152.07 18.99,151.56 19.81,150.74
VID6: length 4.2
  TOP w0.203: 19.64,147.79 19.96,148.11 PU600.37
  TOP w0.254: PR615.1 18.2,146.24 18.91,146.24 v3(19.18,146.51) 19.28,146.61 19.28,147.43 19.64,147.79
VIDALERT_N: length 46.7
  TOP w0.102: v3(122.15,146.4) 121.69,145.94 121.69,145.64 119.28,143.23 112.12,143.23 v1(111.6,142.71) 110.42,141.53 110.42,129.93 109.53,129.04 109.53,123.99 106.11,120.57 106.11,116.58 105.86,116.32 105.86,115.38 RC88.2 RC87.2
  BOTTOM w0.102: PU500.32 122.67,145.09 122.57,145.19 122.57,145.97 v3(122.15,146.4) 121.15,147.39 PR503.1
VIDSCLK: length 70.5
  TOP w0.102: v3(122.98,146.39) 122.41,146.95 121.79,146.95 120.18,145.35 120.18,144.92 119.5,144.24 119.07,144.24 118.63,143.79 v1(114.56,143.79) 111.88,143.79 109.86,141.76 109.86,130.17 108.97,129.28 108.97,124.93 105.15,121.12 v3(105.15,117.38)
  IN1 w0.102: v3(105.15,117.38) 104.85,117.08 104.85,116.07 106.52,114.41 106.52,105.03 108.78,102.76 111.59,102.76 111.95,102.4 111.95,102.18 112.31,101.82 113.83,101.82 113.98,101.97 113.98,102.69 v3(113.47,103.2)
  BOTTOM w0.089: v3(113.47,103.2) 113.94,103.67 JCPU1.AM29
  BOTTOM w0.102: PR504.1 121.34,148.28 122.09,147.53 122.09,147.28 122.98,146.4 v3(122.98,146.39) 123.18,146.18 123.56,146.18 123.7,146.04 PU500.1
VIDSOUT: length 71.9
  TOP w0.102: v3(106.44,116.07) 106.57,115.94 RC90.2 107.05,117.67 107.15,117.77 108.17,117.77 108.29,117.9 108.29,118.15 108.17,118.28 106.8,118.28 106.67,118.4 106.67,118.66 106.8,118.79 108.17,118.79 108.29,118.91 108.29,119.17 108.17,119.29 106.8,119.29 106.67,119.42 106.67,119.67 106.8,119.8 108.17,119.8 108.29,119.93 108.29,120.18 108.17,120.31 107.16,120.31 107.03,120.44 107.03,120.7 107.16,120.83 107.95,120.83 108.08,120.96 108.08,121.75 110.09,123.76 110.09,128.81 110.97,129.7 v1(110.97,140.01) 110.97,141.3 112.35,142.67 119.51,142.67 121.98,145.14 v3(122.15,145.14)
  IN1 w0.102: v3(114.47,103.2) 113.98,103.69 113.98,104.38 113.67,104.7 108.59,104.7 107.63,105.65 107.63,114.87 v3(106.44,116.07)
  BOTTOM w0.102: v3(114.47,103.2) JCPU1.AL28 ; PU500.31 122.59,144.69 v3(122.15,145.14) 122.15,145.14 121.73,145.56 121.73,145.99 121.22,146.5 PR500.1
VLDOIN_1.35V:
  vias: v1(174.11,85.97)
VOL_DOWN#: length 287.6
  TOP w0.102: v3(10.67,145.61) 10.49,145.61 8.03,143.15 8.03,142.39 7.05,141.41 JMDIA1.4 ; R887.2 199.61,81.36 v2(199.4,81.57) 199.32,81.65 v3(199.32,82.73)
  IN3 w0.127: v3(199.32,82.73) 198.87,82.29 195.57,82.29 194.68,81.4 194.68,81.05 193.31,79.68 184.08,79.68 182.75,78.35 180.57,78.35 178.95,76.72 173.15,76.72 156.47,60.05 151.26,60.05 143.47,52.25 116.31,52.25 106.64,61.93 91.84,61.93 90.22,63.55 90.22,80.06 91.16,81 91.16,91.39 88.65,93.91 86.16,93.91 85.75,94.31 80.68,94.31 80.28,94.71 77.5,94.71 77.14,94.35 73.5,94.35 73.35,94.2 55.03,94.2 52.86,96.37 52.86,126.2 49.21,129.85 49.21,132.26 47.82,133.66 46.91,133.66 46.06,134.51 46.06,134.51 45.87,134.7 45.24,134.7 42.23,137.71 38.38,137.71 35.12,140.97 32.72,140.97 31.08,142.61 27.54,142.61 26.52,143.63 20.91,143.63 19.9,142.61 17.07,142.61 14.8,144.88 11.4,144.88 v3(10.67,145.61)
VOL_MUTE#: length 289.9
  TOP w0.102: R884.2 205.49,65 v2(202.48,65) 202.29,65.19 197.2,65.19 194,61.99 193.63,61.99 191.66,60.01 191.66,58.33 192.35,57.64 192.49,57.5 192.49,55.69 191.43,54.64 185.42,54.64 183.03,52.25 175.37,52.25 v3(173.96,50.84) ; v3(8.64,142.67) 7.55,141.59 JMDIA1.3
  IN3 w0.127: v3(173.96,50.84) 172.07,50.84 171.15,49.91 164.42,49.91 163.19,48.68 157.9,48.68 156.01,46.79 113.04,46.79 106.48,53.35 92.77,53.35 91.63,54.48 91.63,54.66 85.01,61.28 85.01,83.87 79.18,89.7 58.31,89.7 57.62,90.39 48.78,90.39 44.52,94.65 44.52,105.2 48.15,108.83 48.15,125.75 41.24,132.66 41.24,134.8 39.41,136.63 36.53,136.63 34.05,139.11 30.82,139.11 29.76,140.17 25.8,140.17 24.97,141 22.81,141 22.13,140.32 16.5,140.32 14.4,142.42 8.89,142.42 v3(8.64,142.67)
VOL_UP#: length 302.6
  TOP w0.102: R888.2 210.38,69.46 210.82,69.02 211.26,69.02 211.86,68.42 211.86,67.38 211.33,66.86 211.33,65.49 210.43,64.59 v2(204.38,64.59) 202.15,64.59 201.78,64.96 197.3,64.96 194.1,61.76 193.73,61.76 191.89,59.92 191.89,58.43 192.51,57.8 192.71,57.6 192.71,55.59 191.53,54.41 185.51,54.41 183.12,52.02 175.73,52.02 v3(173.97,50.26) ; JMDIA1.5 6.55,141.71 v3(7.56,142.72)
  IN3 w0.127: v3(7.56,142.72) 8.11,142.17 14.29,142.17 16.4,140.06 22.23,140.06 22.91,140.74 24.86,140.74 25.69,139.91 29.65,139.91 30.71,138.85 33.94,138.85 36.42,136.38 39.3,136.38 40.98,134.69 40.98,132.55 47.89,125.64 47.89,108.93 44.26,105.3 44.26,94.55 48.67,90.13 57.52,90.13 58.2,89.45 79.08,89.45 84.76,83.76 84.76,61.39 84.76,61.18 91.38,54.56 91.38,54.37 92.66,53.09 106.38,53.09 112.93,46.54 156.11,46.54 158,48.43 163.3,48.43 164.53,49.66 171.25,49.66 171.85,50.26 v3(173.97,50.26)
VR_HOT#: length 2.5
  BOTTOM w0.203: PU500.5 125.3,146.63 v1(125.46,146.79) 125.74,147.07 125.87,147.07 126.48,147.68 PR524.2
VR_ON: length 4.8
  BOTTOM w0.102: v1(121.82,149.62) 121.82,148.61 PR511.2
  BOTTOM w0.203: PU500.2 124.1,146.33 PR511.2
VSEN_VGA: length 37
  TOP w0.203: PU600.12 26.17,147.31 26.48,146.99 26.48,146.79 26.57,146.7
  TOP w0.254: 26.57,146.7 26.57,145.65 26.98,145.24 27.02,145.24 v3(27.12,145.14) 27.43,145.14 PC624.1 27.5,144.47 27.5,142.18 PR640.2 PC612.2 ; PR650.2 47.55,135.16 v3(47.31,134.91)
  IN1 w0.254: v3(27.12,145.14) 27.02,145.24 26.82,145.24 26.44,144.86 26.44,143.87 27.17,143.14 30.86,143.14 32.66,141.34 34.75,141.34 38.43,137.66 41.91,137.66 44.55,135.02 46.14,135.02 46.5,135.37 46.99,135.37 47.31,135.05 v3(47.31,134.91)
  BOTTOM w0.102: v3(27.12,145.14) 26.67,145.14 v1(26.32,145.49)
VSET_5075: length 5.5
  TOP w0.102: U51.A17 216.1,75.04 216.47,74.67 v1(216.47,73.71) 216.47,73.52 217.17,72.82 217.35,72.82 C284.1 R407.1
VSUM+_VGA: length 15.1
  TOP w0.203: PU600.15 26.55,148.51 26.8,148.26
  TOP w0.254: PR651.2 30.1,152.07 31.58,150.59 31.59,150.59 32.47,149.71 PR619.2 33.22,149.7 v1(33.22,148.2) 33.22,147.77 33.1,147.64 PR648.1 PC627.1 30.75,147.75 PC626.1 29.29,147.75 29.08,147.97 28.34,147.97 PR655.1 26.98,148.26 26.8,148.26
