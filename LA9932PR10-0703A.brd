# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_RUN_TPM: length 17.4
  TOP w0.381: C551.1 211.36,115.9 U39.10 ; U39.19 211.36,104.8 C552.1 ; C553.1 v1(214.62,105.78) 214.62,106.49 214.61,106.51 U39.24 ; U39.5 214.61,114.25 214,114.86 214,115.75 214.19,115.94
  TOP w0.508: C550.1 214.25,103.75 v3(213.81,104.19) 214.25,104.64 C553.1 ; C552.1 210.39,104.71 v3(210.19,104.51) ; C45.1 215.33,115.75 v3(214.82,115.24) 214.19,115.88 C44.1 ; v3(210.49,115.67) 210.81,115.99 C551.1
  vias: v3(209.2,115.69) v3(209.81,115.69)
+3.3V_SPI: length 50.5
  TOP w0.305: RH185.2 215.53,130.57 215.19,130.91 213.56,130.91 212.98,131.5 JSPI1.15
  TOP w0.508: v3(226.07,127.24) C746.1 U52.8 ; R3664.1 v3(238.65,131.96) ; R3668.1 v3(225.16,130.67) ; v3(225.3,123.05) 225.16,122.91 R3666.1 ; v3(239.27,124.45) R3665.1 ; U53.8 226.81,121.76 C1216.1 v3(226.07,120.39) ; RH185.2 216.09,130.29 v3(216.47,130.67)
  IN1 w0.508: v3(239.27,124.45) 235.21,120.39 v3(226.07,120.39) ; v3(216.47,130.67) 216.98,131.18 224.65,131.18 v3(225.16,130.67)
  IN4 w0.508: v3(238.65,131.96) 239.27,131.33 v3(239.27,124.45) ; v3(226.07,127.24) 225.16,128.16 v3(225.16,130.67)
  BOTTOM w0.102: v3(226.07,120.39) 227.01,120.39 v1(227.14,120.51)
+3.3V_SUS: length 258.3
  TOP w0.305: U41.17 237.14,62.48 237.43,62.77
  TOP w0.508: v3(222.89,29.96) 222.37,30.48 R732.1 ; 237.43,62.77 237.43,63.74 237.95,64.26 C633.1 237.68,64.73 v3(236.26,64.73) ; v3(220.98,32.69) 221.68,31.99 R731.1
  IN2 w0.508: 222.38,59.17 221.94,58.73 221.94,33.65 v3(220.98,32.69) 220.98,31.87 v3(222.89,29.96)
  IN3 w1.524: 47.21,95.56 48.83,95.56 50.46,93.93 50.46,92.87 51.99,91.34 58.02,91.34 58.7,90.65 79.58,90.65 83.69,86.54 84.1,86.54 85.97,84.67 85.97,61.85 89.73,58.09 92.2,58.09 93.54,56.76 98.24,56.76 99.19,57.71 104.59,57.71 113.93,48.38 155.35,48.38 157.24,50.27 161.53,50.27 163.58,52.31 ; 221.55,61.9 218.45,61.9 217.49,60.95 192.82,60.95 191.2,59.33 191.2,58.79 188.43,56.02 185.55,56.02 181.71,52.19 175.77,52.19 174.63,53.33
  BOTTOM w0.508: v3(236.26,64.73) 236.26,62.98 234.04,60.76 225.87,60.76 224.09,62.54 v3(223.41,62.54)
  vias: v2(225.55,73.79) v3(45.47,96.32) v3(45.79,95.81) v3(46.08,96.32) v3(222.84,62.28) v3(223.41,61.93) v3(224.09,73.59) v3(224.7,74.2) v3(224.7,73.59)
+3.3V_TP: length 29.9
  TOP w0.102: v2(186.29,99.53) 186.45,99.7 R1161.2
  TOP w0.305: v3(189.55,107.18) 189.55,106.86 188.96,106.27 JTP1.5
  TOP w0.508: v3(191.07,119.82) R903.1 ; v3(187.51,120.52) R902.1
  IN3 w0.508: v3(191.07,119.82) 188.21,119.82 v3(187.51,120.52)
  IN4 w0.508: v3(189.8,101.12) 189.8,105.46 189.55,105.72 v3(189.55,107.18) 189.55,110.16 187.51,112.21 v3(187.51,120.52)
+3.3V_VCCPRTCSUS: length 17.6
  TOP w0.508: CH53.1 182.17,127.96 182.79,128.58 RH241.2 RH240.2 185.1,128.58 v3(185.17,128.64)
  IN1 w0.508: 174.94,130.41 176.34,130.41 176.72,130.03 179.62,130.03 180.32,130.73 182.78,130.73 183.07,130.44 183.07,129.25 183.68,128.64 v3(185.17,128.64)
  BOTTOM w0.102: v1(184.41,128.2) 184.85,128.64 v3(185.17,128.64)
  BOTTOM w0.254: v3(172.16,131.63) 172.15,131.63 171.69,131.17 UH1.K8
+3.3V_VTR: length 4.8
  TOP w0.279: C739.1 217.54,76.95 v1(216.64,76.95) 216.35,76.95 216.12,77.17 215.81,77.17 215.44,77.54 U51.A22
  TOP w0.508: C775.1 C739.1 R834.2
+3.3V_VTR_ADC: length 5.2
  TOP w0.279: U51.A58 v1(202.76,78.04) 202.5,77.79 202,77.79 C736.1
  TOP w0.508: R839.2 C757.1 C736.1
+3.3V_WLAN: length 15.5
  TOP w0.381: v3(213.04,145.21) 213.04,146.04 212.79,146.29 Q124.2 ; Q124.5 210.77,146.29 211.08,145.99 211.08,145.34 210.89,145.15 v3(210.89,145.09)
  TOP w0.508: C606.2 215.09,147.63 Q89.2 v3(215.09,145.1) ; v3(207.24,148.35) 207.24,148.75 207.77,149.28 R725.2
  BOTTOM w0.508: v3(201.36,148.29) 201.23,148.16 R3885.2 ; R3886.2 217.52,160.81 v3(217.03,160.33) ; v3(215.09,145.1) 215.75,146.69 216.1,148.77
  vias: v2(242.55,149.89) v3(192.09,150.18) v3(192.7,150.18) v3(193.31,150.18) v3(204.6,148.22) v3(204.87,148.76) v3(205.18,148.22) v3(212.6,159.82) v3(212.92,160.33) v3(212.85,142.87) v3(213.23,159.82) v3(213.46,142.87) v3(214.09,142.89) v3(240.54,149.68) v3(240.62,151.1) v3(241.28,151.14)
+3V5V_PWR_SRC: length 5.5
  TOP w0.102: v2(206.59,52.36) 205.89,52.36 205.45,51.92 PC103.1
  TOP w0.203: PU100.12 201.82,37.69 PC117.1
  TOP w0.508: 203.27,37.34 203.25,37.33 PC117.1
  vias: v4(202.63,50.09) v4(202.63,49.46) v4(203.27,50.09) v4(203.27,49.46) v4(203.27,40.06) v4(203.27,39.42) v4(203.84,40.38) v4(203.84,39.74)
+3VALWP: length 47
  TOP w0.102: 223.38,49.9 v2(225.82,49.9)
  TOP w0.254: v4(193.11,36.11) PR100.1
  IN2 w0.254: v4(218.43,45.08) 219.88,45.08 220.35,44.61 220.35,34.66 218.23,32.54 217.08,32.54 215.65,31.11 196.41,31.11 194.06,33.45 194.06,35.16 v4(193.11,36.11)
+5V_ALW: length 353.5
  TOP w0.203: v3(246.51,148.07) U57.4 ; U37.4 174.75,40.33 v3(174.77,40.31) ; v3(222.12,127.94) 221.87,127.94 221.6,127.67 U146.4 ; v3(265.25,174.75) U145.4
  TOP w0.305: JMDIA1.1 8.55,140.13 8.55,140.69 8.7,140.83 9.34,140.83
  TOP w0.381: PU1.5 221.93,120.65 222.44,120.14 v2(222.44,119.47) 222.09,119.12 PR14.1
  TOP w0.508: v3(238.24,134.89) 236.14,136.98 231.92,136.98 231.32,137.58 231.32,139.87 231.8,140.35 PR723.2 ; v3(175.96,91.25) 176.72,91.25 177.17,90.8 PR211.1 ; v3(31.23,148.4) PR645.2 ; v3(275.53,183.81) 275.91,183.43 C715.1 ; 14.56,145.58 13.22,146.92 v3(13.22,147.39) ; 14.56,145.58 14.06,145.09 14.06,142.36 13.22,141.52 10.02,141.52 9.34,140.83 ; 14.56,145.58 C1002.1 ; v3(221.54,169.08) 221.54,169.05 219.95,167.46 219.95,165.33 219.38,164.76 219.38,161.2 219.71,160.87 219.71,159 219.46,158.74 219.46,152.5 218.23,151.27 218.23,139.82 219.44,138.61 v3(220.73,138.61) 220.73,139.41 220.52,139.61 PR745.1 ; R1629.1 172.25,113.86 172.25,113.04 v3(172.34,112.96) ; v3(29.4,154.61) 28.39,155.63 23.62,155.63 23.31,155.31 PR635.2 ; v3(272.9,192.48) R957.2 ; PR203.1 179.45,90.8 v3(179.07,90.41) ; PR530.2 131.95,141.85 v3(133.29,143.18) ; v3(221.27,118.26) 221.18,118.35 PR14.1 ; v3(170.44,97.78) 171.64,97.78 172.2,97.22 PR309.2 ; v3(37.03,148.21) PR843.2
  IN1 w0.508: v3(172.34,112.96) 172.57,112.73 180.18,112.73 180.72,113.27 183.89,113.27 184.09,113.07 200.65,113.07 201.79,114.21 217.82,114.21 221.27,117.66 v3(221.27,118.26)
  IN1 w1.016: 237.24,108.51 230.19,108.51
  IN2 w0.508: v3(118.68,141.66) 118.68,142.29 120.62,144.23 122.84,144.23 124.27,145.66 127.7,145.66 128.14,146.1 130.37,146.1 v3(133.29,143.18) ; v3(221.27,118.26) 222.63,116.9 222.63,111.05 225.5,108.18 v3(228.93,108.18) ; v3(175.96,91.25) 176.21,91.51 176.21,93.27 176.91,93.97 177.36,93.97 178.42,95.04 178.42,103.92 174.63,107.72 174.63,110.67 v3(172.34,112.96) ; v3(31.23,148.4) 31.23,148.69 32.45,149.91 35.33,149.91 v3(37.03,148.21)
  IN3 w0.508: v3(265.25,174.75) 265.25,172.89 265.94,172.2 268.42,172.2 269.31,173.09 v3(270,173.09)
  IN4 w0.508: v3(13.22,147.39) 12.19,148.41 12.19,151.56 15.24,154.61 v3(29.4,154.61) ; v3(220.73,138.61) 221.01,138.33 221.01,135.35 222.12,134.23 v3(222.12,127.94) 221.49,127.94 220.79,127.24 220.79,124.2 221.2,123.79 221.2,118.34 v3(221.27,118.26)
  BOTTOM w0.254: JLVDS1.1 v3(221.54,169.08)
  BOTTOM w0.508: v3(170.44,97.78) 171.07,97.15 171.07,94.8 174.61,91.25 v3(175.96,91.25) 176.6,91.25 177.43,90.41 v3(179.07,90.41) ; v3(29.4,154.61) 29.4,152.76 31.23,150.93 v3(31.23,148.4) ; v3(118.68,141.66) 118.68,140.46 119.58,139.56 PR520.2 ; v3(172.34,112.96) 172.28,112.96 171.64,112.32 167.64,112.32 166.13,113.83 158.4,113.83 157.18,115.05 155.94,115.05 153.99,117.01 153.99,118.24 148.58,123.65 148.58,133.29 142.08,139.79 142.08,140.73 138.05,144.77 134.88,144.77 v3(133.29,143.18)
  vias: v2(222,61.46) v2(228.7,68.47) v3(4.15,182.11) v3(4.15,181.5) v3(4.76,182.11) v3(4.76,181.5) v3(173.1,40.48) v3(173.1,39.89) v3(173.1,39.31) v3(173.69,40.48) v3(173.69,39.89) v3(173.69,39.31) v3(175.82,40.44) v3(175.82,39.8) v3(175.82,39.22) v3(176.46,40.44) v3(176.46,39.8) v3(176.46,39.22) v3(177,40.07) v3(177,39.49) v3(228.22,67.43) v3(228.83,67.43) v3(228.93,108.79) v3(238.44,108.83) v3(238.44,108.22) v3(255.65,152.58) v3(256.73,153.91) v3(272.23,182.61) v3(272.23,181.97) v3(272.81,182.61) v3(272.81,182.03) v3(279.68,180.14) v3(279.64,179.47) v3(280.21,179.19) v3(280.72,168.71) v3(280.72,168.13) v3(280.87,179.2) v3(281.31,168.72) v3(281.31,168.14) v3(282.37,188.92) v3(282.61,188.29) v3(283.16,189.18) v3(283.19,188.53) v4(219.9,58.66) v4(219.9,58.03) v4(219.9,57.39) v4(219.9,56.76) v4(219.9,56.12) v4(220.54,58.35) v4(220.54,57.71) v4(220.54,57.08) v4(220.54,56.44) v4(220.54,55.81) v4(221.17,58.66) v4(221.17,58.03) v4(221.17,57.39) v4(221.17,56.76) v4(221.17,56.12)
+5V_ALW2: length 1.2
  TOP w0.203: v1(200.99,38.09) PU100.13
+5V_HDD:
  vias: v2(78.54,36.85) v3(79.82,40.25) v3(79.82,39.64) v3(79.82,39.03) v3(79.82,38.42)
+5V_MOD:
  vias: v2(171.4,45.91)
+5V_RUN: length 535
  TOP w0.102: v3(8.36,180.9) v2(9.09,180.9)
  TOP w0.203: v3(26.56,149.71) PU600.18
  TOP w0.254: RP8.4 209.88,91.76 v3(210.19,92.07) 210.38,91.87 RP8.3 ; RP8.2 210.88,91.81 v3(211.14,92.07) 211.38,91.82 RP8.1
  TOP w0.305: C52.1 43.27,96.54 JUSH1.7
  TOP w0.381: C365.1 166.02,159.87 U21.5 ; U24.5 176.67,160.76 176.85,160.58 176.85,159.96 C369.1
  TOP w0.508: C369.1 175.83,158.94 v3(175.83,158.55) ; v3(42.74,96.32) C52.1 ; v3(166.05,159.12) 166,159.17 C365.1
  TOP w1.016: 282.64,163.63 281.75,164.52 280.23,164.52 278.63,166.12 271.94,166.12 270.62,167.44 268.73,167.44
  IN2 w1.016: 194.62,146.94 192.66,148.9 191.76,148.9 190.48,150.18 190.48,150.9 186.46,154.92 181.26,154.92 178.67,157.51 177.64,157.51 176.72,158.42
  IN2 w2.032: 46.48,121.15 46.48,102.99 44.2,100.7 44.2,97.59 ; 83.25,43.17 81.79,44.63 81.79,46.66 77.8,50.66 77.8,57.34 83.12,62.66 83.12,77.02 84.44,78.34 84.44,85.55 82.06,87.94 79.41,87.94 77.48,89.87 59.91,89.87
  IN3 w1.016: 9.39,181.7 11.48,183.8 11.48,185.27 12.88,186.67 12.88,198.73 13.31,199.16 13.31,202.21 15.58,204.48 17.38,204.48 18.01,203.85 18.95,203.85 19.31,204.21 20.26,204.21 20.7,203.76 25.4,203.76 ; 27.56,149.79 27.56,149.17 24.62,146.23 22.46,146.23 20.93,144.71 16.51,144.71 15.25,145.96 12.08,145.96 5.4,152.64 5.4,165.08 8.07,167.74 8.07,170.66 7.94,170.79 7.94,172.45 6.54,173.85 5.78,173.85 5.13,174.5 5.13,176.63 6.22,177.73 6.22,180.84 ; 147.13,157.72 148.21,156.64 153.16,156.64 155.39,158.87 162.5,158.87 163.13,158.24 166.26,158.24
  IN3 w2.032: 265.66,168.42 264.81,169.27 254.93,169.27 251.21,165.55 251.21,162.39 247.36,158.54 244.76,158.54 243.37,157.15 239.82,157.15 238.32,155.64 232.74,155.64 229.42,152.32 229.42,149.39 226.66,146.62 221.27,146.62 220.65,147.25 217.45,147.25 217.03,146.83 207.4,146.83 202.92,142.35 196.26,142.35 195.44,143.17
  IN3 w2.54: 171.61,44.53 168.34,41.27 159.7,41.27 156.28,44.69 92.43,44.69 91.54,43.81 87.34,43.81
  IN4 w2.54: 197.3,68.63 197.3,63.55 194.25,60.51 ; 195.71,136.71 195.71,135.23 197.03,133.91 197.03,119.5 196.68,119.15 196.68,103.92 196.92,103.69 ; 177.67,50.85 178.94,52.12 187.9,52.12 189.8,54.03 189.8,57.16 190.17,57.53 190.17,57.57 190.63,58.03 ; 196.31,97.93 195.92,97.54 195.92,95.53 194.91,94.52 194.91,83.68
  BOTTOM w1.016: 146.94,157.66 146.94,156.91 145.78,155.76 143.7,155.76 142.55,154.6 142.55,151.17 141.61,150.23 137.99,150.23 136.74,148.98 134.43,148.98 133.75,149.66 133.73,149.66
  vias: v3(7.75,180.9) v3(26.55,204.53) v3(26.55,203.94) v3(28.39,151.82) v3(28.39,151.18) v3(45.85,89.72) v3(45.85,89.11) v3(46.46,89.72) v3(46.46,89.11) v3(83.38,41.77) v3(84.01,41.77) v3(84.39,42.41) v3(84.65,41.77) v3(84.98,42.41) v3(133.03,151.12) v3(133.64,151.12) v3(146.58,159.18) v3(146.75,158.55) v3(166.66,159.12) v3(176.6,47.77) v3(176.6,47.18) v3(176.6,46.6) v3(176.6,45.99) v3(176.56,45.37) v3(176.56,44.76) v3(177.2,47.77) v3(177.2,47.18) v3(177.2,46.6) v3(177.2,45.99) v3(177.17,45.37) v3(177.17,44.76) v3(177.74,45.58) v3(194.82,145.6) v3(194.82,145.01) v3(195.14,144.52) v3(195.47,145.6) v3(195.47,145.01) v3(196.66,99.56) v3(197.25,99.56) v3(197.83,99.56) v3(266.38,166.97) v3(266.85,167.54) v3(267.08,167) v3(267.53,167.44)
+5V_TSP:
  vias: v1(186.63,144.52)
+5V_USB_CHG_PWR: length 1.8
  TOP w0.102: 280.94,196.84 280.94,196.67 v2(279.77,195.51)
  vias: v3(281.56,205.13) v3(281.56,204.5) v3(282.2,205.13) v3(282.2,204.5)
+5V_USB_PWR2: length 2.4
  TOP w0.102: v2(298.49,186.11) 297.84,186.76 296.39,186.76
  vias: v3(287.2,184.34) v3(287.2,183.71) v3(287.2,183.07) v3(287.2,182.44) v3(289.75,185.31) v3(289.75,184.66) v3(290.39,185.31) v3(290.39,184.66) v3(295.29,187.66) v3(295.61,187.1) v3(295.92,187.66) v3(296.24,187.1)
+5V_USB_PWR3: length 2.7
  TOP w0.102: v2(279.78,170.77) 281.03,169.52 281.97,169.52
  vias: v3(283.4,170.82) v3(283.4,170.18) v3(284.04,170.82) v3(284.04,170.18) v3(292.53,173.26) v3(292.52,172.58) v3(293.16,173.26) v3(293.14,172.58) v3(293.83,183.21) v3(294.13,183.77) v3(294.46,183.21) v3(294.77,183.77)
+5VALWP: length 71.1
  TOP w0.203: PU100.14 200.55,38.49 v4(200.63,38.57)
  TOP w0.254: PR101.1 v3(193.11,39.23)
  IN1 w0.508: v4(212.41,53.84) 211.14,52.57 195.52,52.57 193.37,50.42 193.37,44.3 194.11,43.56 194.11,40.24 v3(193.11,39.23) ; v4(213.43,53.84) 211.49,51.91 196,51.91 194.13,50.04 194.13,44.68 194.82,44 194.82,40.78 196.5,39.11 198.88,39.11 199.42,38.57 v4(200.63,38.57)
  vias: v1(214.83,61.08)
+AVCC33: length 0.9
  TOP w0.203: U27.5 v3(197.51,163.72)
  vias: v1(196.47,164.46) v3(194.25,165.09) v3(194.86,165.09)
+DVCC33: length 5.9
  TOP w0.203: U27.22 202.82,159.63 203.05,159.4 204.32,159.4 204.79,158.93 C117.1
  TOP w0.508: v3(205.41,159.87) 205.41,159.44 C117.1 C114.1
  vias: v1(203.01,156.33) v3(206.5,155.18) v3(206.82,155.69) v3(207.11,155.18)
+DVDD_CORE: length 4.7
  TOP w0.102: C954.1 264.57,160.65 v1(263.87,159.95)
  TOP w0.254: U74.1 267.53,159.97 266.85,160.65 266.51,160.65
  TOP w0.508: 266.51,160.65 C954.1
+VCC_CORE: length 85.7
  TOP w0.254: v3(131.51,136.9) 131.48,136.9 131.07,137.32 131.07,137.9 PR555.2 ; PR546.2 135.07,137.77 v3(135.07,137.34)
  IN1 w0.254: v3(132.21,123.75) 132.21,124.08 132.83,124.7 135.13,124.7 135.76,125.34 135.76,133.75 132.62,136.9 v3(131.51,136.9) ; v3(114.37,123.82) 114.47,123.92 120.04,123.92 120.33,123.62 120.33,120.42 121.33,119.43 123.62,119.43 124.31,118.74 133.98,118.74 137.07,121.82 137.07,134.21 134.96,136.32 134.96,137.24 v3(135.07,137.34)
  IN2 w0.508: v3(100.71,115.31) 100.71,115.3 105.92,110.1 109.98,110.1
  BOTTOM w0.254: PL503.1 132.65,123.2 132.21,123.65 v3(132.21,123.75) ; v3(131.51,136.9) 131.22,136.9 130.94,137.18 130.94,137.77 PR556.1 ; v3(135.07,137.34) 135.07,137.66 134.69,138.04 PR546.2 ; PL502.1 v3(114.37,123.82)
  BOTTOM w0.508: RC91.1 v3(100.71,115.31)
  vias: v2(114.78,114.42) v3(114.81,115.37) v3(115.38,123.05) v3(115.44,115.37) v3(115.47,99.2) v3(115.44,97.38) v3(116.42,113.66) v3(116.42,112.48) v3(116.42,111.28) v3(116.52,123.05) v3(116.52,121.91) v3(116.52,120.77) v3(116.52,119.62) v3(116.46,115.43) v3(116.47,110.2) v3(116.47,109.2) v3(116.47,108.2) v3(116.47,107.2) v3(116.47,106.2) v3(116.47,105.2) v3(116.47,104.2) v3(116.47,103.2) v3(116.47,102.2) v3(116.47,101.2) v3(116.47,100.2) v3(116.47,99.2) v3(116.87,96.75) v3(116.99,98.4) v3(117.42,113.66) v3(117.42,112.48) v3(117.42,111.28) v3(117.47,110.2) v3(117.47,109.2) v3(117.47,108.2) v3(117.47,107.2) v3(117.47,106.2) v3(117.47,105.2) v3(117.47,104.2) v3(117.47,103.2) v3(117.47,102.2) v3(117.47,101.2) v3(117.47,100.2) v3(117.47,99.2) v3(117.63,98.4) v3(117.67,123.05) v3(117.67,121.91) v3(117.67,120.77) v3(117.67,119.62) v3(118.49,115.31) v3(118.47,109.2) v3(118.47,107.2) v3(118.47,105.2) v3(118.47,103.2) v3(118.47,101.2) v3(118.47,99.2) v3(118.52,98.4) v3(118.81,123.05) v3(118.81,121.91) v3(118.81,120.77) v3(118.81,119.62) v3(118.9,96.75) v3(119.13,115.31) v3(119.28,98.4) v3(119.42,113.66) v3(119.42,112.48) v3(119.42,111.28) v3(119.47,110.2) v3(119.47,109.2) v3(119.47,108.2) v3(119.47,107.2) v3(119.47,106.2) v3(119.47,105.2) v3(119.47,104.2) v3(119.47,103.2) v3(119.47,102.2) v3(119.47,101.2) v3(119.47,100.2) v3(119.47,99.2) v3(119.83,123.43) v3(119.83,122.29) v3(120.14,115.43) v3(120.47,109.2) v3(120.47,107.2) v3(120.47,105.2) v3(120.47,103.2) v3(120.47,101.2) v3(120.47,99.2) v3(120.68,98.4) v3(121.06,96.75) v3(121.22,123.43) v3(121.22,122.29) v3(121.42,113.66) v3(121.42,112.48) v3(121.42,111.28) v3(121.44,98.4) v3(121.47,110.2) v3(121.47,109.2) v3(121.47,108.2) v3(121.47,107.2) v3(121.47,106.2) v3(121.47,105.2) v3(121.47,104.2) v3(121.47,103.2) v3(121.47,102.2) v3(121.47,101.2) v3(121.47,100.2) v3(121.47,99.2) v3(121.92,123.82) v3(121.92,122.67) v3(121.92,121.53) v3(121.92,120.39) v3(122.47,109.2) v3(122.47,107.2) v3(122.47,103.2) v3(122.47,101.2) v3(122.47,99.2) v3(122.83,98.4) v3(122.96,96.75) v3(123.06,123.82) v3(123.06,122.67) v3(123.06,121.53) v3(123.06,120.39) v3(123.42,111.28) v3(123.51,115.43) v3(123.49,113.66) v3(123.49,112.48) v3(123.47,110.2) v3(123.47,109.2) v3(123.47,108.2) v3(123.47,107.2) v3(123.47,106.2) v3(123.47,105.2) v3(123.47,104.2) v3(123.47,103.2) v3(123.47,102.2) v3(123.47,101.2) v3(123.47,100.2) v3(123.47,99.2) v3(123.47,98.44) v3(124.03,94.5) v3(124.21,123.82) v3(124.21,122.67) v3(124.21,121.53) v3(124.21,120.39) v3(124.47,109.2) v3(124.47,107.2) v3(124.47,105.2) v3(124.47,103.2) v3(124.47,101.2) v3(124.47,99.2) v3(124.47,98.44) v3(124.66,94.5) v3(124.99,96.75) v3(125.29,94.5) v3(125.48,111.29) v3(125.47,110.2) v3(125.47,109.2) v3(125.47,108.2) v3(125.47,107.2) v3(125.47,106.2) v3(125.47,105.2) v3(125.47,104.2) v3(125.47,103.2) v3(125.47,102.2) v3(125.47,101.2) v3(125.47,100.2) v3(125.47,99.2) v3(125.6,123.75) v3(125.62,113.66) v3(125.62,112.48) v3(125.63,98.4) v3(126.47,102.2) v3(126.47,101.2) v3(126.47,99.2) v3(126.75,123.75) v3(126.77,98.4) v3(127.03,96.75) v3(127.19,115.43) v3(127.47,101.2) v3(127.47,100.2) v3(127.47,99.2) v3(127.47,98.44) v3(127.64,111.28) v3(128.02,112.48) v3(128.47,101.2) v3(128.47,100.2) v3(128.47,99.2) v3(128.72,111.28) v3(128.8,98.4) v3(128.84,123.56) v3(128.84,122.42) v3(128.84,121.28) v3(128.84,120.13) v3(129.06,96.75) v3(129.47,100.2) v3(129.47,99.2) v3(129.57,98.4) v3(129.99,123.56) v3(129.99,122.42) v3(129.99,121.28) v3(129.99,120.13) v3(130.47,100.2) v3(130.47,99.2) v3(130.84,98.4) v3(131.09,96.75) v3(131.47,100.2) v3(131.47,99.2) v3(131.6,98.4) v3(132.47,100.2) v3(132.47,99.2) v3(132.87,98.4) v3(133.12,96.75) v3(133.47,100.2) v3(133.47,99.2) v3(133.63,98.4) v3(134.47,100.2) v3(134.47,99.2) v3(134.9,98.4) v3(135.03,96.75) v3(135.47,101.2) v3(135.47,100.2) v3(135.47,99.2) v3(135.66,98.4) v3(136.47,101.2) v3(136.47,100.2) v3(136.47,99.2) v3(137.06,98.4) v3(137.19,96.75) v3(137.35,100.16) v3(137.47,99.2) v3(137.82,98.4)
+VCCADAC: length 7.2
  TOP w0.102: LH1.2 171.43,151.3 v1(171.53,151.4)
  TOP w0.508: v3(171.01,148.01) 170.88,147.88 CH18.1 CH19.1 170.25,148.91 CH20.1 170.25,151.29 LH1.2
  BOTTOM w0.254: UH1.P45 170.15,147.15 v3(171.01,148.01)
+VCCIO2PCH: length 60.3
  TOP w0.254: v3(163.74,132.73) 163.77,132.73 164.21,132.28 164.21,129.85 163.85,129.48 163.85,129.39
  TOP w0.508: v3(165.85,127.3) 165.84,127.3 165.84,127.31 165.17,127.31 164.8,127.68 CH62.1 164.71,127.69 CH60.1 CH61.1 163.85,129.39
  IN4 w0.254: v3(164.93,109.39) 164.93,112.37 163.75,113.54 163.75,115.14 162.57,116.32 162.57,117.15 163.39,117.96 163.39,120.2 164.21,121.02 164.21,122.64 164.82,123.25 164.82,125.74 165.13,126.05 165.13,126.89 165.54,127.3 v3(165.85,127.3)
  BOTTOM w0.254: UH1.AJ14 164.33,133.06 UH1.AJ12 164,132.73 v3(163.74,132.73) ; v3(164.93,109.39) 154.53,109.39 154.08,109.84 150.69,109.84 148.34,107.5 148.34,104.13 151.07,101.4 v1(151.07,100.96) RC106.2 CC137.1 151.13,96.38 RC105.1
+VCCIO2PCH_R: length 6.2
  BOTTOM w0.102: v1(149.67,99.11) RC106.1
  BOTTOM w0.508: RC106.1 149.6,97.73 JCPU1.A23
+VCCIO_OUT: length 369.6
  TOP w0.508: R55.1 217.54,89.35 218.05,89.86 v3(218.73,89.86) ; RC29.1 107.34,114.18 107.96,114.8 RC87.1 RC90.1 v3(107.96,116.91) ; RV78.1 v3(62.61,147.88) ; RC74.2 133.72,116.75 137.61,120.64 v3(137.61,122.86) ; RC86.1 152.83,99.38 147.89,104.32 v2(147.89,115.45) 147.89,117.47 v3(146.75,118.61) ; RC28.1 108.84,112.83 v3(109.09,113.08)
  IN1 w0.508: v3(112.47,110.2) 111.22,110.2 109.09,112.32 v3(109.09,113.08) 108.84,113.34 108.84,116.03 v3(107.96,116.91) ; v3(92.71,80) 92.71,82.16 97.05,86.5 97.05,97.81 98.5,99.25 98.5,103.18 97.57,104.11 97.57,110.91 v3(99.5,112.84)
  IN2 w0.508: v3(62.61,147.88) 63.44,147.88 64.99,146.33 78.76,146.33 80.57,148.14 81.2,148.14 82.55,149.5 89.52,149.5 90.37,148.64 110.67,148.64 112.28,150.26 117.36,150.26 v3(119.43,148.19) ; v3(137.61,122.86) 142.5,122.86 v3(146.75,118.61) ; v3(98.24,82.6) 96.33,82.6 93.73,80 v3(92.71,80)
  IN3 w0.508: v3(99.5,112.84) 98.62,113.72 96.39,113.72 95.57,114.54 95.57,118.76 96.43,119.62 96.43,138.01 98.55,140.13 v3(99.19,140.13) ; v3(218.73,89.86) 218.61,89.98 218.29,89.98 214.2,94.07 212.27,94.07 209.71,96.64 198.22,96.64 197.93,96.35 196.72,96.35 195.86,97.21 189.3,97.21 187.54,98.97 182.59,98.97 176.16,105.41 167.7,105.41 165.37,107.74 163.02,107.74 161.36,109.4 156.02,109.4 153.26,112.16 149.16,112.16 148.21,113.11 148.21,117.15 v3(146.75,118.61)
  IN4 w0.508: v3(109.09,113.08) 109.09,112.58 108.65,112.13 105.09,112.13 104.08,111.12 101.23,111.12 v3(99.5,112.84) ; v3(137.61,122.86) 137.61,140.13 134.18,143.56 134.18,146.12 130.37,149.92 128.6,149.92 127.71,149.03 121.36,149.03 120.52,148.19 v3(119.43,148.19) 118.1,148.19 117.16,147.25 110.94,147.25 109.41,145.72 106.91,145.72 103.56,142.37 99.84,142.37 99.19,141.72 v3(99.19,140.13)
  BOTTOM w0.305: v3(112.47,110.2) JCPU1.AN35 ; JXDP1.16 92.98,79.73 v3(92.71,80)
  BOTTOM w0.508: v3(98.24,82.6) 98.48,82.36 CC17.1 CC18.1 ; v3(119.43,148.19) 119.51,148.28 PR504.2 PR503.2 PR500.2 119.57,146.5 PC548.2
+VCCST: length 26.2
  TOP w0.508: CC48.1 CC47.1 104.1,111.56 RC99.1 104.97,110.61 v3(104.59,110.23)
  IN4 w0.254: 114.43,109.97 114.94,109.46 114.94,106.75 v3(115.47,106.22) 114.96,105.72 114.24,105.72 113.98,105.97 113.98,109.53 114.43,109.97
  IN4 w0.508: v3(104.59,110.23) 107.38,110.23 108.46,111.31 113.1,111.31 114.43,109.97
  BOTTOM w0.254: v3(115.47,106.22) 115.94,105.75 JCPU1.AK31
+VDD_MEM15_REFDA: length 8.4
  TOP w0.508: v3(78.58,129.4) 78.58,129.46 79.16,130.04 79.55,130.04 80.57,129.02 CV275.1 82.41,129.02 RV146.1 82.6,129.01 83.19,129.59 RV145.2 83.3,129.9 83.76,130.36 84.39,130.36 v1(84.77,130.74)
  BOTTOM w0.3: UV1.K26 v3(78.58,129.4)
+VDD_MEM15_REFSA: length 7.4
  TOP w0.102: RV147.1 84.24,127.35 v1(84.47,127.12)
  TOP w0.4: v3(79.37,128.53) 79.37,128.27 79.98,127.66
  TOP w0.508: RV148.2 83.5,127.37 RV147.1 82.27,127.35 CV274.1 81.19,127.69 81.01,127.51 80.13,127.51 79.98,127.66
  BOTTOM w0.254: v3(79.37,128.53) 79.03,128.2 UV1.J26
+VDDA_AVDD: length 11.8
  TOP w0.254: U74.27 275.4,155.47 275.52,155.35 275.85,155.35 276.39,154.8 v1(276.42,154.8) C957.1
  IN4 w1.016: 282.96,159.57 282.96,159.11 282.08,158.23 282.08,156.63 278.77,153.32 277.89,153.32
  vias: v3(277.05,153.6) v3(277.05,153.01) v3(282.64,160.45) v3(283.22,160.45)
+VDDA_AVDD2: length 2.1
  TOP w0.254: 275.36,161.48 274.09,161.48 273.79,161.18 U74.38
  vias: v1(278.56,161.41)
+VDDA_PVDD: length 3.2
  TOP w0.254: U74.45 270.29,161.76 269.88,162.17 ; 273.88,162.17 273.29,161.58 U74.39
  vias: v1(269.56,162.49) v3(267.59,162.93) v3(268.17,162.93) v3(274.65,162.16) v3(275.24,162.16)
+VDDC_CT: length 6.9
  TOP w0.508: LV19.2 76.57,140.63 CV60.1 75.62,139.68 CV54.1
  BOTTOM w0.381: UV1.AA20 73.78,137.65 v3(74.23,138.1) ; v3(74.23,138.1) 73.78,138.55 UV1.AB20 ; v3(74.23,138.1) 74.73,138.6 UV1.AB21 ; UV1.AB21 74.82,138.6 v3(75.31,138.1) 74.81,137.6 UV1.AA21 ; UV1.AB21 74.78,139.1 v3(74.93,139.25)
  vias: v1(74.68,138.48)
GND: length 4743.1
  TOP w0.102: v3(224.93,120.32) 224.92,120.31 v2(224.92,119.56) ; v3(268.25,205.49) 268.24,205.5 v2(267.59,205.5)
  TOP w0.178: U36.11 v3(224.72,71.05)
  TOP w0.203: v3(21.85,199.63) 21.79,199.69 U19.15 ; v3(19.61,196.54) 19.61,196.58 19.48,196.71 U19.8 ; U27.6 197.8,163.32 197.73,163.25 197.55,163.25 v3(197.42,163.12) ; U146.11 v3(217.84,127.67) ; PU200.1 175.92,84.81 175.78,84.67 175.6,84.67 v3(175.46,84.81) ; U37.11 174.75,44.12 v3(174.69,44.19) ; v3(14.8,199.98) 14.83,200.02 14.86,200.02 14.93,200.09 U19.35 ; PU200.3 176.72,84.57 176.71,84.56 176.71,84.22 v3(176.43,83.94) ; v3(265.25,178.54) U145.11 ; v3(246.51,151.76) U57.11
  TOP w0.254: v3(52,160.65) PU700.14 ; v3(234.7,142.29) 234.8,142.29 235.35,142.85 PQ707.4 ; UV4.A3 v3(80.2,109.66) ; RPH19.5 188,138.36 187.77,138.58 v3(187.75,138.58) 187.72,138.58 187.5,138.37 RPH19.6 ; UV3.L5 v3(66.66,104.86) ; UV4.J1 v3(78.6,102.46) ; v3(220.03,75.68) 220.29,75.42 RP9.2 ; UV4.L5 v3(82.6,100.86) ; RP16.5 194.4,74.74 v3(193.89,75.25) ; RP9.3 220.35,74.92 v3(219.97,74.54) 220.08,74.42 RP9.4 ; UV3.P10 v3(62.66,107.26) ; RP6.5 186.51,57.51 v3(186.88,57.14) 187.01,57.27 RP6.6 ; UV4.B5 v3(81.8,108.86) ; v3(58.55,102.23) 58.9,102.23 UV3.H14 UV3.H13 ; v3(228.78,32.98) 228.96,32.98 229.12,33.15 JEXP1.13 ; v3(78.49,97.84) 78.7,98.06 UV4.R1 ; UV4.N14 v3(89,99.26) ; UV4.A12 v3(87.4,109.66) ; UV3.N14 v3(58.46,106.06) ; v3(40.32,138.2) PU800.5 ; v3(44.52,142.04) 44.32,142.23 PU800.14 ; UV3.C11 v3(61.06,97.66) UV3.C12 ; UV3.N12 v3(60.26,106.46) ; UV3.A1 v3(69.86,96.86) ; UV4.G10 v3(85.8,104.06) ; UV3.N1 v3(69.99,106.06) ; UV3.C3 v3(67.46,98.46) ; v3(84.96,56.76) 85.15,56.57 U88.10 ; UV4.U1 78.62,96.07 v3(78.62,96.07) ; v3(233.19,143.82) 233.52,144.15 PQ707.1 ; UV4.R12 v3(87.4,97.66) ; UV3.U14 v3(58.66,109.66) ; UV3.B5 v3(65.86,96.86) ; RP18.4 168.61,60.53 v3(169.03,60.95) ; UV3.U12 v3(60.26,109.66) ; JEXP1.7 v3(228.67,31.65) ; v3(205.83,148.4) 206.29,147.95 206.92,147.95 207.46,147.41 RP20.4 ; v3(89.94,103.66) UV4.H14 UV4.H13 ; UV4.C4 v3(81,108.06) ; v3(60.58,95.88) 60.66,95.96 UV3.A12 ; UV4.R4 v3(81,98.46) ; UV4.T10 v3(85.8,96.86) ; U88.16 80.21,51.98 C388.2 80.52,52.43 80.53,52.43 80.59,52.48 U88.15 ; UV4.U3 v3(80.2,96.86) ; U74.7 267.5,156.97 267.24,156.7 v3(267.09,156.7) ; UV4.C3 v3(81,107.26) ; UV4.G5 v3(82.6,104.86) ; UV3.B10 v3(61.86,97.66) ; v3(226.82,35.8) 225.67,34.65 JEXP1.20 ; v3(40.51,146.55) 40.32,146.36 PU800.23 ; v3(118.47,100.2) 117.99,99.71 T72.1 ; UV3.G10 v3(62.66,101.66) ; UV4.A14 v3(89.98,109.26) ; v3(69.06,103.26) UV3.K2 ; RP17.3 213.39,92.95 v3(213.16,93.18) 212.89,92.92 RP17.4 ; UV3.R12 v3(60.26,108.06) ; RP19.6 166.54,64.02 v3(166.16,64.4) 166.27,64.52 RP19.5 ; UV3.G5 v3(65.86,100.86) ; UV3.K13 UV3.K14 v3(58.41,103.66) ; UV4.D10 85.69,106.86 85.63,106.93 v3(85.6,106.93) ; v3(89.79,102.42) 89.43,102.06 UV4.K14 UV4.K13 ; UV3.T5 v3(65.66,108.46) ; UV3.M10 v3(62.66,105.66) ; RP6.7 187.51,57.33 v3(187.71,57.14) 188.01,57.45 RP6.8 ; v3(87.4,108.06) UV4.C11 ; UV4.E3 v3(80.2,105.66) ; UV4.E12 v3(88.2,105.66) ; v3(86.11,48.19) 85.65,48.64 U88.5 ; UV4.P10 v3(85.8,98.46) ; UV3.L10 v3(62.66,104.86) ; UV4.B10 v3(86.6,108.06) ; v3(62.66,102.46) UV3.J10 v3(62.66,103.26) ; UV4.F5 v3(81.8,105.66) ; v3(228.67,34.88) 228.9,34.65 JEXP1.19 ; UV4.N1 v3(78.46,99.66) ; UV3.H1 v3(69.86,101.66) ; v3(223.65,29.96) 224.34,30.65 JEXP1.4 ; U88.13 83.65,56.72 v3(83.69,56.76) 83.76,56.76 84.15,56.37 U88.12 ; UV4.N12 v3(87.4,99.26) ; UV4.H2 v3(80.2,103.26) ; UV3.A3 v3(67.46,96.06) ; UV4.M5 v3(81.8,100.06) ; UV4.R3 v3(80.2,97.66) ; v3(36.32,142.23) PU800.32 ; UV3.R14 v3(58.52,107.66) ; UV4.F10 v3(85.8,104.86) ; UV4.E1 v3(78.6,106.46) ; UV3.E1 v3(69.86,100.06) ; UV3.A14 58.84,96.46 v3(58.59,96.71) ; UV3.U3 67.86,109.68 v3(67.76,109.78) ; UV4.C14 v3(90,107.66) ; v3(166.18,54.67) 166.1,54.74 Q123.1 ; UV3.C4 v3(67.46,97.66) ; RPH15.5 174.62,121.96 174.87,122.21 175.21,122.21 175.41,122.41 v3(175.41,122.66) ; UV4.U12 v3(87.4,96.06) ; JEXP1.25 v3(228.76,36.15) ; v3(85.8,103.26) UV4.J10 v3(85.8,102.46) ; UV4.A1 v3(78.6,109.66) ; UV3.E14 v3(58.42,99.66) ; UV3.E12 v3(60.26,100.06) ; RP5.8 186.48,77.37 v3(185.65,77.37) ; UV4.R14 v3(89,97.66) ; UV3.C13 UV3.C14 v3(58.46,98.06) ; UV3.R4 v3(67.46,107.26) ; UV3.N3 v3(67.46,105.66) ; UV4.R11 v3(86.6,97.66) ; UV3.F10 v3(62.66,100.86) ; UV4.C1 v3(78.6,108.06) ; v3(271.82,161.6) 271.85,161.6 271.79,161.54 U74.42 ; UV3.F5 v3(66.66,100.06) ; UV3.C1 v3(69.86,98.46) ; UV4.K2 v3(80.2,102.46) ; UV3.E3 v3(68.26,100.06) ; UV3.U1 69.46,109.41 69.77,109.71 v3(69.77,109.72) ; UV3.R11 v3(61.86,108.06) ; UV3.R1 69.94,107.66 v3(69.99,107.71) ; UV3.H2 v3(68.26,102.46) ; UV4.H1 v3(78.6,104.06) ; UV4.L10 v3(85.8,100.86) ; UV3.T10 v3(62.66,108.86) ; UV3.R3 v3(68.26,108.06) ; UV4.E14 v3(89.94,106.06) ; UV4.K1 v3(78.6,101.66) ; UV4.C13 v3(88.2,107.26) UV4.C12 ; UV4.U14 v3(89,96.06) ; UV3.D10 v3(61.86,99.26) ; UV4.N3 v3(81,100.06) ; UV4.T5 v3(81.8,96.86) ; UV4.M10 v3(85.8,100.06) ; UV3.K1 v3(69.86,104.06) ; UV3.M5 v3(66.66,105.66)
  TOP w0.279: v3(231.59,63.68) 231.78,63.48 U41.7
  TOP w0.305: U46.B27 185.37,71.94 v3(185.55,71.75) ; U51.B60 205.66,78.79 v3(205.73,78.87) ; U51.B66 205.57,75.79 v3(205.73,75.96) ; JAPS1.12 231.58,98.9 231.4,99.08 v3(231.14,99.08) ; JSPI1.19 211.37,129.5 v3(211.01,129.15) 211.16,129 JSPI1.20 ; JUSH1.17 48.27,93.9 v3(48.39,93.78) ; v3(210.5,74.86) 210.57,74.79 210.57,74.59 210.68,74.48 U51.B11 ; JAPS1.8 v3(231.21,96.9) ; JSPI1.18 211.17,130 v3(210.95,130.23) 211.22,130.5 JSPI1.17 ; v3(238.41,77.22) 238.46,77.17 JDEG2.10 ; v3(205.74,81.94) 205.6,81.79 U51.B54 ; JAPS1.10 v3(231.22,97.9) ; JUSH1.20 49.77,94.04 49.48,93.75 v3(49.05,93.75) ; v3(214.89,74.48) 214.57,74.79 U51.B18 ; JAPS1.14 v3(231.19,99.9) ; v3(5.65,141.28) 6.05,140.88 6.05,140.87 JMDIA1.6 ; v3(253.12,156.82) 253.12,155.12 253.67,154.57 JLED1.6 ; JTP1.1 187.38,108.27 187.14,108.51 v3(187.14,108.89) ; JUSH1.2 40.77,93.85 v3(41.02,93.59) 41.27,93.83 JUSH1.3
  TOP w0.381: U50.3 200.56,90.56 v3(200.65,90.64) ; v3(79.82,36.57) 80.12,36.26 Q29.1 ; JSIM1.13 218.98,165.63 218.45,165.1 v3(218.45,164.35) ; PQ807.1 173.37,73.16 173.51,73.3 173.51,73.74 v3(173.28,73.97) ; v3(171.96,161.72) 172.29,162.06 Q331.4 ; U15.3 257.83,173.33 v3(258.45,172.71) ; v3(234.13,79.49) 232.92,79.49 232.74,79.67 PQ806.4 ; v3(221.74,124.45) 221.74,124.2 221.93,124.01 PU1.2 ; U39.3 215.91,112.01 v3(215.8,111.91) 215.26,112.45 U39.4 ; PU804.3 v3(229.49,82.46) ; PQ807.4 175.91,71.86 v2(176.18,71.59) v3(176.72,71.05) ; U39.25 215.26,108.4 v3(214.82,108.83) ; U9.3 177.1,117.39 v3(177.29,117.2) ; PQ824.4 221.82,95.7 222,95.88 v3(222.51,95.88) ; v3(186.17,42.94) 186.17,42.64 186.38,42.42 PQ821.4 ; v3(159.54,118.8) 159.54,118.39 159.65,118.28 UH3.3 ; v3(216.35,159.18) 216.84,158.69 U54.3 ; v3(156.57,115.89) 156.8,115.66 Q52.4 ; PQ812.4 113.43,154.27 113.67,154.51 v3(113.77,154.51) ; 229.73,77.27 229.59,77.13 PQ805.4 ; JSIM1.12 218.98,159.28 218.51,158.8 v3(218.51,158.52) ; U39.18 210.71,106.62 v3(210.19,106.1) ; JSIM1.17 233.31,162.24 v3(233.17,162.38) ; v3(178.34,158.5) 178.49,158.34 U23.7 ; v3(233.72,167.85) 233.71,167.85 233.31,167.45 JSIM1.16 ; v3(189.61,40.41) 189.61,40.95 189.44,41.12 PQ821.1 ; UV14.3 85.11,146.47 85.35,146.23 v3(85.68,146.23) ; v3(199.51,86.52) 199.51,85.84 200.26,85.08 C740.2 ; v3(231.84,81.52) 231.4,81.52 230.84,80.97 PQ806.1 ; Q331.1 174.2,160.76 173.99,160.96 v3(173.99,161.2) ; PQ819.4 v3(180.09,50.49) ; JEXP1.29 v3(228.73,37.21) ; U39.8 v3(212.66,111.95) ; U58.3 v3(226.47,111.76) ; v3(280.4,169.43) U93.1 ; v3(179.71,162.46) 179.17,162.46 178.77,162.06 U24.3 ; v3(189.64,37.9) 189.64,38.23 189.41,38.46 PQ813.4 ; v3(166.92,154.16) 166.63,154.44 U20.7 ; v3(223.88,37.39) 224.06,37.21 JEXP1.30 ; U39.1 217.21,112.29 v3(216.92,112) 216.56,112.37 U39.2 ; PQ813.1 186.5,39.76 v3(186.16,40.1) ; RD28.2 97.15,22.48 96.56,21.9 RD16.2 ; U21.3 169.79,161.17 170.07,161.45 v3(170.07,161.69) ; v3(210.5,111.81) 210.71,112.02 U39.11 ; U56.3 213.6,155.83 v3(213.43,156.01) ; v3(104.65,46.92) 104.65,47.55 105.43,48.33 UC1.3 ; PQ819.1 v3(184,49.19) ; PQ805.1 v3(224.87,78.43) ; PU808.3 v3(177.72,20.78) ; JEXP1.1 v3(228.73,30.09) ; v3(283.96,181.88) U91.1 ; v3(220.52,92) PQ824.1
  TOP w0.406: v3(236.09,141.25) 236.09,141.16 235.59,140.66 PU704.3 ; PU807.3 v3(181.78,45.63) ; v3(286.35,195.85) 286.2,195.7 D88.3 ; v3(287.16,173.28) D91.3 ; v3(278.3,190.81) D78.3 ; PU805.3 v3(190.49,49.95) ; Q76.1 v3(171.51,54.28) ; v3(224.41,85.05) 224.41,85.05 224.74,85.38 PU801.3 ; PU806.3 v3(189.66,48.26) ; Q29.4 v3(83.46,34.96)
  TOP w0.432: v3(156.22,113.97) 155.5,113.25 Q52.1 155.5,112.57 155.14,112.22 R1611.2
  TOP w0.457: CV49.2 72.96,137.4 73.37,137 73.37,136.98 PC951.2 73.78,136.46 v3(74.23,136.01) 74.69,135.55 PC930.2 74.69,134.04 PC944.2 ; CV79.2 68,136.46 v3(68.45,136.01) 68.91,135.55 PC927.2 PC933.2 68.91,133.96 v3(69.47,133.4) 70.03,132.84 PC929.2 70.03,132.65 v3(70.49,132.2) 70.94,131.74 PC950.2 ; PC945.2 72.72,131.87 v3(72.33,132.26) 71.87,132.72 PC947.2 71.87,132.87 71.53,133.21 71.53,133.22 71.39,133.37 v3(71.38,133.37) 70.88,133.86 PC946.2 70.88,133.98 CV82.2 70.88,135.55 69.97,136.46 CV80.2 69.97,136.59 v3(69.41,137.15) 68.91,137.64 CV78.2 ; C741.2 201.8,74.29 v3(202.05,74.04) 202.52,73.57 C724.2 ; RH76.2 161.8,120.61 162.26,120.15 v3(162.65,120.15) ; v3(188.09,31.05) 188.3,31.27 188.77,31.27 189.26,31.75 C1505.1 ; v3(182.06,87.27) 181.45,86.67 PC215.2 ; CH54.2 169.17,133.63 169.17,133.84 v3(169.28,133.96) ; PC931.2 68,132.65 v3(68.45,132.2) 68.91,131.74 PC932.2 ; v3(160.6,138.11) 160.6,137.52 CH36.2 ; v3(75.3,131.18) 74.86,131.63 PC948.2 74.75,131.74 v3(74.3,132.2) 73.84,132.65 PC949.2 73.79,132.83 v3(73.28,133.34) 72.79,133.84 PC928.2 PC934.2 72.79,135.55 v3(72.33,136.01) 71.87,136.46 CV83.2 71.69,136.76 CV62.2 71.43,137.79 CV81.2
  TOP w0.508: v3(84.41,110.73) CV207.2 RV128.2 ; v3(276.17,164.52) 276.07,164.62 C958.2 ; RV240.2 v3(73.47,145.53) CV340.2 ; v3(152.57,28.61) 153.07,28.61 CD42.2 ; CH62.2 164.53,128.78 164.53,129.48 v3(164.59,129.54) ; CH34.2 163.36,138.04 v3(163.34,138.02) 162.79,138.02 CH35.2 ; PR610.1 PR612.1 16.89,152.45 v3(16.61,152.73) ; v3(12.7,203.63) 12.13,203.63 v2(11.88,203.89) CE17.2 ; R512.2 v3(174.37,38.03) ; RV192.2 CV332.2 63.36,113.22 v3(63.18,113.4) ; v3(45.66,137.09) 45.2,136.63 PC817.2 44.34,136.07 PC816.2 ; v3(234.11,125.28) 234.41,125.57 U53.4 ; PQ709.3 222.64,139.62 v3(221.63,138.61) ; v3(168.21,145.15) 166.74,145.15 165.72,146.17 CH68.2 CH67.2 165.74,147.01 CH50.2 ; C480.2 264.16,191 v3(264.48,190.68) ; RV48.1 73.8,139.93 v3(73.78,139.95) ; v3(132.08,15.61) 132.41,15.28 CD38.2 CD37.2 ; v3(63.37,142.23) 63.5,142.1 CV61.2 ; v3(7.55,183.75) 7.13,183.33 C998.2 C50.2 ; RV25.1 66.87,131.77 66.87,132.77 v3(67.44,133.34) ; C746.2 v3(225.16,127.24) ; C1508.1 v3(180.58,29.21) R677.1 ; C478.2 261.1,173.78 v3(261.48,174.16) ; PC120.2 v3(192.88,42.23) ; RV108.1 v3(93.28,106.74) ; 220.99,36.67 220.99,36.67 ; 220.99,36.67 220.98,36.67 220.98,36.69 C649.2 ; 220.99,36.67 220.99,36.68 220.99,36.67 ; 220.99,36.67 220.99,36.67 ; 220.99,36.67 220.99,36.68 220.99,36.67 ; v3(127.13,159.88) 127.07,159.95 C695.2 R757.2 ; v3(276.16,163.88) C626.2 276.93,162.98 C625.1 ; PC801.1 v3(234.84,82.91) ; v3(40.51,146.55) 40.07,147 PR858.2 ; v3(224.93,120.32) 224.93,120.79 C1216.2 ; C296.2 216.22,169.27 v3(216.3,169.19) ; R793.2 v3(195.14,67.55) ; v3(24.24,202.63) C342.2 C340.2 ; C1002.2 15.79,146.5 16.09,146.19 v3(16.36,146.19) 16.6,145.95 PR615.2 ; Q45.3 220.52,83.29 v3(220.79,83.56) ; v3(217.7,169.17) 217.49,169.38 C246.2 ; PR111.1 197.25,43.09 v4(197.04,43.3) ; v3(167.39,113.72) 167.73,114.06 CH28.2 ; PC805.1 v3(228.79,87.75) ; R3737.2 193.55,170.88 193.83,170.88 v3(194.24,170.47) ; C53.2 v3(45.79,98.67) ; C395.2 77.54,39.23 v3(77.15,39.61) 77.66,40.12 C396.2 ; JSD1.20 v3(209.83,27.64) ; C436.2 175.13,46.15 v3(174.63,46.66) 174.25,46.28 C438.2 ; R100.1 v3(195.89,166.36) 195.7,166.55 R106.1 ; RD6.1 151.63,36.24 152.2,36.81 v3(152.57,36.81) 152.87,36.5 CD18.2 CD20.2 CD19.2 CD17.2 ; CD25.2 117.68,21.52 CD31.2 116.33,20.82 v3(116.14,20.63) ; SW1.3 269.14,201.27 v3(268.56,200.69) ; JSPI1.22 207.66,140.65 v3(207.27,140.26) ; D33.1 105.86,171.19 v3(105.28,171.76) ; CH27.2 163.61,141.29 v3(163.77,141.45) ; v3(80.41,128.2) 80.41,128.32 79.45,129.28 RV36.1 ; CV42.2 81.47,92.45 81.47,91.94 v3(81.41,91.87) ; v3(219.33,80.57) 219.27,80.51 R1069.2 C777.2 ; R758.2 C696.2 127.45,168.84 v3(126.62,168.01) ; v3(235.9,104.73) 235.52,104.34 JAPS1.18 ; C106.2 191.58,165.15 v3(191.45,165.03) ; v3(14.54,204.78) CE16.2 CE13.2 ; RV49.2 57.98,137.07 v3(57.79,136.88) 57.6,136.69 RV46.2 ; CV176.2 92.8,97.71 v3(93.33,97.71) ; C366.2 173.66,153.05 v3(174.11,152.59) ; C574.2 189.27,21.36 v3(188.98,21.07) ; v3(261.94,151.18) 261.81,151.31 C1559.2 ; v3(53.98,167.91) PC707.2 ; RV147.2 82.92,126.43 v3(82.81,126.55) 82.55,126.29 CV274.2 ; C1507.1 v3(187.89,35.88) ; JLOM1.14 244.3,217.14 243.68,216.51 243.68,208.36 243.1,207.79 243.1,205.73 243.44,205.4 C482.2 243.84,202.06 v3(244.36,201.54) ; C473.2 250.89,183.43 251.47,183.43 v3(251.59,183.31) ; C715.2 276.09,184.34 v3(275.59,184.84) ; C31.2 23.16,196.07 v3(23.76,195.47) ; v3(261.24,177.92) 260.61,178.55 C446.2 ; v3(181.87,118.61) 181.56,118.3 R1636.1 180.34,118.3 C288.2 ; JKB1.8 195.59,101.92 v3(195.96,102.29) ; C1506.1 179.96,23.43 v3(179.96,22.91) ; v3(247.04,162.83) 247.18,162.97 Y3.4 ; v3(284.61,195.6) 284.61,195.9 C654.2 ; v3(58.75,131.9) 57.34,131.9 56.97,131.54 CV216.2 ; PR106.2 v3(193.11,41.01) ; JSIM1.5 224.79,156.01 v3(224.84,155.96) ; v3(264.16,198.81) C484.2 ; JMDIA1.7 10.7,143.2 10.71,143.2 v3(10.71,144.71) ; v3(82.04,147.32) 81.86,147.5 CV66.2 ; C462.2 242.89,157.15 243.27,157.53 243.27,159.41 v3(243.61,159.76) ; v3(80.77,91.94) CV178.2 CV188.2 CV141.2 ; v3(205.64,92) 205.36,91.72 Q47.3 ; CV201.2 67.46,148.07 v3(67.43,148.03) ; v3(221.62,109.95) 221.73,110.06 R938.2 ; JSPI1.21 v3(210.89,126.85) ; v3(67.12,91.87) 67.25,92 CV189.2 ; v3(77.73,134.23) 77.15,134.8 CV75.2 ; C45.2 C44.2 v3(213.17,116.91) ; PQ825.3 v3(195.6,80.97) ; v3(169.53,145.3) 169.53,146.07 RH97.1 ; C470.1 R152.1 246.46,162.42 246.46,162.42 v3(246.47,162.42) ; v3(127.83,115.43) 127.83,116.03 PC940.2 ; v3(93.29,105.87) 93.28,105.86 RV110.2 CV326.2 ; RC58.2 RC63.2 RC61.2 110.06,67.8 109.16,68.7 109.16,76.82 v3(109.47,77.13) ; 194.78,1.2 v3(194.78,2.71) ; PR102.1 193.55,35.17 v4(193.11,34.72) 193.55,34.28 PR105.2 ; R3884.2 C802.1 202.27,31.89 v3(202.06,32.11) ; CV142.2 v3(88.84,92.76) ; v3(219.76,140.82) 220.09,141.15 PC725.2 220.52,142.04 PR740.2 ; v3(221,36.67) 220.99,36.67 ; PR405.2 v4(206.06,53.33) ; C800.1 192.61,22.29 C566.1 194.63,22.79 194.95,23.1 v3(194.95,23.87) ; v3(151.59,99.18) 151.77,99 RC89.2 ; PC820.2 34.65,140.13 v3(34.79,139.99) ; v3(157,29.99) 158.33,28.66 Q72.3 ; v3(195.21,27.93) 195.98,27.93 196.28,28.23 JSD1.21 ; v3(236.15,57.34) 236.45,57.65 C643.2 ; C702.2 152.49,161.66 v3(152.49,162.6) ; PR731.2 PC726.2 v3(230.51,139.49) 230.51,140.01 230.9,140.4 PC736.2 ; CV21.2 CV18.2 v3(82.63,117.26) ; C707.2 184.85,58.17 v3(184.43,57.75) 184.43,57.65 184.85,57.23 R803.2 ; C32.2 C354.2 v3(11.75,197.41) ; C572.2 209.12,31.71 v3(209.55,32.15) ; v3(264.01,164.4) 264.01,163.64 264.34,163.31 C967.2 ; CV76.2 76.86,130.26 v3(76.86,130.66) 75.91,130.66 75.73,130.48 75.26,130.48 75.13,130.61 CV23.2 ; CV43.2 v3(54.42,95.88) ; RC62.1 109.73,113.08 v3(109.73,113.08) ; v3(211.58,117.66) 211.27,117.34 C551.2 R657.2 ; C776.2 209.74,88.5 v3(209.45,88.79) ; v3(124.14,115.43) 124.14,116.03 PC941.2 ; C1541.2 276.35,168.39 v3(275.94,168.8) ; v3(66.56,126.2) 66.85,126.2 CV25.2 ; R5.2 284.8,163.36 v3(284.43,163.73) ; RV146.2 82.78,130.28 v3(82.78,130.6) 81.92,130.6 81.74,130.42 CV275.2 ; CH48.2 170.46,139.34 v3(169.95,138.84) 169.95,138.69 169.6,138.35 CH72.2 ; v3(97.49,19.99) 96.9,19.99 96.47,20.42 RD16.2 ; v3(199.51,86.52) 199.01,86.52 JTAG1.2 ; CV210.2 RV120.2 61.52,94.72 v3(61.79,94.99) ; R1138.2 216.73,159.69 216.47,159.95 v3(215.46,159.95) ; C113.2 206.76,151.69 v3(206.88,151.56) ; v3(185.61,124.64) 185.61,125.01 185.09,125.53 CH4.1 ; v3(92.18,36.81) 92.66,36.33 CD2.2 CD1.2 ; v3(58.04,159.95) 57.41,160.58 PC706.2 ; RH223.2 v3(172.23,115.7) ; C994.2 264.36,157.98 264.25,157.86 C977.2 262.88,157.86 262.43,157.42 262.43,156.56 v3(263.05,155.95) ; RH120.1 v3(177.74,120.45) ; CV55.2 76.91,138.69 76.53,139.07 CV54.2 76.53,139.32 v3(77.03,139.82) ; CH66.2 180.28,138.48 180.79,138.99 v3(180.79,139.31) ; v3(129.03,33.84) 128.91,33.96 CD13.2 ; C1509.1 193.07,27.52 v3(193.35,27.8) ; PR817.2 73.92,151.59 73.92,150.76 v3(73.65,150.5) 73.55,150.5 73.15,150.89 PC811.2 ; v3(45.77,136.25) PR657.1 ; CV24.2 68.98,127.99 v3(69.06,127.92) ; CV44.2 v3(65.28,91.87) ; v3(233.86,118.54) 234.51,119.2 JSF1.8 ; v3(167.32,93.27) PC303.2 166.38,93.89 PC205.2 ; v3(219.95,145.71) 220.03,145.79 PC730.2 PR739.2 ; v3(60.06,134.93) CV358.2 ; PR25.2 7.74,176.14 v3(7.05,176.14) ; v3(226.51,114.99) 228.28,114.99 C778.2 C1184.2 ; v3(210.63,88.76) 210.63,87.44 211.16,86.91 R843.1 ; v3(180.98,161.19) 180.76,161.41 R491.1 ; C705.2 182.75,75.87 v3(183.14,75.49) 183.77,76.13 C706.2 ; CV180.2 v3(66.36,91.87) ; CE7.2 25.73,205.53 v3(25.91,205.35) ; v3(177.99,46.47) 178.36,46.84 PQ818.3 ; PD4.1 71.87,165.81 71.53,166.16 v3(71.53,166.41) ; v3(41.25,150.55) 42.69,150.55 PR874.2 ; PR605.1 17.21,148.91 v3(16.64,148.91) ; C387.2 v3(89.41,50.66) ; CH49.2 170.62,137.21 v3(169.95,137.21) 169.95,136.98 169.48,136.51 CH29.2 ; v3(123.32,25.01) 123.57,25.01 124.27,25.71 CD9.2 ; CH51.2 162.93,145.16 v3(162.84,145.07) ; PR307.1 PC307.2 v3(181.26,95.75) ; RH226.2 163.64,122.63 v3(163.58,122.56) ; CV224.2 59.63,127.61 v3(59.94,127.29) ; CV202.2 v3(66.49,148.05) ; C976.2 184.67,14.67 v3(185.04,15.04) ; 167.1,131.46 166.63,131.93 CH46.2 ; 167.1,131.46 v3(167.28,131.46) ; 167.1,131.46 167.08,131.46 166.51,130.88 CH59.2 ; C1503.1 v3(182.74,22.08) ; v3(66.51,128.6) 66.54,128.57 CV22.2 ; v3(234.19,58.21) C635.2 C642.2 ; v3(148.02,170.55) 148.46,170.11 C701.2 ; C637.2 233.31,58.03 v3(232.73,58.03) ; CE12.2 v3(229.05,62.98) ; PC103.2 206.71,51.41 v3(207.08,51.04) ; v3(117.1,115.43) 117.1,116.09 PC943.2 ; v3(223.24,158.57) 223.39,158.42 JSIM1.10 ; v3(182.31,130.12) 182.15,130.28 181.26,130.28 ME1.1 ; PC209.2 177.53,82.34 178.32,83.12 PC214.2 178.5,83.94 v3(178,84.43) ; RD11.2 153.41,22.14 CD39.2 CD40.2 CD41.2 153.57,24.48 153.23,24.82 v3(152.66,24.82) ; v3(171.83,159.06) 171.46,159.43 C356.2 R492.1 ; C51.2 C52.2 v3(42.74,98.69) ; PC814.1 176,16.74 v3(175.55,16.3) ; v3(120.78,115.43) 120.78,116.03 PC942.2 ; PQ817.3 v3(189.12,49.37) ; C975.2 v3(181.66,15.15) ; v3(215.29,169.18) 214.95,169.52 C247.2 ; RC109.2 94.29,25.66 v3(94.81,25.14) ; v3(87.32,92.78) 87.06,93.03 CV151.2 ; v3(205.75,88.78) 205.75,87.9 R812.1 ; C399.2 C402.2 v3(83.31,46.98) ; v3(74.25,166.65) 74.58,166.32 PD2.1 ; CV73.2 76.96,132.33 v3(77.54,131.75) ; 220.99,36.68 220.99,36.67 ; 220.99,36.68 220.99,36.67 ; 220.99,36.67 220.99,36.67 ; v3(90.11,26.09) 90.37,25.82 RC108.2 ; C974.2 180.74,14.86 v3(180.98,15.1) ; v3(216.54,68.25) 216.98,67.81 C782.2 217.79,68.3 C759.2 ; v3(164.51,120.22) 164.51,120.79 RH56.2 ; RD7.1 152.27,32.95 151.96,32.63 151.96,31.93 152.23,31.65 v3(152.57,31.65) ; JTP1.10 185.91,102.62 186.32,103.04 v3(186.32,103.88) ; QV2.3 94.58,93.73 94.17,93.32 v3(94.17,92.45) ; PU701.4 230.09,145.85 v3(230.29,145.65) 230.54,145.65 PC727.2 ; Q48.3 275.72,182.6 v3(275.66,182.54) ; v3(216.16,150.61) 216.09,150.55 C606.1 ; C954.2 264.8,162.04 v3(264.4,161.65) ; CV198.2 70.49,144.72 v3(70.49,143.06) ; v3(77.6,132.96) 77.03,133.53 CV74.2 ; v3(173.18,25.3) 173.17,25.32 PQ829.3 ; v3(261.96,152.9) R1141.2 R1142.2 ; C107.2 192.06,163.21 v3(191.64,163.63) 192.12,164.1 C108.2 ; C449.2 268.86,179.81 268.21,180.46 v3(267.65,180.46) ; JSD1.6 v3(202.03,27.38) ; v3(216.78,155.5) 216.27,156.01 R1139.2 ; CC48.2 v3(101.22,113.59) ; CH37.2 162.14,142.82 162.56,143.24 v3(162.76,143.24) ; CV57.2 90.88,117.06 v3(90.84,117.02) CV53.2 90.19,117.89 RV60.1 ; CV157.2 54.79,100.89 RV118.1 54.79,100.89 v3(54.11,100.89) ; v3(103.53,93.43) 103.62,93.34 RC83.2 RC76.2 ; C714.2 v3(176.79,68.1) ; C640.2 234.57,67.82 C634.2 v3(234.63,68.57) ; CH53.2 181.55,127.04 181.04,127.55 v3(181.04,128.01) 181.04,128.41 CH6.1 ; C621.2 276.42,185.47 v3(275.85,186.05) ; v3(55.45,126.29) 55.9,125.85 CV343.2 ; v3(102.43,56.57) 102.29,56.43 QC1.3 ; JSD1.10 v3(202.58,3.55) ; C703.2 108.52,161.53 v3(108.21,161.22) ; PC213.2 177.93,91.43 177.44,91.43 v3(177.1,91.77) ; CV19.2 CV163.2 v3(73.92,117.26) ; CH19.2 CH18.2 169.23,147.88 v3(168.59,148.52) 168.59,149.6 CH20.2 ; v3(168.26,141.94) 167.94,141.62 CH75.2 ; C471.1 R562.2 245.95,167.07 v3(245.71,167.31) ; v3(210.39,103.8) C552.2 ; v3(200.69,88.61) 200.2,88.13 C720.2 ; R1154.1 C708.2 194.98,66.03 v3(195.2,66.25) ; CD32.2 128.21,12.75 v3(128.21,12.5) ; PC117.2 v4(202.19,36.63) ; v3(182.46,20.41) 182.23,20.18 C1504.1 ; D89.1 288.58,185.54 v3(288.72,185.68) ; CV191.2 CV192.2 54.55,99.12 v3(53.98,99.69) ; CV20.2 v3(85.29,117.26) ; v3(163.24,129.27) 162.93,128.96 CH61.2 CH60.2 ; JSF1.7 235.49,106.49 v3(235.93,106.05) ; CV60.2 77.99,140.39 v3(78.58,139.8) ; CC138.2 108.47,47.37 v3(108.02,46.92) ; CV78.2 68.91,138.62 CV84.2 ; v3(194.3,23.85) C575.2 193.41,23.87 192.55,23.87 R1702.2 ; v3(167.97,138.84) 167.97,139.36 CH47.2 ; v3(166.88,114.16) 166.26,114.78 QH3.3 ; v3(93.41,29.75) 93.91,29.25 RD18.2 ; C961.2 273.67,164.44 v3(273.75,164.52) ; RC100.2 RC78.2 103.89,95.11 v3(103.63,94.86) ; CV69.2 CV71.2 81.03,132.27 v3(80.31,133) ; 222.28,14.15 v3(221.16,14.15) ; C561.1 191.73,33.01 191.15,33.59 v3(190.72,33.59) ; v3(256.81,152.64) 256.81,152.46 257.02,152.25 257.84,152.25 258.36,152.77 C1004.2 258.36,157.05 JLED1.7 ; R804.2 C709.2 191.52,77.38 v3(191.42,77.49) ; v3(236.09,141.25) 236.71,140.63 PQ710.3 ; v3(152.57,38.33) 153.48,38.33 CD21.2 CD22.2 ; v3(104.6,20.37) 103.11,21.86 RD21.2 ; CD11.2 120.19,26.65 CD3.2 v3(118.75,25.64) ; CH10.2 165.99,133.57 v3(165.99,134) 165.99,134.86 CH25.2 ; C716.2 v3(182.82,57.74) ; C18.2 v3(219.33,83.68) ; C1558.2 263.01,171.34 v3(262.69,171.02) ; v3(199.63,76.47) 199.79,76.32 C743.2 ; v3(18.01,143.14) PR616.1 PC600.1 ; R1640.2 v3(41.72,98.67) ; CH70.2 166.54,143.23 v3(167.29,143.23) ; CD4.2 CD5.2 v3(124.33,33.96) ; v3(93.6,119.37) 93.6,119.05 CV423.2 ; R726.2 R733.2 v3(266.56,173.14) ; CD45.2 98.38,23.89 RC110.2 97.47,23.74 v3(97.41,23.68) ; v3(225.53,153.58) 225.9,153.95 C628.2 225.91,154.33 C630.2 ; v3(166.93,122.47) 166.93,122.99 RH55.2 RH54.2 ; v3(264.48,189.41) 264.16,189.73 C479.2 ; v3(249.92,166.19) Y3.2 ; CD26.2 125.86,20.88 v3(125.92,20.82) ; C645.2 C646.2 221.2,34.03 v3(220.98,33.8) ; RD30.2 90.67,21.9 CD24.2 CD23.2 90.86,23.23 v3(90.24,23.23) ; v3(273.99,177.33) Q59.3 ; CV129.2 RV80.2 v3(87.2,85.39) ; v3(53.34,105.72) 53.34,105.72 CV158.2 54.85,104.89 RV194.2 CV349.2 ; CH69.2 166.65,140.44 v3(166.64,140.44) 165.98,139.78 CH71.2 ; QC3.3 135.56,115.99 134.94,115.37 v3(134.37,115.37) ; U148.2 195.71,172.9 v3(196.03,173.22) ; CV152.2 v3(93.31,99.62) ; PC819.2 v3(46.04,139.44) ; v3(60.01,125.47) 60.45,125.91 RV180.1 ; C638.2 v3(231.01,58.03) ; CV146.2 v3(69.03,92.38) ; C772.2 163.91,114.85 R931.2 v3(163.91,116.32) ; v3(170.22,141.94) 170.66,141.49 CH73.2 ; v3(164.79,116.96) 164.16,117.58 CH12.2 ; JKB1.10 v3(193.59,102.35) ; C28.2 134.75,156.01 v3(134.62,155.88) ; JAPS1.17 v3(235.52,93.02) ; CE14.2 21.66,205.16 v3(22.1,204.71) 22.55,205.16 CE5.2 ; C773.2 R1611.2 ; v3(192.09,47.01) PC810.1 PC808.1 ; JKB1.12 v3(188.93,104.15) ; v3(101.03,24.44) 100.34,24.44 RD24.2 ; v3(178.34,158.5) 177.5,159.34 C369.2 ; v3(178.85,122.8) 179.34,123.29 CH5.1 ; v3(192.72,31.54) 192.72,30.3 C1510.1 ; C764.2 v3(177.93,42.22) ; Q70.3 154.62,116.88 v3(154.62,117.53) ; v3(177.61,142.8) 177.05,142.8 RH118.1 ; v3(24.26,199) R88.2 ; C622.2 285.37,164.89 C623.2 v3(284.42,164.95) ; C736.2 C757.2 199.84,79.37 v3(199.77,79.3) ; v3(70.81,92.38) CV156.2 ; C781.2 200.14,83.68 v3(199.65,83.68) 199.39,83.43 R836.2 C735.2 ; C755.2 v3(187.12,100.65) ; v3(68.37,92.38) 68.14,92.61 CV145.2 ; RV45.2 62.22,134.66 v3(62.56,135) ; v3(101.22,94.4) 101.22,93.7 100.86,93.35 RV82.1 99.51,93.35 QV6.3 ; PQ2.3 217.05,118.42 217.49,117.97 v3(217.72,117.97) ; v3(26.54,203.19) 26.93,203.19 27.25,203.51 U89.2 ; CD12.2 v3(116.27,25.77) ; C636.2 222.99,153.61 v3(222.98,153.6) 222.1,153.6 C639.2 ; JSIM1.11 220.74,156.39 221.14,155.99 v3(221.85,155.99) ; C774.2 v3(211.77,69.21) ; CD43.2 CD44.2 150.88,23.29 v3(150.37,23.8) ; v3(98.49,164.14) 98.47,164.12 97.91,164.69 PQ816.3 ; PR104.1 v3(193.11,40.12) ; C737.2 v3(219.33,74.41) ; CE18.2 18.1,205.09 v3(18.48,204.71) 18.99,205.22 CE15.2 ; PC406.2 v3(200.22,51.3) ; JMDIA1.8 3.9,143.2 3.9,143.2 v3(3.9,144.71) ; v3(151.75,128.88) 152.21,128.88 152.57,128.53 RH332.1 ; v3(56.44,128.27) 56.44,127.83 56.77,127.5 58.11,127.5 CV221.2 ; v3(176.83,128.57) 176.96,128.71 177.8,128.71 CH7.1 ; C1001.2 4.83,180.52 v3(4.57,180.27) ; CC47.2 101.5,111.88 v3(101.22,112.16) ; v3(169.28,133.96) 169.28,134.65 CH30.2 ; v3(84.39,150.87) 84.6,150.66 CV87.2 ; JDEG2.12 v3(240.86,70.57) ; C388.2 80.14,51.43 v3(80.33,51.23) ; C581.2 v3(186.63,33.65) ; v3(183.75,38.06) 183.44,38.06 183.15,38.36 PQ827.3 ; v3(284.33,178.12) D90.1 ; v3(95.11,121.68) 95.36,121.93 QV3.3 ; v3(77.28,117.26) CV166.2 CV167.2 ; v3(276.19,172.52) 277.37,172.52 278.02,173.17 C624.1 ; v3(138.99,98.77) 139.33,99.11 RC82.2 ; C115.2 205.39,155.79 205.38,155.79 204.92,156.25 v3(204.92,156.39) 204.92,156.4 204.92,156.64 204.54,157.02 R114.1 204.52,157.53 C116.2 ; v3(232.48,138.75) 232.48,138.28 PC733.1 ; CH74.2 175.14,138.98 v3(174.44,138.98) 174.44,138.04 173.68,137.28 RH187.2 ; v3(244.1,178.11) C474.2 ; v3(156.54,157.96) 156.15,158.35 PR814.1 ; CV41.2 v3(91.06,95.43) ; PC3.2 v3(242.76,153.11) ; v3(175.95,24.51) 176.57,23.89 C578.2 ; v3(199.33,154.55) 199.66,154.22 R104.2 ; U52.4 234.68,131.69 v3(234.3,131.31) ; CH38.2 158.25,134.1 v3(158.57,134.42) ; PQ6.6 8.51,179.25 8.76,179.5 v3(8.76,179.82) ; v3(202.39,88.57) 202.39,88.06 C290.2 ; C756.2 C758.2 198.43,97.7 v3(197.68,96.96) ; PQ831.3 173.58,18.24 v3(173.76,18.42) ; C289.2 172.91,113.72 v3(173.29,113.34) ; RD27.2 90.67,28.84 91.96,30.13 v3(92.06,30.13) ; v3(11.05,169.45) PC13.2 ; QV11.3 79.33,90.02 78.68,90.67 v2(78.68,90.73) v3(78.68,91.87) ; C1539.2 v3(281.29,170.04) ; v3(273.52,192.74) D72.1 ; C631.2 224.98,154.18 v3(224.4,153.6) 223.88,154.12 C616.2 ; v3(257.11,179.19) 257.11,179.17 256.73,178.79 C472.2 ; v3(228.98,61.97) CE10.2 CE11.2 ; v3(197.02,75.05) 197.6,75.05 R879.1 ; CH24.2 164.09,135.67 v3(164,135.58) 164,135.09 CH23.2 ; JKB1.11 204.39,104.15 v3(203.9,104.64) ; v3(82.83,132.2) 82.84,132.21 CV77.2 ; v3(219.39,72.38) C284.2 R407.2 ; v3(139.45,116.58) 139.05,116.18 RC75.2 ; C445.2 C450.2 266.47,180.84 v3(266.84,180.47) ; CE6.2 110.91,172.67 v3(110.68,172.9) ; v3(213.87,158.99) 214.19,158.68 C725.2 ; PC114.1 v4(193.99,38.09) ; PR738.2 PC729.2 v3(223.08,148.96) ; C629.2 228.8,154.35 v3(229.24,154.78) ; JSD1.13 213.08,3.5 v3(213.08,3.5) ; v3(236.29,65.47) 237.86,65.47 C633.2 ; C742.2 209.55,69.83 v3(209.55,69.27) ; v3(213.5,121.01) PR15.1 ; RH53.1 CH40.2 176,129.78 v3(176.31,129.48) 176.74,129.91 CMOS1.1 ; JUSH1.21 v3(38.11,92.89) ; v3(203.46,71.49) 203.16,71.49 202.63,70.96 C721.2 ; JSF1.5 v3(231.22,115.2) ; v3(67.25,143.12) 66.98,143.38 CV204.2 CV199.2 ; CV222.2 CV220.2 62.03,129.48 v3(62.24,129.27) ; v3(269.14,196.93) SW1.1 ; C26.2 C25.2 135.19,154.23 v3(135.13,154.3) 134.75,154.68 C29.2 ; v3(89.35,123.94) RV61.1 RV104.1 ; C779.2 212.54,66.54 v3(212.03,66.03) ; CV177.2 92.88,98.52 v3(93.32,98.52) ; QV7.3 v3(88.01,114.59) ; C114.2 C117.2 207.14,158.93 207.58,159.38 v3(207.58,159.69) ; CH45.2 167.7,136.32 CH22.2 166.84,136.74 v3(167.31,137.21) 167.06,137.45 CH43.2 ; PC17.2 166.04,166.94 v3(166.37,166.61) ; CV411.2 v3(94.24,118.8) ; v3(252.66,159.26) 251.52,158.12 JLED1.8 ; v3(246.67,160.96) R557.2 ; C727.2 v3(210.44,153.58) 210.06,153.2 R1137.2 ; JDEG2.11 v3(240.76,79.27) ; CD29.2 131.19,21.33 v3(131.83,20.69) ; CV331.2 RV186.2 v3(85.27,113.03) ; v3(24.26,200.84) R76.2 ; C469.2 235.12,157.65 v3(234.98,157.51) ; PR844.2 v3(169.97,22.6) ; CD33.2 v3(126.24,12.5) ; CH52.2 v3(154.05,133.47) ; v3(94.15,100.62) 94.03,100.51 CV153.2 ; C710.2 177.03,65.7 176.89,65.56 v3(176.89,65.33) ; JSIM1.18 230.85,156.49 230.29,155.93 v3(229.62,155.93) ; PC815.2 35.74,135.75 35.17,136.32 35.17,137.2 PC813.2 36.13,137.59 v3(36.69,138.15) ; CV215.2 CV219.2 60.35,130.34 60.09,130.08 v3(59.6,130.08) ; v3(158.54,137.48) 158.19,137.48 CH21.2 ; C1526.2 279.83,181.29 v3(280.08,181.54) ; v3(101.49,51.91) 101.57,52 CC19.2 ; C1540.2 v3(275.2,167.31) ; C444.2 246.06,154.04 C423.2 244.62,154.04 v3(243.42,152.83) ; v3(176.26,147.59) 176.44,147.77 CH76.2 ; U8.2 174.55,115.29 v3(174.3,115.55) ; C365.2 165.09,159.24 v3(164.97,159.12) ; v3(264.16,197.54) C483.2 ; v3(248.81,153.42) 248.18,154.04 C447.2 246.98,154.04 C448.2 ; CD7.2 117.43,35.35 CD6.2 v3(118.75,33.9) ; R108.1 199.58,169.27 v3(199.04,169.81) ; PU801.3 225.6,84.83 PQ802.3 ; v3(201.79,66.42) C734.2 C733.2 ; v3(24.32,198.05) R81.2 ; v3(234.49,164.23) R561.2 ; CV143.2 v3(87.95,92.76) ; CD28.2 122.54,20.88 v3(122.94,20.88) 123.25,20.88 123.64,21.26 CD30.2 ; v3(210.95,163.19) Q22.3 ; C559.1 188.3,19.09 187.93,18.72 v3(187.49,18.72) ; C783.2 v3(83,90.1) ; CV92.2 v3(72.15,145.51) CV93.2 72.39,146.41 CV98.2 72.39,147.57 72.76,147.94 v3(72.76,148.53) ; CD34.2 v3(118.94,12.44) ; PC210.2 182.82,90.99 v3(183.64,90.16) ; C1178.2 v3(247.73,162.26) ; v3(80.31,142.8) 79.95,143.15 CV67.2 CV68.2 ; v3(62.33,127.42) 61.88,127.42 CV223.2 CV225.2 ; 229.73,77.27 v3(229.73,76.2) ; v3(80.14,117.26) CV26.2 CV13.2 ; 202.19,39.74 v4(202.19,39.04) ; PC818.2 v3(41.72,136.45) ; CV144.2 v3(69.92,92.38) ; C1553.2 106.61,109.96 107.72,108.84 109.11,108.84 v3(109.47,109.2) ; JTP1.9 v3(186.44,110.42) ; JUSH1.22 v3(50.24,91.51) ; CD27.2 v3(122.87,12.56) ; JSD1.19 v3(219.26,28.82) ; RC16.2 103.84,53.84 v3(103.59,54.09) ; v3(12.45,199.7) R87.2 ; C780.2 v3(215.28,86.35) ; v3(8.83,172.27) PR20.2 ; v3(12.26,202.37) C355.2 ; v3(125.99,25.77) 126.11,25.9 CD10.2 ; JSF1.6 v3(231.24,116.2) ; C560.1 191.21,20.39 C580.2 v3(192.41,19.55) ; JEXP1.32 v3(228.85,39.35) ; v3(209.87,65.78) 209.95,65.7 C744.2 ; v3(24.32,199.89) R82.2 ; CV344.2 63.59,125.91 v3(64.11,125.4) ; PC812.1 v3(185.49,45.57) ; v3(93.79,123.43) 93.41,123.05 CV52.2 ; v3(70.37,145.53) CV203.2 ; v3(74.55,117.26) CV164.2 CV165.2 ; RV131.2 CV324.2 85.61,94.56 v3(86.11,95.05) ; C27.2 135.64,156.07 v3(135.45,155.88) ; RC80.2 v3(129.48,113.84) ; v3(121.35,33.26) 121.1,33.26 120.79,33.57 120.79,34.29 121.48,34.98 CD8.2 ; v3(216.35,103.75) C550.2 C553.2 ; CD35.2 v3(116.24,12.47) ; Q71.3 145.5,42.49 145.1,42.09 145.1,40.16 v3(144.8,39.85) ; v3(205.51,71.03) 205.51,70.3 205.11,69.89 C722.2 ; 222.28,1.2 v3(222.28,2.76) ; C30.2 134.93,152.28 v3(135,152.2) ; JSD1.24 v3(195.71,7.35) ; C973.2 v3(177.85,15.05) ; JEXP1.31 v3(228.84,27.95) ; v3(233.62,68.63) 233.17,68.63 C641.2 ; C739.2 C775.2 219.03,78.1 v3(219.43,77.69) 219.83,78.1 R424.1 ; C455.1 v3(198.31,169.75) ; PR207.1 181.47,83.96 v3(182.2,83.96) ; JSD1.3 v3(211.08,27.37) ; PR302.1 v3(181.28,92.18)
  GND1 w0.203: JUSB3.12 292.54,169.85 ; JUSB3.12 291.02,168.97 ; JUSB3.12 289.5,170.73 ; JUSB3.12 292.54,168.97 ; JUSB3.12 291.02,170.73 ; JUSB3.12 292.54,170.73 ; JUSB3.12 289.5,169.85 ; JUSB3.12 289.5,168.97 ; JUSB3.4 291.52,180.53 ; JUSB3.4 290.92,180.35 ; JUSB3.4 292.12,180.35 ; JUSB3.4 290.92,179.15 ; JUSB3.4 291.52,178.98 ; JUSB3.4 292.3,179.75 ; JUSB3.4 292.12,179.15 ; 17.48,209.99 JHDMI1.8 ; JHDMI1.8 18.4,209.99 ; JHDMI1.8 17.94,209.87 ; JHDMI1.8 17.94,211.04 ; JHDMI1.8 18.4,210.92 ; JHDMI1.8 17.48,210.92 ; H16.1 50.86,144.68 ; H16.1 47.26,146.2 ; H16.1 49.34,148.28 ; H16.1 49.34,144.12 ; H16.1 47.82,144.68 ; H16.1 50.86,147.72 ; H16.1 47.82,147.72 ; H16.1 51.42,146.2 ; JDOCK1.161 114.09,170.15 ; JDOCK1.161 116.15,168.2 ; JDOCK1.161 116.15,169.18 ; JDOCK1.161 112.03,170.15 ; JDOCK1.161 114.09,168.2 ; JDOCK1.161 112.03,168.2 ; JDOCK1.161 116.15,170.15 ; JDOCK1.161 112.03,169.18 ; 167.91,34.33 JSATA2.20 ; JSATA2.20 168.44,35.53 ; JSATA2.20 167.91,35.67 ; JSATA2.20 167.39,34.47 ; JSATA2.20 168.44,34.47 ; JSATA2.20 168.59,35 ; JSATA2.20 167.39,35.53 ; JSATA2.20 167.24,35 ; PBATT1.4 66.79,170.63 ; PBATT1.4 67.67,169.75 ; PBATT1.4 67.46,170.42 ; PBATT1.4 67.46,169.08 ; PBATT1.4 66.12,169.08 ; PBATT1.4 65.91,169.75 ; PBATT1.4 66.12,170.42 ; PBATT1.4 66.79,168.87 ; 157.03,168.2 JDOCK1.164 ; JDOCK1.164 159.09,168.2 ; JDOCK1.164 161.15,169.18 ; JDOCK1.164 157.03,169.18 ; JDOCK1.164 159.09,170.15 ; JDOCK1.164 161.15,168.2 ; JDOCK1.164 161.15,170.15 ; JDOCK1.164 157.03,170.15 ; JSATA2.33 167.21,49.92 ; JSATA2.33 164.42,51.48 ; JSATA2.33 164.42,49.92 ; JSATA2.33 167.21,50.7 ; JSATA2.33 164.42,50.7 ; JSATA2.33 167.21,51.48 ; JSATA2.33 165.81,49.92 ; JSATA2.33 165.81,51.48 ; H23.1 61.31,115.53 ; H23.1 58.27,118.57 ; H23.1 59.79,119.13 ; H23.1 57.71,117.05 ; H23.1 61.87,117.05 ; H23.1 58.27,115.53 ; H23.1 59.79,114.97 ; H23.1 61.31,118.57 ; 269.21,209.94 JUSB1.13 ; JUSB1.13 270.09,208.17 ; JUSB1.13 269.21,211.72 ; JUSB1.13 270.97,208.17 ; JUSB1.13 269.21,208.17 ; JUSB1.13 270.09,211.72 ; 167.59,13.92 H4.1 ; H4.1 169.52,15.85 ; H4.1 169.01,17.27 ; H4.1 166.17,17.27 ; H4.1 166.17,14.43 ; H4.1 167.59,17.78 ; H4.1 169.01,14.43 ; H4.1 165.66,15.85 ; JSATA2.21 166.19,35.8 ; JSATA2.21 164.99,36.33 ; JSATA2.21 165.52,36.47 ; JSATA2.21 165.52,35.13 ; JSATA2.21 166.04,36.33 ; JSATA2.21 164.99,35.27 ; JSATA2.21 164.84,35.8 ; JSATA2.21 166.04,35.27 ; JUSB2.7 290.62,194.65 ; JUSB2.7 290.79,195.25 ; JUSB2.7 289.42,195.85 ; JUSB2.7 290.02,194.48 ; JUSB2.7 289.24,195.25 ; JUSB2.7 290.02,196.03 ; JUSB2.7 289.42,194.65 ; JUSB2.7 290.62,195.85 ; 289.5,200.77 JUSB2.10 ; JUSB2.10 291.02,200.77 ; JUSB2.10 292.54,202.53 ; JUSB2.10 292.54,200.77 ; JUSB2.10 291.02,202.53 ; JUSB2.10 292.54,201.65 ; JUSB2.10 289.5,202.53 ; JUSB2.10 289.5,201.65 ; 226.62,21.98 H18.1 ; H18.1 227.79,24.74 ; H18.1 226.62,24.32 ; H18.1 229.38,23.15 ; H18.1 226.2,23.15 ; H18.1 228.96,24.32 ; H18.1 227.79,21.56 ; H18.1 228.96,21.98 ; 290.92,199.35 JUSB2.4 ; JUSB2.4 291.52,197.97 ; JUSB2.4 290.92,198.15 ; JUSB2.4 292.12,199.35 ; JUSB2.4 292.3,198.75 ; JUSB2.4 292.12,198.15 ; JUSB2.4 291.52,199.53 ; 18.98,212.47 JHDMI1.11 ; JHDMI1.11 18.98,211.54 ; JHDMI1.11 19.9,211.54 ; JHDMI1.11 19.9,212.47 ; JHDMI1.11 19.44,212.59 ; JHDMI1.11 19.44,211.42 ; 62.12,169.08 PBATT1.2 ; PBATT1.2 63.46,169.08 ; PBATT1.2 62.79,170.63 ; PBATT1.2 61.91,169.75 ; PBATT1.2 63.67,169.75 ; PBATT1.2 62.79,168.87 ; PBATT1.2 63.46,170.42 ; PBATT1.2 62.12,170.42 ; H22.1 250.59,88.83 ; H22.1 248.51,86.75 ; H22.1 249.07,85.23 ; H22.1 252.67,86.75 ; H22.1 249.07,88.27 ; H22.1 252.11,88.27 ; H22.1 250.59,84.67 ; H22.1 252.11,85.23 ; 269.21,218.42 JUSB1.12 ; JUSB1.12 269.21,217.04 ; JUSB1.12 270.09,218.42 ; JUSB1.12 269.21,215.67 ; JUSB1.12 270.09,215.67 ; JSATA2.14 168.44,30.73 ; JSATA2.14 167.91,29.53 ; JSATA2.14 167.39,29.67 ; JSATA2.14 167.91,30.87 ; JSATA2.14 168.59,30.2 ; JSATA2.14 167.39,30.73 ; JSATA2.14 168.44,29.67 ; JSATA2.14 167.24,30.2 ; JSATA1.23 79.4,28.27 ; JSATA1.23 77.6,26.16 ; JSATA1.23 77.6,28.27 ; JSATA1.23 81.2,27.22 ; JSATA1.23 79.4,26.16 ; JSATA1.23 77.6,27.22 ; JSATA1.23 81.2,26.16 ; JSATA1.23 81.2,28.27 ; JHDMI1.23 29.02,221.04 ; JHDMI1.23 29.02,219.75 ; JHDMI1.23 29.02,218.47 ; JHDMI1.23 28.09,218.47 ; JHDMI1.23 27.16,218.47 ; JHDMI1.23 27.16,219.75 ; JHDMI1.23 28.09,221.04 ; JHDMI1.23 27.16,221.04 ; JUSB1.11 286.67,217.04 ; JUSB1.11 285.79,218.42 ; JUSB1.11 286.67,218.42 ; JUSB1.11 285.79,215.67 ; JUSB1.11 286.67,215.67 ; JUSB3.13 297.12,170.73 ; JUSB3.13 295.94,168.97 ; JUSB3.13 295.94,170.73 ; JUSB3.13 297.12,168.97 ; JUSB3.13 298.3,168.97 ; JUSB3.13 298.3,169.85 ; JUSB3.13 298.3,170.73 ; JUSB3.13 295.94,169.85 ; 59.91,169.75 PBATT1.1 ; PBATT1.1 60.79,168.87 ; PBATT1.1 61.46,169.08 ; PBATT1.1 60.12,170.42 ; PBATT1.1 60.12,169.08 ; PBATT1.1 60.79,170.63 ; PBATT1.1 61.46,170.42 ; PBATT1.1 61.67,169.75 ; JUSB3.7 290.62,175.65 ; JUSB3.7 290.02,175.48 ; JUSB3.7 289.42,176.85 ; JUSB3.7 289.42,175.65 ; JUSB3.7 290.02,177.03 ; JUSB3.7 290.62,176.85 ; JUSB3.7 290.79,176.25 ; JUSB3.7 289.24,176.25 ; 163.49,29.29 JSATA2.1 ; JSATA2.1 164.54,29.29 ; JSATA2.1 163.49,30.35 ; JSATA2.1 164.01,29.15 ; JSATA2.1 164.69,29.82 ; JSATA2.1 164.54,30.35 ; JSATA2.1 163.34,29.82 ; 15.98,211.54 JHDMI1.5 ; JHDMI1.5 16.44,212.59 ; JHDMI1.5 16.44,211.42 ; JHDMI1.5 16.9,211.54 ; JHDMI1.5 15.98,212.47 ; JHDMI1.5 16.9,212.47 ; 102.15,73.92 H5.1 ; H5.1 100.63,74.48 ; H5.1 100.63,77.52 ; H5.1 104.23,76 ; H5.1 103.67,74.48 ; H5.1 102.15,78.08 ; H5.1 100.07,76 ; H5.1 103.67,77.52 ; 295.94,188.85 JUSB2.13 ; JUSB2.13 298.3,189.73 ; JUSB2.13 298.3,188.85 ; JUSB2.13 297.12,189.73 ; JUSB2.13 298.3,187.97 ; JUSB2.13 295.94,189.73 ; JUSB2.13 297.12,187.97 ; JUSB1.10 285.79,211.72 ; JUSB1.10 286.67,208.17 ; JUSB1.10 284.91,208.17 ; JUSB1.10 286.67,209.94 ; JUSB1.10 285.79,208.17 ; JUSB1.10 286.67,211.72 ; JHDMI1.2 14.94,211.04 ; JHDMI1.2 14.94,209.87 ; JHDMI1.2 14.48,209.99 ; JHDMI1.2 15.4,209.99 ; JHDMI1.2 14.48,210.92 ; JHDMI1.2 14.36,210.45 ; JHDMI1.2 15.4,210.92 ; JSATA2.4 164.54,34.16 ; JSATA2.4 163.34,33.63 ; JSATA2.4 164.69,33.63 ; JSATA2.4 163.49,34.16 ; 226.2,44.15 H19.1 ; H19.1 228.96,42.98 ; H19.1 228.96,45.32 ; H19.1 227.79,42.56 ; H19.1 226.62,45.32 ; H19.1 226.62,42.98 ; H19.1 227.79,45.74 ; H19.1 229.38,44.15 ; 151.13,74.48 H9.1 ; H9.1 152.65,73.92 ; H9.1 150.57,76 ; H9.1 154.17,74.48 ; H9.1 151.13,77.52 ; H9.1 154.73,76 ; H9.1 154.17,77.52 ; H9.1 152.65,78.08 ; JDOCK1.155 143.64,160.35 ; JDOCK1.155 141.54,162.3 ; JDOCK1.155 143.64,161.33 ; JDOCK1.155 141.54,160.35 ; JDOCK1.155 143.64,162.3 ; JDOCK1.155 142.59,162.3 ; JDOCK1.155 142.59,160.35 ; JDOCK1.155 141.54,161.33 ; H12.1 234.59,152.78 ; H12.1 236.01,149.43 ; H12.1 233.17,152.27 ; H12.1 233.17,149.43 ; H12.1 232.66,150.85 ; H12.1 236.01,152.27 ; H12.1 236.52,150.85 ; H12.1 234.59,148.92 ; JSATA2.17 168.59,32.6 ; JSATA2.17 167.39,33.13 ; JSATA2.17 168.44,32.07 ; JSATA2.17 167.91,31.93 ; JSATA2.17 168.44,33.13 ; JSATA2.17 167.39,32.07 ; JSATA2.17 167.91,33.27 ; JSATA2.17 167.24,32.6 ; 289.5,189.73 JUSB2.12 ; JUSB2.12 292.54,188.85 ; JUSB2.12 292.54,187.97 ; JUSB2.12 291.02,187.97 ; JUSB2.12 291.02,189.73 ; JUSB2.12 289.5,187.97 ; JUSB2.12 289.5,188.85 ; JUSB2.12 292.54,189.73 ; H3.1 102.15,107.78 ; H3.1 100.63,107.22 ; H3.1 100.07,105.7 ; H3.1 103.67,104.18 ; H3.1 103.67,107.22 ; H3.1 100.63,104.18 ; H3.1 102.15,103.62 ; H3.1 104.23,105.7 ; JSATA2.32 165.81,28.48 ; JSATA2.32 165.81,26.92 ; JSATA2.32 167.21,27.7 ; JSATA2.32 167.21,26.92 ; JSATA2.32 164.42,26.92 ; JSATA2.32 167.21,28.48 ; JSATA2.32 164.42,28.48 ; JSATA2.32 164.42,27.7 ; JDOCK1.156 161.15,160.35 ; JDOCK1.156 157.03,162.3 ; JDOCK1.156 157.03,160.35 ; JDOCK1.156 159.09,162.3 ; JDOCK1.156 161.15,161.33 ; JDOCK1.156 159.09,160.35 ; JDOCK1.156 161.15,162.3 ; JDOCK1.156 157.03,161.33 ; 21.98,211.54 JHDMI1.17 ; JHDMI1.17 22.9,211.54 ; JHDMI1.17 21.98,212.47 ; JHDMI1.17 22.9,212.47 ; JHDMI1.17 22.44,212.59 ; JHDMI1.17 22.44,211.42 ; JDOCK1.153 116.15,162.3 ; JDOCK1.153 114.09,160.35 ; JDOCK1.153 112.03,160.35 ; JDOCK1.153 116.15,160.35 ; JDOCK1.153 112.03,162.3 ; JDOCK1.153 112.03,161.33 ; JDOCK1.153 116.15,161.33 ; JDOCK1.153 114.09,162.3 ; 291.02,181.77 JUSB3.10 ; JUSB3.10 289.5,182.65 ; JUSB3.10 289.5,181.77 ; JUSB3.10 291.02,183.53 ; JUSB3.10 292.54,183.53 ; JUSB3.10 292.54,182.65 ; JUSB3.10 289.5,183.53 ; JUSB3.10 292.54,181.77 ; JSATA2.7 164.54,37.97 ; JSATA2.7 164.01,38.11 ; JSATA2.7 163.34,37.44 ; JSATA2.7 163.49,37.97 ; JSATA2.7 164.69,37.44 ; JDOCK1.145 113.47,163.27 ; JDOCK1.145 112.42,163.27 ; JDOCK1.145 111.36,165.25 ; JDOCK1.145 113.47,167.23 ; JDOCK1.145 113.47,165.25 ; JDOCK1.145 112.42,167.23 ; H7.1 183.39,169.65 ; H7.1 184.81,166.3 ; H7.1 185.32,167.72 ; H7.1 184.81,169.14 ; H7.1 181.46,167.72 ; H7.1 181.97,169.14 ; H7.1 181.97,166.3 ; H7.1 183.39,165.79 ; H10.1 80.09,20.71 ; H10.1 81.51,17.36 ; H10.1 78.67,17.36 ; H10.1 78.67,20.2 ; H10.1 81.51,20.2 ; H10.1 82.02,18.78 ; H10.1 80.09,16.85 ; H10.1 78.16,18.78 ; JDOCK1.158 131.39,166.05 ; JDOCK1.158 129.79,164.45 ; JDOCK1.158 130.59,164.2 ; JDOCK1.158 129.79,166.05 ; JDOCK1.158 130.59,166.3 ; JDOCK1.158 129.54,165.25 ; JDOCK1.158 131.64,165.25 ; JUSB1.4 275.11,207.56 ; JUSB1.4 273.91,207.04 ; JUSB1.4 273.77,207.56 ; JUSB1.4 274.97,207.04 ; JUSB1.4 274.44,206.89 ; JUSB1.4 274.97,208.09 ; JUSB1.4 273.91,208.09 ; JDOCK1.162 130.59,170.15 ; JDOCK1.162 131.64,169.18 ; JDOCK1.162 131.64,168.2 ; JDOCK1.162 129.54,169.18 ; JDOCK1.162 131.64,170.15 ; JDOCK1.162 129.54,170.15 ; JDOCK1.162 130.59,168.2 ; 87.86,167.72 H11.1 ; H11.1 91.21,166.3 ; H11.1 88.37,166.3 ; H11.1 89.79,169.65 ; H11.1 91.21,169.14 ; H11.1 88.37,169.14 ; H11.1 89.79,165.79 ; H11.1 91.72,167.72 ; 255.68,161.85 H14.1 ; H14.1 259.2,160.36 ; H14.1 256.22,160.36 ; H14.1 257.71,159.82 ; H14.1 259.74,161.85 ; H14.1 256.22,163.34 ; H14.1 259.2,163.34 ; H14.1 257.71,163.88 ; H6.1 152.65,107.78 ; H6.1 152.65,103.62 ; H6.1 151.13,104.18 ; H6.1 154.73,105.7 ; H6.1 154.17,104.18 ; H6.1 154.17,107.22 ; H6.1 150.57,105.7 ; H6.1 151.13,107.22 ; 163.69,47.12 JSATA2.12 ; JSATA2.12 163.69,48.18 ; JSATA2.12 164.21,48.32 ; JSATA2.12 164.21,46.98 ; JSATA2.12 163.54,47.65 ; JSATA2.12 164.89,47.65 ; 141.54,165.25 JDOCK1.159 ; JDOCK1.159 143.39,166.05 ; JDOCK1.159 141.79,166.05 ; JDOCK1.159 142.59,166.3 ; JDOCK1.159 142.59,164.2 ; JDOCK1.159 143.64,165.25 ; JDOCK1.159 143.39,164.45 ; JDOCK1.159 141.79,164.45 ; JSATA1.24 81.2,65.69 ; JSATA1.24 79.4,63.58 ; JSATA1.24 81.2,63.58 ; JSATA1.24 77.6,65.69 ; JSATA1.24 81.2,64.63 ; JSATA1.24 77.6,63.58 ; JSATA1.24 77.6,64.63 ; JSATA1.24 79.4,65.69 ; JUSB2.11 298.3,202.53 ; JUSB2.11 298.3,200.77 ; JUSB2.11 295.94,201.65 ; JUSB2.11 295.94,200.77 ; JUSB2.11 295.94,202.53 ; JUSB2.11 297.12,202.53 ; JUSB2.11 298.3,201.65 ; JUSB2.11 297.12,200.77 ; H15.1 91.71,138.67 ; H15.1 92.27,137.15 ; H15.1 88.67,135.63 ; H15.1 90.19,139.23 ; H15.1 88.11,137.15 ; H15.1 90.19,135.07 ; H15.1 91.71,135.63 ; H15.1 88.67,138.67 ; JDOCK1.157 119.39,164.45 ; JDOCK1.157 118.59,164.2 ; JDOCK1.157 117.79,164.45 ; JDOCK1.157 117.54,165.25 ; JDOCK1.157 118.59,166.3 ; JDOCK1.157 119.39,166.05 ; JDOCK1.157 117.79,166.05 ; 78.86,167.77 PBATT1.10 ; PBATT1.10 80.97,167.77 ; PBATT1.10 78.86,169.75 ; PBATT1.10 80.97,169.75 ; PBATT1.10 79.92,167.77 ; 8.86,217.22 JHDMI1.21 ; JHDMI1.21 9.79,219.79 ; JHDMI1.21 10.72,219.79 ; JHDMI1.21 9.79,217.22 ; JHDMI1.21 10.72,218.5 ; JHDMI1.21 8.86,218.5 ; JHDMI1.21 10.72,217.22 ; JHDMI1.21 8.86,219.79 ; JHDMI1.22 27.12,210.3 ; JHDMI1.22 27.12,209.02 ; JHDMI1.22 26.19,209.02 ; JHDMI1.22 26.19,211.59 ; JHDMI1.22 25.26,210.3 ; JHDMI1.22 25.26,211.59 ; JHDMI1.22 25.26,209.02 ; JHDMI1.22 27.12,211.59 ; JDOCK1.163 143.64,169.18 ; JDOCK1.163 143.64,170.15 ; JDOCK1.163 142.59,168.2 ; JDOCK1.163 143.64,168.2 ; JDOCK1.163 141.54,169.18 ; JDOCK1.163 141.54,170.15 ; JDOCK1.163 141.54,168.2 ; JDOCK1.163 142.59,170.15 ; 295.94,183.53 JUSB3.11 ; JUSB3.11 297.12,181.77 ; JUSB3.11 298.3,183.53 ; JUSB3.11 295.94,182.65 ; JUSB3.11 295.94,181.77 ; JUSB3.11 297.12,183.53 ; JUSB3.11 298.3,181.77 ; JUSB3.11 298.3,182.65 ; 3.89,190.81 H2.1 ; H2.1 2.19,191.45 ; H2.1 5.59,194.85 ; H2.1 6.23,193.15 ; H2.1 1.55,193.15 ; H2.1 2.19,194.85 ; H2.1 5.59,191.45 ; H2.1 3.89,195.49 ; 277.41,208.54 JUSB1.7 ; JUSB1.7 278.47,208.54 ; JUSB1.7 278.61,209.06 ; JUSB1.7 278.47,209.59 ; JUSB1.7 277.94,208.39 ; JUSB1.7 277.41,209.59 ; JUSB1.7 277.27,209.06 ; 164.69,48.12 JSATA2.13 ; JSATA2.13 165.74,48.12 ; JSATA2.13 165.89,48.65 ; JSATA2.13 165.74,49.18 ; JSATA2.13 165.21,47.98 ; JSATA2.13 165.21,49.32 ; JSATA2.13 164.69,49.18 ; JSATA2.13 164.54,48.65 ; 164.99,37.67 JSATA2.24 ; JSATA2.24 166.19,38.2 ; JSATA2.24 165.52,38.87 ; JSATA2.24 165.52,37.53 ; JSATA2.24 166.04,37.67 ; JSATA2.24 166.04,38.73 ; JSATA2.24 164.99,38.73 ; JSATA2.24 164.84,38.2 ; 153.79,164.45 JDOCK1.160 ; JDOCK1.160 155.39,164.45 ; JDOCK1.160 154.59,164.2 ; JDOCK1.160 155.39,166.05 ; JDOCK1.160 154.59,166.3 ; JDOCK1.160 155.64,165.25 ; JDOCK1.160 153.79,166.05 ; 10.76,210.3 JHDMI1.20 ; JHDMI1.20 10.76,209.02 ; JHDMI1.20 11.69,211.59 ; JHDMI1.20 12.62,211.59 ; JHDMI1.20 10.76,211.59 ; JHDMI1.20 12.62,209.02 ; JHDMI1.20 12.62,210.3 ; JHDMI1.20 11.69,209.02 ; 78.67,81.93 H8.1 ; H8.1 78.67,84.77 ; H8.1 82.02,83.35 ; H8.1 78.16,83.35 ; H8.1 80.09,81.42 ; H8.1 81.51,84.77 ; H8.1 81.51,81.93 ; H8.1 80.09,85.28 ; 293.49,206.37 H13.1 ; H13.1 292.07,209.72 ; H13.1 295.42,208.3 ; H13.1 292.07,206.88 ; H13.1 293.49,210.23 ; H13.1 291.56,208.3 ; H13.1 294.91,209.72 ; H13.1 294.91,206.88 ; 129.54,160.35 JDOCK1.154 ; JDOCK1.154 129.54,161.33 ; JDOCK1.154 129.54,162.3 ; JDOCK1.154 131.64,160.35 ; JDOCK1.154 130.59,160.35 ; JDOCK1.154 131.64,161.33 ; JDOCK1.154 130.59,162.3 ; JDOCK1.152 161.82,163.27 ; JDOCK1.152 159.71,165.25 ; JDOCK1.152 159.71,167.23 ; JDOCK1.152 159.71,163.27 ; JDOCK1.152 160.76,163.27 ; JDOCK1.152 160.76,167.23 ; JDOCK1.152 161.82,167.23 ; JDOCK1.152 161.82,165.25 ; H1.1 3.89,172.19 ; H1.1 2.19,168.15 ; H1.1 5.59,171.55 ; H1.1 5.59,168.15 ; H1.1 6.23,169.85 ; H1.1 3.89,167.51 ; H1.1 1.55,169.85 ; H1.1 2.19,171.55 ; PBATT1.11 58.72,167.77 ; PBATT1.11 57.67,167.77 ; PBATT1.11 56.61,167.77 ; PBATT1.11 56.61,169.75 ; PBATT1.11 58.72,169.75
  GND2 w0.203: 130.59,168.2 JDOCK1.162 ; JDOCK1.162 131.64,169.18 ; JDOCK1.162 131.64,168.2 ; JDOCK1.162 131.64,170.15 ; JDOCK1.162 129.54,170.15 ; JDOCK1.162 129.54,169.18 ; JDOCK1.162 130.59,170.15 ; 295.94,200.77 JUSB2.11 ; JUSB2.11 295.94,201.65 ; JUSB2.11 298.3,202.53 ; JUSB2.11 297.12,200.77 ; JUSB2.11 298.3,201.65 ; JUSB2.11 295.94,202.53 ; JUSB2.11 298.3,200.77 ; JUSB2.11 297.12,202.53 ; JSATA2.1 164.54,29.29 ; JSATA2.1 164.01,29.15 ; JSATA2.1 164.69,29.82 ; JSATA2.1 164.54,30.35 ; JSATA2.1 163.34,29.82 ; JSATA2.1 163.49,30.35 ; JSATA2.1 163.49,29.29 ; JUSB1.11 286.67,218.42 ; JUSB1.11 286.67,217.04 ; JUSB1.11 285.79,218.42 ; JUSB1.11 286.67,215.67 ; JUSB1.11 285.79,215.67 ; 3.89,167.51 H1.1 ; H1.1 5.59,171.55 ; H1.1 5.59,168.15 ; H1.1 6.23,169.85 ; H1.1 3.89,172.19 ; H1.1 2.19,168.15 ; H1.1 2.19,171.55 ; H1.1 1.55,169.85 ; 78.16,18.78 H10.1 ; H10.1 82.02,18.78 ; H10.1 81.51,20.2 ; H10.1 80.09,20.71 ; H10.1 80.09,16.85 ; H10.1 78.67,20.2 ; H10.1 81.51,17.36 ; H10.1 78.67,17.36 ; 28.09,218.47 JHDMI1.23 ; JHDMI1.23 29.02,219.75 ; JHDMI1.23 27.16,221.04 ; JHDMI1.23 27.16,219.75 ; JHDMI1.23 27.16,218.47 ; JHDMI1.23 29.02,221.04 ; JHDMI1.23 28.09,221.04 ; JHDMI1.23 29.02,218.47 ; JUSB1.10 286.67,208.17 ; JUSB1.10 285.79,211.72 ; JUSB1.10 285.79,208.17 ; JUSB1.10 286.67,209.94 ; JUSB1.10 286.67,211.72 ; JUSB1.10 284.91,208.17 ; 129.54,160.35 JDOCK1.154 ; JDOCK1.154 129.54,162.3 ; JDOCK1.154 129.54,161.33 ; JDOCK1.154 130.59,160.35 ; JDOCK1.154 131.64,160.35 ; JDOCK1.154 130.59,162.3 ; JDOCK1.154 131.64,161.33 ; 129.79,164.45 JDOCK1.158 ; JDOCK1.158 130.59,164.2 ; JDOCK1.158 130.59,166.3 ; JDOCK1.158 129.79,166.05 ; JDOCK1.158 129.54,165.25 ; JDOCK1.158 131.64,165.25 ; JDOCK1.158 131.39,166.05 ; 291.02,181.77 JUSB3.10 ; JUSB3.10 289.5,181.77 ; JUSB3.10 292.54,183.53 ; JUSB3.10 291.02,183.53 ; JUSB3.10 289.5,183.53 ; JUSB3.10 289.5,182.65 ; JUSB3.10 292.54,182.65 ; JUSB3.10 292.54,181.77 ; 157.03,170.15 JDOCK1.164 ; JDOCK1.164 157.03,168.2 ; JDOCK1.164 159.09,170.15 ; JDOCK1.164 161.15,168.2 ; JDOCK1.164 159.09,168.2 ; JDOCK1.164 157.03,169.18 ; JDOCK1.164 161.15,169.18 ; JDOCK1.164 161.15,170.15 ; 112.03,161.33 JDOCK1.153 ; JDOCK1.153 112.03,160.35 ; JDOCK1.153 114.09,162.3 ; JDOCK1.153 116.15,162.3 ; JDOCK1.153 114.09,160.35 ; JDOCK1.153 116.15,160.35 ; JDOCK1.153 116.15,161.33 ; JDOCK1.153 112.03,162.3 ; JUSB1.7 278.47,209.59 ; JUSB1.7 278.47,208.54 ; JUSB1.7 277.41,208.54 ; JUSB1.7 278.61,209.06 ; JUSB1.7 277.94,208.39 ; JUSB1.7 277.41,209.59 ; JUSB1.7 277.27,209.06 ; JSATA2.13 165.74,49.18 ; JSATA2.13 165.74,48.12 ; JSATA2.13 164.69,48.12 ; JSATA2.13 165.21,49.32 ; JSATA2.13 165.21,47.98 ; JSATA2.13 164.54,48.65 ; JSATA2.13 164.69,49.18 ; JSATA2.13 165.89,48.65 ; H23.1 61.87,117.05 ; H23.1 57.71,117.05 ; H23.1 58.27,115.53 ; H23.1 61.31,115.53 ; H23.1 59.79,114.97 ; H23.1 58.27,118.57 ; H23.1 61.31,118.57 ; H23.1 59.79,119.13 ; 22.44,211.42 JHDMI1.17 ; JHDMI1.17 21.98,211.54 ; JHDMI1.17 21.98,212.47 ; JHDMI1.17 22.9,212.47 ; JHDMI1.17 22.9,211.54 ; JHDMI1.17 22.44,212.59 ; JUSB1.12 270.09,218.42 ; JUSB1.12 269.21,217.04 ; JUSB1.12 269.21,218.42 ; JUSB1.12 270.09,215.67 ; JUSB1.12 269.21,215.67 ; PBATT1.2 63.46,170.42 ; PBATT1.2 62.12,169.08 ; PBATT1.2 61.91,169.75 ; PBATT1.2 62.12,170.42 ; PBATT1.2 63.67,169.75 ; PBATT1.2 63.46,169.08 ; PBATT1.2 62.79,168.87 ; PBATT1.2 62.79,170.63 ; JUSB2.4 291.52,199.53 ; JUSB2.4 290.92,198.15 ; JUSB2.4 292.12,199.35 ; JUSB2.4 290.92,199.35 ; JUSB2.4 290.74,198.75 ; JUSB2.4 292.12,198.15 ; JUSB2.4 292.3,198.75 ; JUSB2.4 291.52,197.97 ; JSATA2.33 167.21,49.92 ; JSATA2.33 167.21,50.7 ; JSATA2.33 164.42,50.7 ; JSATA2.33 164.42,51.48 ; JSATA2.33 165.81,49.92 ; JSATA2.33 164.42,49.92 ; JSATA2.33 165.81,51.48 ; JSATA2.33 167.21,51.48 ; H13.1 295.42,208.3 ; H13.1 293.49,210.23 ; H13.1 294.91,209.72 ; H13.1 292.07,206.88 ; H13.1 292.07,209.72 ; H13.1 291.56,208.3 ; H13.1 294.91,206.88 ; H13.1 293.49,206.37 ; 226.2,23.15 H18.1 ; H18.1 228.96,21.98 ; H18.1 227.79,24.74 ; H18.1 226.62,24.32 ; H18.1 228.96,24.32 ; H18.1 226.62,21.98 ; H18.1 229.38,23.15 ; H18.1 227.79,21.56 ; JUSB3.13 298.3,168.97 ; JUSB3.13 295.94,168.97 ; JUSB3.13 295.94,169.85 ; JUSB3.13 297.12,170.73 ; JUSB3.13 298.3,170.73 ; JUSB3.13 297.12,168.97 ; JUSB3.13 298.3,169.85 ; JUSB3.13 295.94,170.73 ; 157.03,160.35 JDOCK1.156 ; JDOCK1.156 157.03,161.33 ; JDOCK1.156 161.15,161.33 ; JDOCK1.156 157.03,162.3 ; JDOCK1.156 161.15,160.35 ; JDOCK1.156 161.15,162.3 ; JDOCK1.156 159.09,162.3 ; JDOCK1.156 159.09,160.35 ; 112.03,169.18 JDOCK1.161 ; JDOCK1.161 116.15,168.2 ; JDOCK1.161 112.03,170.15 ; JDOCK1.161 112.03,168.2 ; JDOCK1.161 114.09,168.2 ; JDOCK1.161 114.09,170.15 ; JDOCK1.161 116.15,170.15 ; JDOCK1.161 116.15,169.18 ; 273.91,208.09 JUSB1.4 ; JUSB1.4 274.97,208.09 ; JUSB1.4 275.11,207.56 ; JUSB1.4 274.44,206.89 ; JUSB1.4 273.91,207.04 ; JUSB1.4 273.77,207.56 ; JUSB1.4 274.44,208.24 ; JUSB1.4 274.97,207.04 ; JSATA1.24 81.2,63.58 ; JSATA1.24 79.4,63.58 ; JSATA1.24 77.6,64.63 ; JSATA1.24 77.6,65.69 ; JSATA1.24 81.2,64.63 ; JSATA1.24 81.2,65.69 ; JSATA1.24 77.6,63.58 ; JSATA1.24 79.4,65.69 ; 151.13,104.18 H6.1 ; H6.1 152.65,107.78 ; H6.1 154.17,107.22 ; H6.1 151.13,107.22 ; H6.1 154.17,104.18 ; H6.1 150.57,105.7 ; H6.1 154.73,105.7 ; H6.1 152.65,103.62 ; H5.1 102.15,78.08 ; H5.1 102.15,73.92 ; H5.1 100.63,77.52 ; H5.1 100.63,74.48 ; H5.1 103.67,74.48 ; H5.1 100.07,76 ; H5.1 104.23,76 ; H5.1 103.67,77.52 ; JSATA2.24 166.19,38.2 ; JSATA2.24 165.52,37.53 ; JSATA2.24 165.52,38.87 ; JSATA2.24 166.04,37.67 ; JSATA2.24 164.99,37.67 ; JSATA2.24 166.04,38.73 ; JSATA2.24 164.84,38.2 ; JSATA2.24 164.99,38.73 ; 151.13,77.52 H9.1 ; H9.1 154.73,76 ; H9.1 152.65,73.92 ; H9.1 150.57,76 ; H9.1 152.65,78.08 ; H9.1 154.17,77.52 ; H9.1 151.13,74.48 ; H9.1 154.17,74.48 ; 255.68,161.85 H14.1 ; H14.1 259.2,160.36 ; H14.1 256.22,160.36 ; H14.1 257.71,163.88 ; H14.1 257.71,159.82 ; H14.1 259.74,161.85 ; H14.1 259.2,163.34 ; H14.1 256.22,163.34 ; 295.94,181.77 JUSB3.11 ; JUSB3.11 297.12,181.77 ; JUSB3.11 298.3,183.53 ; JUSB3.11 297.12,183.53 ; JUSB3.11 295.94,183.53 ; JUSB3.11 298.3,181.77 ; JUSB3.11 295.94,182.65 ; JUSB3.11 298.3,182.65 ; 289.24,176.25 JUSB3.7 ; JUSB3.7 289.42,175.65 ; JUSB3.7 290.02,175.48 ; JUSB3.7 289.42,176.85 ; JUSB3.7 290.62,175.65 ; JUSB3.7 290.02,177.03 ; JUSB3.7 290.79,176.25 ; JUSB3.7 290.62,176.85 ; PBATT1.10 80.97,169.75 ; PBATT1.10 79.92,167.77 ; PBATT1.10 80.97,167.77 ; PBATT1.10 78.86,169.75 ; PBATT1.10 78.86,167.77 ; JUSB3.12 292.54,170.73 ; JUSB3.12 292.54,168.97 ; JUSB3.12 289.5,168.97 ; JUSB3.12 289.5,169.85 ; JUSB3.12 289.5,170.73 ; JUSB3.12 291.02,168.97 ; JUSB3.12 292.54,169.85 ; JUSB3.12 291.02,170.73 ; 88.67,138.67 H15.1 ; H15.1 90.19,135.07 ; H15.1 88.67,135.63 ; H15.1 91.71,135.63 ; H15.1 91.71,138.67 ; H15.1 90.19,139.23 ; H15.1 88.11,137.15 ; H15.1 92.27,137.15 ; JDOCK1.155 143.64,162.3 ; JDOCK1.155 141.54,162.3 ; JDOCK1.155 142.59,160.35 ; JDOCK1.155 143.64,161.33 ; JDOCK1.155 143.64,160.35 ; JDOCK1.155 141.54,160.35 ; JDOCK1.155 142.59,162.3 ; JDOCK1.155 141.54,161.33 ; PBATT1.4 67.46,170.42 ; PBATT1.4 65.91,169.75 ; PBATT1.4 67.67,169.75 ; PBATT1.4 66.12,170.42 ; PBATT1.4 67.46,169.08 ; PBATT1.4 66.79,168.87 ; PBATT1.4 66.79,170.63 ; PBATT1.4 66.12,169.08 ; JDOCK1.159 143.64,165.25 ; JDOCK1.159 141.79,166.05 ; JDOCK1.159 141.54,165.25 ; JDOCK1.159 142.59,166.3 ; JDOCK1.159 143.39,166.05 ; JDOCK1.159 141.79,164.45 ; JDOCK1.159 142.59,164.2 ; JDOCK1.159 143.39,164.45 ; 78.67,81.93 H8.1 ; H8.1 82.02,83.35 ; H8.1 81.51,81.93 ; H8.1 81.51,84.77 ; H8.1 80.09,85.28 ; H8.1 78.16,83.35 ; H8.1 80.09,81.42 ; H8.1 78.67,84.77 ; 289.5,189.73 JUSB2.12 ; JUSB2.12 289.5,187.97 ; JUSB2.12 292.54,187.97 ; JUSB2.12 292.54,188.85 ; JUSB2.12 291.02,189.73 ; JUSB2.12 289.5,188.85 ; JUSB2.12 292.54,189.73 ; JUSB2.12 291.02,187.97 ; 234.59,148.92 H12.1 ; H12.1 233.17,149.43 ; H12.1 236.01,149.43 ; H12.1 236.01,152.27 ; H12.1 233.17,152.27 ; H12.1 236.52,150.85 ; H12.1 232.66,150.85 ; H12.1 234.59,152.78 ; H22.1 250.59,88.83 ; H22.1 248.51,86.75 ; H22.1 252.11,85.23 ; H22.1 249.07,88.27 ; H22.1 252.11,88.27 ; H22.1 252.67,86.75 ; H22.1 250.59,84.67 ; H22.1 249.07,85.23 ; 117.79,164.45 JDOCK1.157 ; JDOCK1.157 117.79,166.05 ; JDOCK1.157 117.54,165.25 ; JDOCK1.157 119.39,164.45 ; JDOCK1.157 119.39,166.05 ; JDOCK1.157 118.59,166.3 ; JDOCK1.157 118.59,164.2 ; 164.99,36.33 JSATA2.21 ; JSATA2.21 164.84,35.8 ; JSATA2.21 165.52,36.47 ; JSATA2.21 165.52,35.13 ; JSATA2.21 164.99,35.27 ; JSATA2.21 166.19,35.8 ; JSATA2.21 166.04,35.27 ; JSATA2.21 166.04,36.33 ; 289.42,195.85 JUSB2.7 ; JUSB2.7 289.24,195.25 ; JUSB2.7 290.02,194.48 ; JUSB2.7 290.62,195.85 ; JUSB2.7 289.42,194.65 ; JUSB2.7 290.79,195.25 ; JUSB2.7 290.62,194.65 ; JUSB2.7 290.02,196.03 ; 56.61,167.77 PBATT1.11 ; PBATT1.11 58.72,169.75 ; PBATT1.11 58.72,167.77 ; PBATT1.11 56.61,169.75 ; PBATT1.11 57.67,167.77 ; H11.1 91.72,167.72 ; H11.1 89.79,169.65 ; H11.1 87.86,167.72 ; H11.1 91.21,169.14 ; H11.1 91.21,166.3 ; H11.1 88.37,166.3 ; H11.1 89.79,165.79 ; H11.1 88.37,169.14 ; JSATA1.23 81.2,26.16 ; JSATA1.23 79.4,26.16 ; JSATA1.23 81.2,27.22 ; JSATA1.23 77.6,28.27 ; JSATA1.23 79.4,28.27 ; JSATA1.23 81.2,28.27 ; JSATA1.23 77.6,27.22 ; JSATA1.23 77.6,26.16 ; 167.91,34.33 JSATA2.20 ; JSATA2.20 168.59,35 ; JSATA2.20 167.39,34.47 ; JSATA2.20 168.44,34.47 ; JSATA2.20 167.24,35 ; JSATA2.20 167.39,35.53 ; JSATA2.20 168.44,35.53 ; JSATA2.20 167.91,35.67 ; PBATT1.1 60.79,170.63 ; PBATT1.1 61.46,170.42 ; PBATT1.1 61.46,169.08 ; PBATT1.1 60.12,170.42 ; PBATT1.1 60.79,168.87 ; PBATT1.1 61.67,169.75 ; PBATT1.1 60.12,169.08 ; PBATT1.1 59.91,169.75 ; JUSB2.10 292.54,201.65 ; JUSB2.10 291.02,202.53 ; JUSB2.10 289.5,202.53 ; JUSB2.10 292.54,200.77 ; JUSB2.10 291.02,200.77 ; JUSB2.10 292.54,202.53 ; JUSB2.10 289.5,201.65 ; JUSB2.10 289.5,200.77 ; JHDMI1.22 27.12,211.59 ; JHDMI1.22 27.12,209.02 ; JHDMI1.22 25.26,210.3 ; JHDMI1.22 25.26,211.59 ; JHDMI1.22 25.26,209.02 ; JHDMI1.22 27.12,210.3 ; JHDMI1.22 26.19,209.02 ; JHDMI1.22 26.19,211.59 ; H4.1 169.01,17.27 ; H4.1 165.66,15.85 ; H4.1 166.17,14.43 ; H4.1 169.52,15.85 ; H4.1 167.59,17.78 ; H4.1 167.59,13.92 ; H4.1 169.01,14.43 ; H4.1 166.17,17.27 ; JSATA2.17 168.59,32.6 ; JSATA2.17 167.39,33.13 ; JSATA2.17 167.24,32.6 ; JSATA2.17 168.44,33.13 ; JSATA2.17 167.91,33.27 ; JSATA2.17 168.44,32.07 ; JSATA2.17 167.91,31.93 ; JSATA2.17 167.39,32.07 ; 15.98,211.54 JHDMI1.5 ; JHDMI1.5 16.44,211.42 ; JHDMI1.5 15.98,212.47 ; JHDMI1.5 16.9,211.54 ; JHDMI1.5 16.9,212.47 ; JHDMI1.5 16.44,212.59 ; JSATA2.32 167.21,26.92 ; JSATA2.32 167.21,27.7 ; JSATA2.32 165.81,26.92 ; JSATA2.32 164.42,28.48 ; JSATA2.32 167.21,28.48 ; JSATA2.32 164.42,27.7 ; JSATA2.32 164.42,26.92 ; JSATA2.32 165.81,28.48 ; 8.86,217.22 JHDMI1.21 ; JHDMI1.21 10.72,219.79 ; JHDMI1.21 10.72,218.5 ; JHDMI1.21 8.86,219.79 ; JHDMI1.21 9.79,219.79 ; JHDMI1.21 8.86,218.5 ; JHDMI1.21 9.79,217.22 ; JHDMI1.21 10.72,217.22 ; 10.76,211.59 JHDMI1.20 ; JHDMI1.20 11.69,211.59 ; JHDMI1.20 12.62,211.59 ; JHDMI1.20 12.62,209.02 ; JHDMI1.20 11.69,209.02 ; JHDMI1.20 12.62,210.3 ; JHDMI1.20 10.76,210.3 ; JHDMI1.20 10.76,209.02 ; JSATA2.14 167.91,30.87 ; JSATA2.14 167.24,30.2 ; JSATA2.14 167.39,30.73 ; JSATA2.14 168.44,30.73 ; JSATA2.14 168.44,29.67 ; JSATA2.14 167.91,29.53 ; JSATA2.14 167.39,29.67 ; JSATA2.14 168.59,30.2 ; 290.74,179.75 JUSB3.4 ; JUSB3.4 290.92,180.35 ; JUSB3.4 292.12,179.15 ; JUSB3.4 292.3,179.75 ; JUSB3.4 291.52,180.53 ; JUSB3.4 292.12,180.35 ; JUSB3.4 290.92,179.15 ; JUSB3.4 291.52,178.98 ; H16.1 49.34,148.28 ; H16.1 47.82,144.68 ; H16.1 49.34,144.12 ; H16.1 51.42,146.2 ; H16.1 47.82,147.72 ; H16.1 50.86,147.72 ; H16.1 47.26,146.2 ; H16.1 50.86,144.68 ; JHDMI1.11 19.9,211.54 ; JHDMI1.11 19.44,212.59 ; JHDMI1.11 19.9,212.47 ; JHDMI1.11 19.44,211.42 ; JHDMI1.11 18.98,212.47 ; JHDMI1.11 18.98,211.54 ; 17.94,209.87 JHDMI1.8 ; JHDMI1.8 17.48,210.92 ; JHDMI1.8 17.48,209.99 ; JHDMI1.8 17.94,211.04 ; JHDMI1.8 18.4,210.92 ; JHDMI1.8 18.4,209.99 ; 163.49,37.97 JSATA2.7 ; JSATA2.7 164.69,37.44 ; JSATA2.7 164.54,37.97 ; JSATA2.7 164.01,38.11 ; JSATA2.7 163.34,37.44 ; JSATA2.7 164.54,36.91 ; JSATA2.7 163.49,36.91 ; H3.1 103.67,107.22 ; H3.1 100.63,107.22 ; H3.1 103.67,104.18 ; H3.1 102.15,107.78 ; H3.1 100.07,105.7 ; H3.1 100.63,104.18 ; H3.1 102.15,103.62 ; H3.1 104.23,105.7 ; 153.79,166.05 JDOCK1.160 ; JDOCK1.160 155.64,165.25 ; JDOCK1.160 154.59,166.3 ; JDOCK1.160 153.79,164.45 ; JDOCK1.160 154.59,164.2 ; JDOCK1.160 155.39,166.05 ; JDOCK1.160 155.39,164.45 ; JDOCK1.145 113.47,165.25 ; JDOCK1.145 113.47,163.27 ; JDOCK1.145 113.47,167.23 ; JDOCK1.145 112.42,167.23 ; JDOCK1.145 112.42,163.27 ; JDOCK1.145 111.36,165.25 ; H19.1 228.96,42.98 ; H19.1 226.62,42.98 ; H19.1 226.2,44.15 ; H19.1 227.79,42.56 ; H19.1 227.79,45.74 ; H19.1 228.96,45.32 ; H19.1 229.38,44.15 ; H19.1 226.62,45.32 ; JDOCK1.163 143.64,169.18 ; JDOCK1.163 143.64,168.2 ; JDOCK1.163 141.54,168.2 ; JDOCK1.163 142.59,168.2 ; JDOCK1.163 141.54,169.18 ; JDOCK1.163 142.59,170.15 ; JDOCK1.163 141.54,170.15 ; JDOCK1.163 143.64,170.15 ; 181.97,169.14 H7.1 ; H7.1 184.81,169.14 ; H7.1 184.81,166.3 ; H7.1 183.39,165.79 ; H7.1 181.97,166.3 ; H7.1 183.39,169.65 ; H7.1 185.32,167.72 ; H7.1 181.46,167.72 ; JUSB1.13 270.97,208.17 ; JUSB1.13 269.21,208.17 ; JUSB1.13 269.21,211.72 ; JUSB1.13 270.09,211.72 ; JUSB1.13 270.09,208.17 ; JUSB1.13 269.21,209.94 ; H2.1 5.59,191.45 ; H2.1 1.55,193.15 ; H2.1 3.89,190.81 ; H2.1 3.89,195.49 ; H2.1 6.23,193.15 ; H2.1 2.19,194.85 ; H2.1 5.59,194.85 ; H2.1 2.19,191.45 ; JHDMI1.2 15.4,210.92 ; JHDMI1.2 15.4,209.99 ; JHDMI1.2 14.94,211.04 ; JHDMI1.2 14.94,209.87 ; JHDMI1.2 14.48,210.92 ; JHDMI1.2 14.36,210.45 ; JHDMI1.2 14.48,209.99 ; 159.71,163.27 JDOCK1.152 ; JDOCK1.152 160.76,163.27 ; JDOCK1.152 161.82,163.27 ; JDOCK1.152 160.76,167.23 ; JDOCK1.152 159.71,165.25 ; JDOCK1.152 159.71,167.23 ; JDOCK1.152 161.82,165.25 ; JDOCK1.152 161.82,167.23 ; JSATA2.12 164.89,47.65 ; JSATA2.12 163.69,47.12 ; JSATA2.12 163.69,48.18 ; JSATA2.12 164.21,46.98 ; JSATA2.12 164.21,48.32 ; JSATA2.12 163.54,47.65 ; 295.94,188.85 JUSB2.13 ; JUSB2.13 298.3,187.97 ; JUSB2.13 297.12,187.97 ; JUSB2.13 297.12,189.73 ; JUSB2.13 298.3,189.73 ; JUSB2.13 295.94,189.73 ; JUSB2.13 298.3,188.85 ; JSATA2.4 164.54,34.16 ; JSATA2.4 163.34,33.63 ; JSATA2.4 164.69,33.63 ; JSATA2.4 164.54,33.1 ; JSATA2.4 163.49,33.1 ; JSATA2.4 163.49,34.16
  IN2 w0.254: v3(129.57,148.58) 130.04,148.58 135.56,143.06 135.56,142.72 136.36,141.92 v3(136.36,136.96)
  VCC w0.203: JUSB3.7 290.02,177.03 ; JUSB3.7 289.24,176.25 ; JUSB3.7 289.42,176.85 ; JUSB3.7 290.62,175.65 ; JUSB3.7 290.02,175.48 ; JUSB3.7 289.42,175.65 ; JUSB3.7 290.62,176.85 ; JUSB3.7 290.79,176.25 ; 297.12,200.77 JUSB2.11 ; JUSB2.11 298.3,200.77 ; JUSB2.11 297.12,202.53 ; JUSB2.11 298.3,202.53 ; JUSB2.11 298.3,201.65 ; JUSB2.11 295.94,200.77 ; JUSB2.11 295.94,202.53 ; JUSB2.11 295.94,201.65 ; 292.07,206.88 H13.1 ; H13.1 294.91,206.88 ; H13.1 295.42,208.3 ; H13.1 292.07,209.72 ; H13.1 291.56,208.3 ; H13.1 293.49,210.23 ; H13.1 293.49,206.37 ; H13.1 294.91,209.72 ; 297.12,181.77 JUSB3.11 ; JUSB3.11 298.3,181.77 ; JUSB3.11 295.94,182.65 ; JUSB3.11 295.94,181.77 ; JUSB3.11 298.3,182.65 ; JUSB3.11 297.12,183.53 ; JUSB3.11 295.94,183.53 ; JUSB3.11 298.3,183.53 ; JUSB1.11 286.67,217.04 ; JUSB1.11 285.79,218.42 ; JUSB1.11 285.79,215.67 ; JUSB1.11 286.67,215.67 ; JUSB1.11 286.67,218.42 ; 289.42,194.65 JUSB2.7 ; JUSB2.7 289.42,195.85 ; JUSB2.7 290.02,194.48 ; JUSB2.7 289.24,195.25 ; JUSB2.7 290.02,196.03 ; JUSB2.7 290.79,195.25 ; JUSB2.7 290.62,195.85 ; JUSB2.7 290.62,194.65 ; JHDMI1.21 10.72,217.22 ; JHDMI1.21 8.86,219.79 ; JHDMI1.21 9.79,219.79 ; JHDMI1.21 10.72,218.5 ; JHDMI1.21 10.72,219.79 ; JHDMI1.21 8.86,218.5 ; JHDMI1.21 8.86,217.22 ; JHDMI1.21 9.79,217.22 ; 28.09,218.47 JHDMI1.23 ; JHDMI1.23 27.16,219.75 ; JHDMI1.23 29.02,221.04 ; JHDMI1.23 29.02,219.75 ; JHDMI1.23 27.16,221.04 ; JHDMI1.23 27.16,218.47 ; JHDMI1.23 29.02,218.47 ; JHDMI1.23 28.09,221.04 ; 273.77,207.56 JUSB1.4 ; JUSB1.4 274.97,207.04 ; JUSB1.4 273.91,208.09 ; JUSB1.4 275.11,207.56 ; JUSB1.4 273.91,207.04 ; JUSB1.4 274.97,208.09 ; JUSB1.4 274.44,206.89 ; JUSB1.4 274.44,208.24 ; 285.79,208.17 JUSB1.10 ; JUSB1.10 286.67,211.72 ; JUSB1.10 286.67,209.94 ; JUSB1.10 285.79,211.72 ; JUSB1.10 286.67,208.17 ; JUSB1.10 284.91,208.17 ; 269.21,211.72 JUSB1.13 ; JUSB1.13 270.09,211.72 ; JUSB1.13 269.21,209.94 ; JUSB1.13 269.21,208.17 ; JUSB1.13 270.97,208.17 ; JUSB1.13 270.09,208.17 ; 291.02,200.77 JUSB2.10 ; JUSB2.10 291.02,202.53 ; JUSB2.10 292.54,201.65 ; JUSB2.10 292.54,202.53 ; JUSB2.10 292.54,200.77 ; JUSB2.10 289.5,201.65 ; JUSB2.10 289.5,200.77 ; JUSB2.10 289.5,202.53 ; JHDMI1.17 22.44,212.59 ; JHDMI1.17 22.9,212.47 ; JHDMI1.17 22.9,211.54 ; JHDMI1.17 22.44,211.42 ; JHDMI1.17 21.98,212.47 ; JHDMI1.17 21.98,211.54 ; 14.94,209.87 JHDMI1.2 ; JHDMI1.2 14.36,210.45 ; JHDMI1.2 14.48,210.92 ; JHDMI1.2 15.4,209.99 ; JHDMI1.2 14.48,209.99 ; JHDMI1.2 14.94,211.04 ; JHDMI1.2 15.4,210.92 ; 291.02,168.97 JUSB3.12 ; JUSB3.12 289.5,170.73 ; JUSB3.12 291.02,170.73 ; JUSB3.12 292.54,168.97 ; JUSB3.12 289.5,169.85 ; JUSB3.12 292.54,170.73 ; JUSB3.12 292.54,169.85 ; JUSB3.12 289.5,168.97 ; JUSB3.4 292.12,179.15 ; JUSB3.4 292.12,180.35 ; JUSB3.4 291.52,178.98 ; JUSB3.4 290.92,180.35 ; JUSB3.4 292.3,179.75 ; JUSB3.4 291.52,180.53 ; JUSB3.4 290.74,179.75 ; JUSB3.4 290.92,179.15 ; 17.94,209.87 JHDMI1.8 ; JHDMI1.8 17.94,211.04 ; JHDMI1.8 17.48,210.92 ; JHDMI1.8 17.48,209.99 ; JHDMI1.8 18.4,209.99 ; JHDMI1.8 18.4,210.92 ; 289.5,189.73 JUSB2.12 ; JUSB2.12 289.5,187.97 ; JUSB2.12 291.02,189.73 ; JUSB2.12 292.54,187.97 ; JUSB2.12 291.02,187.97 ; JUSB2.12 289.5,188.85 ; JUSB2.12 292.54,188.85 ; JUSB2.12 292.54,189.73 ; H9.1 154.17,77.52 ; H9.1 150.57,76 ; H9.1 151.13,77.52 ; H9.1 152.65,78.08 ; H9.1 151.13,74.48 ; H9.1 152.65,73.92 ; H9.1 154.73,76 ; H9.1 154.17,74.48 ; JUSB2.13 298.3,187.97 ; JUSB2.13 298.3,188.85 ; JUSB2.13 295.94,189.73 ; JUSB2.13 297.12,187.97 ; JUSB2.13 298.3,189.73 ; JUSB2.13 295.94,188.85 ; JUSB2.13 297.12,189.73 ; JHDMI1.20 11.69,211.59 ; JHDMI1.20 10.76,210.3 ; JHDMI1.20 12.62,209.02 ; JHDMI1.20 10.76,209.02 ; JHDMI1.20 12.62,211.59 ; JHDMI1.20 11.69,209.02 ; JHDMI1.20 12.62,210.3 ; JHDMI1.20 10.76,211.59 ; 18.98,211.54 JHDMI1.11 ; JHDMI1.11 18.98,212.47 ; JHDMI1.11 19.9,212.47 ; JHDMI1.11 19.44,211.42 ; JHDMI1.11 19.9,211.54 ; JHDMI1.11 19.44,212.59 ; JUSB1.7 278.61,209.06 ; JUSB1.7 277.41,209.59 ; JUSB1.7 277.41,208.54 ; JUSB1.7 278.47,208.54 ; JUSB1.7 277.27,209.06 ; JUSB1.7 278.47,209.59 ; JUSB1.7 277.94,208.39 ; JUSB2.4 292.12,199.35 ; JUSB2.4 290.92,199.35 ; JUSB2.4 290.92,198.15 ; JUSB2.4 292.3,198.75 ; JUSB2.4 291.52,199.53 ; JUSB2.4 292.12,198.15 ; JUSB2.4 290.74,198.75 ; JUSB2.4 291.52,197.97 ; 269.21,217.04 JUSB1.12 ; JUSB1.12 269.21,218.42 ; JUSB1.12 269.21,215.67 ; JUSB1.12 270.09,215.67 ; JUSB1.12 270.09,218.42 ; JUSB3.10 292.54,182.65 ; JUSB3.10 292.54,181.77 ; JUSB3.10 291.02,183.53 ; JUSB3.10 292.54,183.53 ; JUSB3.10 289.5,182.65 ; JUSB3.10 289.5,183.53 ; JUSB3.10 289.5,181.77 ; JUSB3.10 291.02,181.77 ; JUSB3.13 298.3,168.97 ; JUSB3.13 297.12,170.73 ; JUSB3.13 295.94,168.97 ; JUSB3.13 297.12,168.97 ; JUSB3.13 295.94,169.85 ; JUSB3.13 298.3,170.73 ; JUSB3.13 295.94,170.73 ; JUSB3.13 298.3,169.85 ; JHDMI1.5 16.44,212.59 ; JHDMI1.5 15.98,211.54 ; JHDMI1.5 16.9,211.54 ; JHDMI1.5 16.44,211.42 ; JHDMI1.5 15.98,212.47 ; JHDMI1.5 16.9,212.47 ; JHDMI1.22 27.12,210.3 ; JHDMI1.22 27.12,211.59 ; JHDMI1.22 26.19,211.59 ; JHDMI1.22 25.26,210.3 ; JHDMI1.22 25.26,211.59 ; JHDMI1.22 26.19,209.02 ; JHDMI1.22 25.26,209.02 ; JHDMI1.22 27.12,209.02 ; 100.63,74.48 H5.1 ; H5.1 103.67,74.48 ; H5.1 100.63,77.52 ; H5.1 103.67,77.52 ; H5.1 102.15,73.92 ; H5.1 102.15,78.08 ; H5.1 104.23,76 ; H5.1 100.07,76
  GND3 w0.203: JSATA2.17 168.59,32.6 ; JSATA2.17 167.24,32.6 ; JSATA2.17 168.44,33.13 ; JSATA2.17 167.39,33.13 ; JSATA2.17 168.44,32.07 ; JSATA2.17 167.39,32.07 ; JSATA2.17 167.91,33.27 ; JSATA2.17 167.91,31.93 ; 27.16,219.75 JHDMI1.23 ; JHDMI1.23 29.02,219.75 ; JHDMI1.23 28.09,221.04 ; JHDMI1.23 27.16,218.47 ; JHDMI1.23 28.09,218.47 ; JHDMI1.23 29.02,221.04 ; JHDMI1.23 29.02,218.47 ; JHDMI1.23 27.16,221.04 ; JUSB2.10 291.02,202.53 ; JUSB2.10 292.54,201.65 ; JUSB2.10 292.54,202.53 ; JUSB2.10 289.5,201.65 ; JUSB2.10 289.5,200.77 ; JUSB2.10 291.02,200.77 ; JUSB2.10 289.5,202.53 ; JUSB2.10 292.54,200.77 ; JSATA2.14 168.44,29.67 ; JSATA2.14 168.44,30.73 ; JSATA2.14 167.24,30.2 ; JSATA2.14 167.91,29.53 ; JSATA2.14 168.59,30.2 ; JSATA2.14 167.39,30.73 ; JSATA2.14 167.91,30.87 ; JSATA2.14 167.39,29.67 ; JSATA2.24 166.04,37.67 ; JSATA2.24 165.52,37.53 ; JSATA2.24 164.99,38.73 ; JSATA2.24 166.04,38.73 ; JSATA2.24 164.84,38.2 ; JSATA2.24 165.52,38.87 ; JSATA2.24 164.99,37.67 ; JSATA2.24 166.19,38.2 ; 21.98,211.54 JHDMI1.17 ; JHDMI1.17 22.9,211.54 ; JHDMI1.17 21.98,212.47 ; JHDMI1.17 22.9,212.47 ; JHDMI1.17 22.44,212.59 ; JHDMI1.17 22.44,211.42 ; JUSB2.12 292.54,189.73 ; JUSB2.12 292.54,187.97 ; JUSB2.12 289.5,187.97 ; JUSB2.12 289.5,188.85 ; JUSB2.12 289.5,189.73 ; JUSB2.12 291.02,187.97 ; JUSB2.12 292.54,188.85 ; JUSB2.12 291.02,189.73 ; JDOCK1.145 112.42,167.23 ; JDOCK1.145 111.36,165.25 ; JDOCK1.145 113.47,167.23 ; JDOCK1.145 113.47,165.25 ; JDOCK1.145 112.42,163.27 ; JDOCK1.145 113.47,163.27 ; H1.1 5.59,168.15 ; H1.1 2.19,171.55 ; H1.1 3.89,172.19 ; H1.1 3.89,167.51 ; H1.1 6.23,169.85 ; H1.1 2.19,168.15 ; H1.1 1.55,169.85 ; H1.1 5.59,171.55 ; JUSB3.10 291.02,183.53 ; JUSB3.10 289.5,182.65 ; JUSB3.10 291.02,181.77 ; JUSB3.10 292.54,182.65 ; JUSB3.10 292.54,181.77 ; JUSB3.10 289.5,181.77 ; JUSB3.10 292.54,183.53 ; JUSB3.10 289.5,183.53 ; 295.94,170.73 JUSB3.13 ; JUSB3.13 295.94,168.97 ; JUSB3.13 298.3,170.73 ; JUSB3.13 298.3,169.85 ; JUSB3.13 297.12,168.97 ; JUSB3.13 297.12,170.73 ; JUSB3.13 295.94,169.85 ; JUSB3.13 298.3,168.97 ; 292.07,206.88 H13.1 ; H13.1 295.42,208.3 ; H13.1 291.56,208.3 ; H13.1 293.49,206.37 ; H13.1 294.91,206.88 ; H13.1 293.49,210.23 ; H13.1 292.07,209.72 ; H13.1 294.91,209.72 ; 89.79,165.79 H11.1 ; H11.1 91.21,169.14 ; H11.1 89.79,169.65 ; H11.1 91.72,167.72 ; H11.1 88.37,169.14 ; H11.1 87.86,167.72 ; H11.1 88.37,166.3 ; H11.1 91.21,166.3 ; 295.94,200.77 JUSB2.11 ; JUSB2.11 295.94,202.53 ; JUSB2.11 295.94,201.65 ; JUSB2.11 298.3,201.65 ; JUSB2.11 298.3,202.53 ; JUSB2.11 298.3,200.77 ; JUSB2.11 297.12,200.77 ; JUSB2.11 297.12,202.53 ; 226.62,45.32 H19.1 ; H19.1 227.79,42.56 ; H19.1 226.2,44.15 ; H19.1 227.79,45.74 ; H19.1 228.96,42.98 ; H19.1 226.62,42.98 ; H19.1 228.96,45.32 ; H19.1 229.38,44.15 ; 130.59,164.2 JDOCK1.158 ; JDOCK1.158 129.54,165.25 ; JDOCK1.158 131.64,165.25 ; JDOCK1.158 129.79,166.05 ; JDOCK1.158 131.39,166.05 ; JDOCK1.158 129.79,164.45 ; JDOCK1.158 130.59,166.3 ; JSATA2.32 165.81,28.48 ; JSATA2.32 164.42,26.92 ; JSATA2.32 167.21,27.7 ; JSATA2.32 164.42,27.7 ; JSATA2.32 167.21,26.92 ; JSATA2.32 167.21,28.48 ; JSATA2.32 165.81,26.92 ; JSATA2.32 164.42,28.48 ; 256.22,163.34 H14.1 ; H14.1 259.2,160.36 ; H14.1 257.71,163.88 ; H14.1 257.71,159.82 ; H14.1 256.22,160.36 ; H14.1 255.68,161.85 ; H14.1 259.2,163.34 ; H14.1 259.74,161.85 ; H9.1 154.73,76 ; H9.1 151.13,77.52 ; H9.1 154.17,77.52 ; H9.1 150.57,76 ; H9.1 151.13,74.48 ; H9.1 154.17,74.48 ; H9.1 152.65,73.92 ; H9.1 152.65,78.08 ; JUSB3.11 298.3,182.65 ; JUSB3.11 298.3,181.77 ; JUSB3.11 297.12,183.53 ; JUSB3.11 295.94,182.65 ; JUSB3.11 295.94,183.53 ; JUSB3.11 295.94,181.77 ; JUSB3.11 298.3,183.53 ; JUSB3.11 297.12,181.77 ; 112.03,161.33 JDOCK1.153 ; JDOCK1.153 116.15,162.3 ; JDOCK1.153 116.15,161.33 ; JDOCK1.153 114.09,160.35 ; JDOCK1.153 114.09,162.3 ; JDOCK1.153 112.03,160.35 ; JDOCK1.153 112.03,162.3 ; JDOCK1.153 116.15,160.35 ; 62.12,170.42 PBATT1.2 ; PBATT1.2 61.91,169.75 ; PBATT1.2 63.46,169.08 ; PBATT1.2 62.79,170.63 ; PBATT1.2 62.12,169.08 ; PBATT1.2 62.79,168.87 ; PBATT1.2 63.46,170.42 ; PBATT1.2 63.67,169.75 ; 167.24,35 JSATA2.20 ; JSATA2.20 167.91,34.33 ; JSATA2.20 168.44,35.53 ; JSATA2.20 168.59,35 ; JSATA2.20 168.44,34.47 ; JSATA2.20 167.91,35.67 ; JSATA2.20 167.39,35.53 ; JSATA2.20 167.39,34.47 ; H8.1 80.09,85.28 ; H8.1 81.51,84.77 ; H8.1 78.16,83.35 ; H8.1 80.09,81.42 ; H8.1 78.67,84.77 ; H8.1 82.02,83.35 ; H8.1 78.67,81.93 ; H8.1 81.51,81.93 ; 19.44,211.42 JHDMI1.11 ; JHDMI1.11 18.98,211.54 ; JHDMI1.11 19.9,211.54 ; JHDMI1.11 18.98,212.47 ; JHDMI1.11 19.44,212.59 ; JHDMI1.11 19.9,212.47 ; 273.91,207.04 JUSB1.4 ; JUSB1.4 275.11,207.56 ; JUSB1.4 273.77,207.56 ; JUSB1.4 274.97,207.04 ; JUSB1.4 274.97,208.09 ; JUSB1.4 273.91,208.09 ; JUSB1.4 274.44,206.89 ; JUSB1.4 274.44,208.24 ; JSATA2.33 167.21,49.92 ; JSATA2.33 164.42,49.92 ; JSATA2.33 165.81,49.92 ; JSATA2.33 164.42,50.7 ; JSATA2.33 165.81,51.48 ; JSATA2.33 167.21,50.7 ; JSATA2.33 167.21,51.48 ; JSATA2.33 164.42,51.48 ; H3.1 102.15,107.78 ; H3.1 104.23,105.7 ; H3.1 100.07,105.7 ; H3.1 103.67,107.22 ; H3.1 100.63,107.22 ; H3.1 103.67,104.18 ; H3.1 102.15,103.62 ; H3.1 100.63,104.18 ; 56.61,169.75 PBATT1.11 ; PBATT1.11 58.72,169.75 ; PBATT1.11 56.61,167.77 ; PBATT1.11 58.72,167.77 ; PBATT1.11 57.67,167.77 ; JUSB2.13 298.3,189.73 ; JUSB2.13 298.3,187.97 ; JUSB2.13 297.12,189.73 ; JUSB2.13 298.3,188.85 ; JUSB2.13 295.94,188.85 ; JUSB2.13 297.12,187.97 ; JUSB2.13 295.94,189.73 ; JDOCK1.160 155.64,165.25 ; JDOCK1.160 154.59,164.2 ; JDOCK1.160 155.39,164.45 ; JDOCK1.160 155.39,166.05 ; JDOCK1.160 153.79,164.45 ; JDOCK1.160 153.79,166.05 ; JDOCK1.160 154.59,166.3 ; JSATA2.12 164.21,48.32 ; JSATA2.12 163.54,47.65 ; JSATA2.12 164.89,47.65 ; JSATA2.12 163.69,47.12 ; JSATA2.12 164.21,46.98 ; JSATA2.12 163.69,48.18 ; H16.1 49.34,148.28 ; H16.1 47.82,147.72 ; H16.1 51.42,146.2 ; H16.1 49.34,144.12 ; H16.1 50.86,144.68 ; H16.1 50.86,147.72 ; H16.1 47.82,144.68 ; H16.1 47.26,146.2 ; 79.92,167.77 PBATT1.10 ; PBATT1.10 78.86,169.75 ; PBATT1.10 80.97,169.75 ; PBATT1.10 78.86,167.77 ; PBATT1.10 80.97,167.77 ; 269.21,218.42 JUSB1.12 ; JUSB1.12 269.21,215.67 ; JUSB1.12 270.09,218.42 ; JUSB1.12 270.09,215.67 ; JUSB1.12 269.21,217.04 ; 249.07,85.23 H22.1 ; H22.1 252.11,88.27 ; H22.1 250.59,84.67 ; H22.1 250.59,88.83 ; H22.1 252.11,85.23 ; H22.1 252.67,86.75 ; H22.1 248.51,86.75 ; H22.1 249.07,88.27 ; JUSB3.4 291.52,180.53 ; JUSB3.4 290.92,180.35 ; JUSB3.4 290.92,179.15 ; JUSB3.4 292.12,179.15 ; JUSB3.4 290.74,179.75 ; JUSB3.4 292.12,180.35 ; JUSB3.4 291.52,178.98 ; JUSB3.4 292.3,179.75 ; 129.54,170.15 JDOCK1.162 ; JDOCK1.162 130.59,170.15 ; JDOCK1.162 131.64,168.2 ; JDOCK1.162 129.54,169.18 ; JDOCK1.162 131.64,169.18 ; JDOCK1.162 131.64,170.15 ; JDOCK1.162 130.59,168.2 ; H18.1 227.79,24.74 ; H18.1 227.79,21.56 ; H18.1 228.96,21.98 ; H18.1 229.38,23.15 ; H18.1 226.62,24.32 ; H18.1 226.62,21.98 ; H18.1 228.96,24.32 ; H18.1 226.2,23.15 ; 57.71,117.05 H23.1 ; H23.1 59.79,114.97 ; H23.1 61.87,117.05 ; H23.1 59.79,119.13 ; H23.1 61.31,115.53 ; H23.1 61.31,118.57 ; H23.1 58.27,115.53 ; H23.1 58.27,118.57 ; JSATA2.21 166.04,35.27 ; JSATA2.21 164.99,36.33 ; JSATA2.21 165.52,36.47 ; JSATA2.21 164.99,35.27 ; JSATA2.21 165.52,35.13 ; JSATA2.21 164.84,35.8 ; JSATA2.21 166.04,36.33 ; JSATA2.21 166.19,35.8 ; 150.57,105.7 H6.1 ; H6.1 151.13,107.22 ; H6.1 151.13,104.18 ; H6.1 154.17,107.22 ; H6.1 154.17,104.18 ; H6.1 152.65,107.78 ; H6.1 152.65,103.62 ; H6.1 154.73,105.7 ; JDOCK1.154 130.59,162.3 ; JDOCK1.154 130.59,160.35 ; JDOCK1.154 129.54,161.33 ; JDOCK1.154 131.64,160.35 ; JDOCK1.154 129.54,160.35 ; JDOCK1.154 131.64,161.33 ; JDOCK1.154 129.54,162.3 ; 25.26,210.3 JHDMI1.22 ; JHDMI1.22 26.19,211.59 ; JHDMI1.22 27.12,209.02 ; JHDMI1.22 25.26,209.02 ; JHDMI1.22 25.26,211.59 ; JHDMI1.22 27.12,211.59 ; JHDMI1.22 26.19,209.02 ; JHDMI1.22 27.12,210.3 ; JUSB1.10 286.67,209.94 ; JUSB1.10 286.67,208.17 ; JUSB1.10 285.79,208.17 ; JUSB1.10 286.67,211.72 ; JUSB1.10 285.79,211.72 ; JUSB1.10 284.91,208.17 ; JHDMI1.5 16.9,211.54 ; JHDMI1.5 16.44,212.59 ; JHDMI1.5 16.44,211.42 ; JHDMI1.5 15.98,211.54 ; JHDMI1.5 16.9,212.47 ; JHDMI1.5 15.98,212.47 ; 277.41,208.54 JUSB1.7 ; JUSB1.7 278.47,209.59 ; JUSB1.7 277.27,209.06 ; JUSB1.7 278.47,208.54 ; JUSB1.7 277.41,209.59 ; JUSB1.7 278.61,209.06 ; JUSB1.7 277.94,208.39 ; JDOCK1.161 116.15,169.18 ; JDOCK1.161 116.15,168.2 ; JDOCK1.161 112.03,168.2 ; JDOCK1.161 114.09,170.15 ; JDOCK1.161 112.03,169.18 ; JDOCK1.161 116.15,170.15 ; JDOCK1.161 112.03,170.15 ; JDOCK1.161 114.09,168.2 ; JHDMI1.21 10.72,218.5 ; JHDMI1.21 8.86,218.5 ; JHDMI1.21 8.86,219.79 ; JHDMI1.21 9.79,219.79 ; JHDMI1.21 10.72,219.79 ; JHDMI1.21 9.79,217.22 ; JHDMI1.21 8.86,217.22 ; JHDMI1.21 10.72,217.22 ; H12.1 236.52,150.85 ; H12.1 232.66,150.85 ; H12.1 233.17,152.27 ; H12.1 236.01,152.27 ; H12.1 234.59,152.78 ; H12.1 236.01,149.43 ; H12.1 233.17,149.43 ; H12.1 234.59,148.92 ; 270.09,208.17 JUSB1.13 ; JUSB1.13 269.21,209.94 ; JUSB1.13 270.09,211.72 ; JUSB1.13 269.21,211.72 ; JUSB1.13 269.21,208.17 ; JUSB1.13 270.97,208.17 ; JDOCK1.157 119.39,164.45 ; JDOCK1.157 118.59,164.2 ; JDOCK1.157 118.59,166.3 ; JDOCK1.157 119.39,166.05 ; JDOCK1.157 117.79,164.45 ; JDOCK1.157 117.79,166.05 ; JDOCK1.157 117.54,165.25 ; 141.54,161.33 JDOCK1.155 ; JDOCK1.155 142.59,162.3 ; JDOCK1.155 143.64,162.3 ; JDOCK1.155 141.54,162.3 ; JDOCK1.155 141.54,160.35 ; JDOCK1.155 143.64,161.33 ; JDOCK1.155 142.59,160.35 ; JDOCK1.155 143.64,160.35 ; 10.76,210.3 JHDMI1.20 ; JHDMI1.20 12.62,211.59 ; JHDMI1.20 11.69,209.02 ; JHDMI1.20 11.69,211.59 ; JHDMI1.20 10.76,209.02 ; JHDMI1.20 12.62,210.3 ; JHDMI1.20 10.76,211.59 ; JHDMI1.20 12.62,209.02 ; JSATA1.24 81.2,63.58 ; JSATA1.24 79.4,65.69 ; JSATA1.24 77.6,64.63 ; JSATA1.24 81.2,64.63 ; JSATA1.24 79.4,63.58 ; JSATA1.24 81.2,65.69 ; JSATA1.24 77.6,63.58 ; JSATA1.24 77.6,65.69 ; JUSB3.7 290.79,176.25 ; JUSB3.7 289.42,175.65 ; JUSB3.7 289.24,176.25 ; JUSB3.7 290.02,175.48 ; JUSB3.7 289.42,176.85 ; JUSB3.7 290.02,177.03 ; JUSB3.7 290.62,176.85 ; JUSB3.7 290.62,175.65 ; 60.79,168.87 PBATT1.1 ; PBATT1.1 61.46,170.42 ; PBATT1.1 59.91,169.75 ; PBATT1.1 60.12,170.42 ; PBATT1.1 61.46,169.08 ; PBATT1.1 61.67,169.75 ; PBATT1.1 60.79,170.63 ; PBATT1.1 60.12,169.08 ; H2.1 3.89,195.49 ; H2.1 1.55,193.15 ; H2.1 3.89,190.81 ; H2.1 5.59,194.85 ; H2.1 2.19,191.45 ; H2.1 5.59,191.45 ; H2.1 2.19,194.85 ; H2.1 6.23,193.15 ; H5.1 103.67,74.48 ; H5.1 100.63,77.52 ; H5.1 103.67,77.52 ; H5.1 102.15,73.92 ; H5.1 100.63,74.48 ; H5.1 104.23,76 ; H5.1 102.15,78.08 ; H5.1 100.07,76 ; H4.1 167.59,17.78 ; H4.1 169.01,17.27 ; H4.1 166.17,17.27 ; H4.1 166.17,14.43 ; H4.1 169.01,14.43 ; H4.1 165.66,15.85 ; H4.1 167.59,13.92 ; H4.1 169.52,15.85 ; H10.1 80.09,20.71 ; H10.1 78.16,18.78 ; H10.1 80.09,16.85 ; H10.1 78.67,20.2 ; H10.1 78.67,17.36 ; H10.1 82.02,18.78 ; H10.1 81.51,20.2 ; H10.1 81.51,17.36 ; JSATA2.4 164.69,33.63 ; JSATA2.4 163.49,34.16 ; JSATA2.4 163.34,33.63 ; JSATA2.4 164.54,34.16 ; 157.03,162.3 JDOCK1.156 ; JDOCK1.156 159.09,160.35 ; JDOCK1.156 159.09,162.3 ; JDOCK1.156 161.15,162.3 ; JDOCK1.156 157.03,160.35 ; JDOCK1.156 157.03,161.33 ; JDOCK1.156 161.15,161.33 ; JDOCK1.156 161.15,160.35 ; 291.52,197.97 JUSB2.4 ; JUSB2.4 292.12,199.35 ; JUSB2.4 290.92,198.15 ; JUSB2.4 290.92,199.35 ; JUSB2.4 292.3,198.75 ; JUSB2.4 292.12,198.15 ; JUSB2.4 290.74,198.75 ; JUSB2.4 291.52,199.53 ; 163.49,29.29 JSATA2.1 ; JSATA2.1 164.69,29.82 ; JSATA2.1 163.34,29.82 ; JSATA2.1 163.49,30.35 ; JSATA2.1 164.54,30.35 ; JSATA2.1 164.01,29.15 ; JSATA2.1 164.54,29.29 ; JUSB2.7 290.62,194.65 ; JUSB2.7 290.02,194.48 ; JUSB2.7 290.62,195.85 ; JUSB2.7 290.79,195.25 ; JUSB2.7 289.42,194.65 ; JUSB2.7 290.02,196.03 ; JUSB2.7 289.24,195.25 ; JUSB2.7 289.42,195.85 ; JDOCK1.152 161.82,165.25 ; JDOCK1.152 159.71,163.27 ; JDOCK1.152 159.71,167.23 ; JDOCK1.152 159.71,165.25 ; JDOCK1.152 160.76,163.27 ; JDOCK1.152 161.82,163.27 ; JDOCK1.152 160.76,167.23 ; JDOCK1.152 161.82,167.23 ; JSATA2.7 164.54,37.97 ; JSATA2.7 164.54,36.91 ; JSATA2.7 163.49,36.91 ; JSATA2.7 163.34,37.44 ; JSATA2.7 164.69,37.44 ; JSATA2.7 163.49,37.97 ; JSATA2.7 164.01,38.11 ; JSATA2.13 165.74,48.12 ; JSATA2.13 164.69,49.18 ; JSATA2.13 165.21,47.98 ; JSATA2.13 165.89,48.65 ; JSATA2.13 165.21,49.32 ; JSATA2.13 165.74,49.18 ; JSATA2.13 164.54,48.65 ; JSATA2.13 164.69,48.12 ; 157.03,169.18 JDOCK1.164 ; JDOCK1.164 161.15,170.15 ; JDOCK1.164 161.15,169.18 ; JDOCK1.164 159.09,170.15 ; JDOCK1.164 157.03,170.15 ; JDOCK1.164 159.09,168.2 ; JDOCK1.164 157.03,168.2 ; JDOCK1.164 161.15,168.2 ; JUSB3.12 292.54,168.97 ; JUSB3.12 291.02,168.97 ; JUSB3.12 289.5,170.73 ; JUSB3.12 292.54,170.73 ; JUSB3.12 292.54,169.85 ; JUSB3.12 291.02,170.73 ; JUSB3.12 289.5,169.85 ; JUSB3.12 289.5,168.97 ; JUSB1.11 286.67,218.42 ; JUSB1.11 286.67,217.04 ; JUSB1.11 286.67,215.67 ; JUSB1.11 285.79,215.67 ; JUSB1.11 285.79,218.42 ; 66.79,168.87 PBATT1.4 ; PBATT1.4 67.67,169.75 ; PBATT1.4 66.79,170.63 ; PBATT1.4 67.46,169.08 ; PBATT1.4 66.12,169.08 ; PBATT1.4 66.12,170.42 ; PBATT1.4 67.46,170.42 ; PBATT1.4 65.91,169.75 ; 181.46,167.72 H7.1 ; H7.1 184.81,166.3 ; H7.1 181.97,169.14 ; H7.1 184.81,169.14 ; H7.1 185.32,167.72 ; H7.1 183.39,165.79 ; H7.1 183.39,169.65 ; H7.1 181.97,166.3 ; 17.48,209.99 JHDMI1.8 ; JHDMI1.8 17.94,211.04 ; JHDMI1.8 17.94,209.87 ; JHDMI1.8 17.48,210.92 ; JHDMI1.8 18.4,209.99 ; JHDMI1.8 18.4,210.92 ; 14.48,209.99 JHDMI1.2 ; JHDMI1.2 14.48,210.92 ; JHDMI1.2 14.94,209.87 ; JHDMI1.2 15.4,209.99 ; JHDMI1.2 15.4,210.92 ; JHDMI1.2 14.94,211.04 ; JHDMI1.2 14.36,210.45 ; 77.6,27.22 JSATA1.23 ; JSATA1.23 77.6,26.16 ; JSATA1.23 79.4,26.16 ; JSATA1.23 81.2,26.16 ; JSATA1.23 77.6,28.27 ; JSATA1.23 81.2,27.22 ; JSATA1.23 81.2,28.27 ; JSATA1.23 79.4,28.27 ; H15.1 92.27,137.15 ; H15.1 88.67,135.63 ; H15.1 88.67,138.67 ; H15.1 88.11,137.15 ; H15.1 90.19,139.23 ; H15.1 91.71,135.63 ; H15.1 90.19,135.07 ; H15.1 91.71,138.67 ; 142.59,164.2 JDOCK1.159 ; JDOCK1.159 143.39,164.45 ; JDOCK1.159 143.39,166.05 ; JDOCK1.159 143.64,165.25 ; JDOCK1.159 141.79,164.45 ; JDOCK1.159 142.59,166.3 ; JDOCK1.159 141.54,165.25 ; JDOCK1.159 141.79,166.05 ; JDOCK1.163 143.64,170.15 ; JDOCK1.163 143.64,169.18 ; JDOCK1.163 141.54,168.2 ; JDOCK1.163 142.59,168.2 ; JDOCK1.163 142.59,170.15 ; JDOCK1.163 143.64,168.2
  BOTTOM w0.102: v3(176.72,71.05) v2(177.46,71.05) ; v3(93.6,119.37) v2(93.6,120.03) ; v2(3.9,145.41) v3(3.9,144.71) ; v3(188.93,104.15) v2(189.59,104.15) ; v3(240.76,79.27) v2(240.01,79.27) ; v3(11.75,197.41) v2(11.75,196.74) ; v3(193.89,75.25) v2(193.26,75.25) ; v3(78.68,91.87) v2(77.83,91.87) ; v3(171.96,161.72) v2(171.96,162.41) ; v3(16.36,146.19) 16.33,146.17 v2(15.51,146.17) ; v3(236.09,141.25) v2(236.75,141.25) ; v3(249.92,166.19) v2(249.92,166.86) ; v3(101.22,94.4) v2(100.04,94.4) ; v3(177.29,117.2) v2(177.89,117.2) ; v3(201.79,66.42) v2(201.08,66.42) ; v3(176.89,65.33) v2(176.16,65.33)
  BOTTOM w0.203: U6.28 134.33,157.83 134.11,158.04 v3(134.11,158.49) ; v3(137.29,151.5) 137.29,152.2 137.19,152.3 U6.11 ; v3(135.74,158.17) 135.53,157.96 U6.31 ; U6.3 137.35,155.49 v3(137.48,155.63)
  BOTTOM w0.22: v3(72.59,122.94) 72.58,122.95 UV1.B18 ; v3(75.81,122.82) 75.78,122.85 UV1.B22 ; UV1.B20 v3(74.18,122.8)
  BOTTOM w0.23: UV1.K32 83.38,129 v3(83.46,128.92) ; v3(59.94,127.29) 60.06,127.41 60.97,127.41 UV1.H2
  BOTTOM w0.25: v3(77.41,122.85) 77.38,122.87 UV1.B24 ; UV1.B10 v3(66.18,122.84) ; v3(79.01,122.87) 78.98,122.9 UV1.B26 ; UV1.U3 61.34,134.6 61.32,134.58 60.64,134.58 60.62,134.6 UV1.U1 60.39,134.6 v3(60.06,134.93)
  BOTTOM w0.254: JDOCK1.131 152.34,162.46 v3(152.49,162.6) ; 170.79,152.62 v3(170.79,152.66) ; 170.79,152.62 171.05,152.36 RPH17.2 ; 170.79,152.62 170.79,152.55 170.55,152.31 RPH17.1 ; JCPU1.AA25 v3(124.47,100.2) ; v3(67.76,109.78) 67.86,109.68 UV3.U3 ; JDOCK1.58 132.84,168 v3(132.84,167.99) ; JDOCK1.55 132.34,162.3 v3(132.59,162.55) 132.84,162.3 JDOCK1.57 ; UV1.K28 UV1.L27 79.78,129.87 v3(80.18,130.27) ; UV3.A14 58.84,96.46 v3(58.59,96.71) ; v3(89.94,103.66) UV4.H14 UV4.H13 ; UH1.AT10 160.9,132.44 v3(161.1,132.64) 160.8,132.64 UH1.AV13 ; v3(82.59,123.82) 82.21,124.2 UV1.C32 ; UV4.R14 v3(89,97.66) UV5.C13 ; JCPU1.W25 v3(126.47,100.2) ; v3(60.14,138.04) 60.38,137.8 UV1.AA1 ; UV4.K1 v3(78.6,101.66) ; JDOCK1.101 144.84,160.4 144.85,160.39 144.85,160.01 v3(144.91,159.95) ; UV4.R4 v3(81,98.46) ; 164.81,129.1 164.86,129.04 UH1.AG2 ; UV1.AC24 77.38,139.46 v3(77.03,139.82) ; UV3.A12 60.66,95.96 v3(60.58,95.88) ; UV4.P10 v3(85.8,98.46) ; JDOCK1.123 150.34,160.42 v3(150.81,159.95) 150.84,159.97 JDOCK1.125 ; UH1.K15 172.08,133.92 172.4,133.59 ; UV4.A12 v3(87.4,109.66) ; v3(73.79,127.06) 74.13,127.4 UV1.H20 ; UV1.AE7 63.73,141 v3(63.37,140.64) 62.98,140.25 UV1.AD6 ; JDOCK1.87 140.34,160.2 v3(140.72,159.82) ; UV1.G10 66.18,126.57 v3(66.56,126.2) 66.18,125.82 UV1.F10 ; v3(77.79,138.99) 77.38,138.58 UV1.AB24 ; UV3.A3 v3(67.46,96.06) ; UV6.J1 v3(69.06,103.26) UV3.K2 ; UV4.M10 v3(85.8,100.06) ; UV3.E1 v3(69.86,100.06) ; JDOCK1.82 138.84,168.44 138.5,168.09 138.2,168.09 137.86,167.76 137.86,167.31 137.86,167.31 v3(137.85,167.31) ; UH1.K33 172.42,141.91 v3(172.42,142.09) 172.48,142.15 172.48,142.37 172.66,142.54 UH1.H36 ; v3(124.02,159.88) 123.84,160.06 JDOCK1.25 ; JCPU1.R11 130.94,85.72 131.38,85.28 v3(131.39,85.28) ; v3(120.84,170.55) JDOCK1.14 ; v3(62.66,103.26) UV3.J10 v3(62.66,102.46) ; UV1.AH10 66.18,143.39 v3(65.79,142.99) ; UH1.G38 173.26,143.54 v3(172.64,143.54) ; v3(77.79,137.85) 78.18,137.46 UV1.Y25 ; JLVDS1.24 v3(210.04,171) ; UV3.A1 v3(69.86,96.86) ; UV3.C3 v3(67.46,98.46) ; UV1.W26 78.98,136.15 v3(78.55,136.58) 78.18,136.21 UV1.W25 ; v3(126.62,168.01) 126.84,168.23 JDOCK1.38 ; UV4.N12 v3(87.4,99.26) ; UV3.B10 v3(61.86,97.66) UV3.C11 ; UV3.C14 v3(58.46,98.06) ; UV3.L10 v3(62.66,104.86) ; JCPU1.AP35 111.94,109.71 v3(111.44,109.21) ; v3(117.89,159.14) 117.84,159.19 JDOCK1.1 ; UV1.C1 60.57,124.2 59.8,124.2 v3(59.75,124.25) ; UV4.M5 v3(81.8,100.06) ; UV3.K13 UV3.K14 v3(58.41,103.66) ; UV4.T5 v3(81.8,96.86) ; JDOCK1.43 128.34,162.3 v3(128.59,162.55) ; v3(153.9,167.63) 153.9,168.1 153.84,168.16 JDOCK1.138 ; UV4.A1 v3(78.6,109.66) ; UV4.C1 v3(78.6,108.06) ; v3(123.84,170.93) JDOCK1.26 ; UH1.R8 169.7,131.17 v3(169.25,131.61) 168.91,131.61 UH1.U10 ; JDOCK1.13 120.84,159.99 v3(120.73,159.88) ; UV4.C12 v3(87.4,108.06) ; UV3.H13 UV3.H14 58.9,102.23 v3(58.55,102.23) ; JDOCK1.94 141.84,167.84 v3(141.99,167.69) ; JCPU1.P26 JCPU1.R26 ; UV1.T11 66.63,133.8 v3(66.18,134.24) ; v3(137.34,162.68) JDOCK1.75 ; JDOCK1.47 129.34,160.15 v3(129.61,159.88) 129.84,160.12 JDOCK1.49 ; v3(136.36,136.96) 136.36,132.84 PH500.2 ; UV3.H1 v3(69.86,101.66) ; UV3.E12 v3(60.26,100.06) ; JIO1.27 3.18,183.25 v3(3.3,183.12) ; JDOCK1.108 v3(146.34,170.55) ; v3(4.7,178.55) 5,178.25 JIO1.8 ; v3(171.44,152.65) 171.55,152.54 RPH17.3 ; JLVDS1.17 v3(213.54,168.97) ; UV1.A3 61,123.4 v3(60.84,123.25) ; UV3.C12 v3(61.06,97.66) ; v3(80.18,135.72) 79.78,136.12 UV1.W27 ; JDOCK1.81 138.84,160.23 v3(138.43,159.82) ; UV1.F2 60.91,125.8 60.71,125.59 60.14,125.59 v3(60.01,125.47) ; UV4.E3 v3(80.2,105.66) ; JDOCK1.120 149.34,170.51 v3(149.34,170.51) ; v3(62.24,129.27) 62.11,129.4 61.39,129.4 UV1.K2 ; v3(125.6,170.93) 125.6,170.49 125.34,170.22 JDOCK1.32 ; JLVDS1.13 215.54,169.43 v3(215.29,169.18) 215.04,169.43 JLVDS1.14 ; UV3.R1 69.94,107.66 v3(69.99,107.71) ; v3(7.46,185.25) JIO1.36 ; JCPU1.T33 129.82,107.73 v3(129.41,108.14) ; v3(62.68,125.09) 62.98,125.39 UV1.F6 ; v3(3.11,184.94) 2.92,184.75 JIO1.33 ; JCPU1.AL31 114.94,105.73 v3(114.48,106.2) ; v3(152.53,170.74) 152.34,170.55 JDOCK1.132 ; UV3.E3 v3(68.26,100.06) ; JDOCK1.126 150.84,170.46 v3(150.69,170.61) ; UH1.R2 v3(169.74,129.23) ; UV4.E1 v3(78.6,106.46) ; UV3.N3 v3(67.46,105.66) ; v3(148.02,170.55) 147.84,170.37 JDOCK1.114 ; v3(174.41,143.65) 174.62,143.85 UH1.B39 ; JLVDS1.11 216.54,169.44 v3(216.3,169.19) 216.04,169.45 JLVDS1.12 ; v3(131.19,162.48) 131.34,162.34 JDOCK1.51 ; v3(81.73,122.74) 81.41,123.05 81.41,123.37 UV1.A30 ; UH1.H13 172.67,133.32 172.4,133.59 ; UV3.N1 v3(69.99,106.06) ; UV3.T5 v3(65.66,108.46) ; v3(122.51,159.88) 122.34,160.05 JDOCK1.19 ; UV3.B5 v3(65.86,96.86) ; UV4.D10 85.69,106.86 85.63,106.93 v3(85.6,106.93) ; UV4.R3 v3(80.2,97.66) ; UV4.K13 UV4.K14 89.43,102.06 v3(89.79,102.42) ; UV4.U14 v3(89,96.06) ; UV4.N3 v3(81,100.06) ; UV3.P10 v3(62.66,107.26) ; JDOCK1.63 134.34,160.11 v3(134.11,159.88) 133.84,160.16 JDOCK1.61 ; UV4.L10 v3(85.8,100.86) ; UV3.R11 v3(61.86,108.06) ; UV4.K2 v3(80.2,102.46) ; UV3.R3 v3(68.26,108.06) ; JIO1.11 2.99,179.25 3.18,179.44 v3(3.49,179.44) ; UV4.C11 v3(86.6,108.06) UV4.B10 ; UV3.M10 v3(62.66,105.66) ; JDOCK1.44 128.34,168.15 v3(128.2,168.01) ; JDOCK1.76 137.34,170.45 v3(137.4,170.52) ; v3(135.64,170.61) 135.84,170.41 JDOCK1.70 ; UV4.U3 v3(80.2,96.86) ; v3(67.25,143.12) 67.77,142.6 UV1.AG12 ; JCPU1.AL32 v3(114.47,107.2) ; JDOCK1.119 149.34,160.23 v3(149.61,159.97) ; UV3.R14 v3(58.52,107.66) ; JDOCK1.102 144.84,170.3 v3(144.59,170.55) ; v3(129.84,170.63) JDOCK1.50 129.84,168.09 v3(130.05,167.88) ; JDOCK1.137 153.84,162.51 v3(153.8,162.55) ; UV3.K1 v3(69.86,104.06) ; UV3.N14 v3(58.46,106.06) ; v3(132.45,85.24) 131.96,85.73 JCPU1.P11 ; v3(127.13,159.88) 126.84,160.17 JDOCK1.37 ; UV3.R12 v3(60.26,108.06) UV6.C13 ; UV4.F10 v3(85.8,104.86) ; UV4.G5 v3(82.6,104.86) ; v3(60.07,136.2) UV1.W1 ; UV4.R11 v3(86.6,97.66) ; UV3.N12 v3(60.26,106.46) ; v3(66.42,135.37) 66.65,135.6 UV1.V11 ; JDOCK1.7 v3(119.34,159.88) ; 172.4,133.59 v3(172.4,133.66) ; JDOCK1.69 135.84,160.13 v3(136.02,159.95) ; v3(7.55,183.75) JIO1.30 ; UV4.G10 v3(85.8,104.06) ; v3(134.44,168) 134.34,168.1 JDOCK1.64 ; JDOCK1.31 125.34,162.41 v3(125.54,162.61) ; UV1.B8 v3(64.58,122.93) ; UV4.L5 v3(82.6,100.86) ; v3(148.53,163.69) 147.84,163.01 JDOCK1.113 ; v3(122.34,170.51) JDOCK1.20 ; UV3.G5 v3(65.86,100.86) ; v3(69.77,109.72) 69.77,109.71 69.46,109.41 UV3.U1 ; v3(78.61,135.37) 78.18,134.94 UV1.U25 78.18,134.6 v3(78.55,134.23) 78.18,133.86 UV1.T25 78.18,133.39 v3(78.55,133.02) 78.18,132.65 UV1.P25 ; JXDP2.26 v3(207.65,104.38) ; JLVDS1.27 v3(208.54,171.06) ; UV4.F5 v3(81.8,105.66) ; JDOCK1.107 v3(146.34,159.85) ; UV4.R12 v3(87.4,97.66) ; UV4.N14 v3(89,99.26) ; JDOCK1.88 140.34,170.55 v3(140.27,170.61) ; UV4.U12 v3(87.4,96.06) ; v3(78.62,96.07) 78.62,96.07 UV4.U1 ; UV4.T10 v3(85.8,96.86) ; UV4.C3 v3(81,107.26) ; v3(156.75,145.24) 157.04,144.95 UH1.BE41 ; JDOCK1.91 141.34,159.96 v3(141.54,159.76) 141.84,160.05 JDOCK1.93 ; v3(119.13,170.61) 119.34,170.4 JDOCK1.8 ; UV3.D10 v3(61.86,99.26) ; v3(142.94,170.68) 143.34,170.28 JDOCK1.96 ; RPH20.2 151.99,126.47 v3(151.74,126.23) 152,125.97 RPH20.1 ; UV4.E12 v3(88.2,105.66) ; UV4.C14 v3(90,107.66) ; UV3.C1 v3(69.86,98.46) ; UV3.E14 v3(58.42,99.66) ; UV3.M5 v3(66.66,105.66) ; UV3.T10 v3(62.66,108.86) ; UV3.U12 v3(60.26,109.66) ; UV3.F10 v3(62.66,100.86) ; UV3.L5 v3(66.66,104.86) ; UV1.K6 v3(63.38,128.6) ; UV3.F5 v3(66.66,100.06) ; UV4.C4 v3(81,108.06) ; JDOCK1.52 v3(131.34,170.66) ; UV4.A14 v3(89.98,109.26) ; UV1.B6 v3(62.98,122.98) ; JCPU1.AR26 v3(110.47,101.2) ; UV3.H2 v3(68.26,102.46) ; UV4.B5 v3(81.8,108.86) ; UV4.A3 v3(80.2,109.66) ; UV4.R1 78.7,98.06 v3(78.49,97.84) ; UV4.H2 v3(80.2,103.26) ; UV4.N1 v3(78.46,99.66) ; v3(85.8,103.26) UV4.J10 v3(85.8,102.46) ; UV3.C4 v3(67.46,97.66) ; UV3.R4 v3(67.46,107.26) ; UV4.H1 v3(78.6,104.06) ; UV1.F18 v3(72.58,126.55) ; UV3.G10 v3(62.66,101.66) ; UV4.E14 v3(89.94,106.06) ; UV3.U14 v3(58.66,109.66)
  BOTTOM w0.279: v3(204.55,110.37) 206.14,110.37 JXDP2.2 ; JCPU1.AK32 115.84,106.73 115.47,107.1 v3(115.47,107.35) ; JXDP2.49 v3(213.65,98.38) ; v3(144.47,97.2) 144,96.73 JCPU1.B22 ; v3(207.77,101.93) 207.23,101.38 JXDP2.38 ; JCPU1.AG31 v3(118.47,106.2) ; v3(213.87,106.23) 213.87,106.92 213.41,107.38 JXDP2.13 ; JCPU1.D22 141.92,96.73 142.45,96.2 v3(142.47,96.2) ; v3(115.47,109.2) JCPU1.AK34 ; JCPU1.AC35 v3(122.47,110.2) ; JCPU1.AE29 v3(120.47,104.2) ; JCPU1.AA27 v3(124.47,102.2) ; v3(210.39,103.8) 210.39,103.96 210.81,104.38 JXDP2.25 ; v3(115.47,103.2) JCPU1.AK28 ; v3(207.71,106.01) 207.58,105.88 JXDP2.20 ; JCPU1.AE33 v3(120.47,108.2) ; v3(113.47,107.2) JCPU1.AM32 ; JXDP2.7 210.77,108.88 v3(210.25,109.4) ; JCPU1.AA31 v3(124.47,106.2) ; JCPU1.AC33 v3(122.47,108.2) ; v3(204.54,98.22) 204.7,98.38 JXDP2.50 ; v3(213.36,96) 213.24,95.88 JXDP2.59 ; v3(204.24,95.98) 204.33,95.88 JXDP2.60 ; v3(115.47,100.2) JCPU1.AK25 ; v3(141.47,96.2) JCPU1.E22 ; v3(210.19,106.1) 210.4,105.88 JXDP2.19 ; v3(112.47,102.2) JCPU1.AN27 ; JCPU1.AG35 v3(118.47,110.2) ; JXDP2.32 207.5,102.88 v3(207.71,102.67) ; JCPU1.AE27 v3(120.47,102.2) ; v3(110.47,106.2) JCPU1.AR31 ; v3(143.47,97.2) 143,96.73 JCPU1.C22 ; v3(120.47,100.2) JCPU1.AE25 ; JXDP2.14 207.44,107.38 v3(207.77,107.05) ; JXDP2.37 v3(210.36,101.38) ; v3(115.47,104.2) JCPU1.AK29 ; JCPU1.AC27 v3(122.47,102.2) ; v3(139.47,97.2) 139.94,97.67 JCPU1.F23 ; JCPU1.AE31 v3(120.47,106.2) ; JXDP2.31 v3(213.46,102.88) ; v3(115.47,105.2) JCPU1.AK30 ; v3(110.47,103.2) JCPU1.AR28 ; JXDP2.1 210.73,110.38 v3(210.38,110.73) ; JXDP2.8 v3(204.61,108.88) ; JCPU1.AC25 v3(122.47,100.2) ; JCPU1.AG33 v3(118.47,108.2) ; v3(110.47,100.2) JCPU1.AR25 ; JCPU1.AA29 v3(124.47,104.2) ; JCPU1.AG29 v3(118.47,104.2) ; v3(109.47,96.2) JCPU1.AT21 ; JCPU1.AE35 v3(120.47,110.2) ; v3(109.47,99.2) JCPU1.AT24 ; JCPU1.AC31 v3(122.47,106.2) ; JCPU1.AG25 v3(118.47,100.2) ; v3(112.47,105.2) JCPU1.AN30 ; JCPU1.AA33 v3(124.47,108.2) ; v3(109.47,105.2) JCPU1.AT30 ; v3(115.47,101.2) JCPU1.AK26 ; JCPU1.AG27 v3(118.47,102.2) ; v3(109.47,102.2) JCPU1.AT27 ; JCPU1.AC29 v3(122.47,104.2)
  BOTTOM w0.3: UV1.J31 82.68,128.2 v3(82.81,128.07) ; UV1.AG27 v3(80.31,142.8) UV1.AH28 ; UV1.B16 v3(70.98,122.8) ; UV1.AK26 78.58,144.2 UV1.AJ25 78.18,143.43 v3(77.87,143.11) 77.87,142.96 78.18,142.65 UV1.AG25 ; UV1.P6 63.26,132.48 v3(63.26,132.6) ; UV1.M32 v3(82.78,130.6) ; UV1.AB6 62.98,138.47 63.51,137.95 v3(63.51,137.87) ; v3(62.56,135) 62.57,135 62.97,135.4 UV1.V6 ; v3(64.13,139.75) UV1.AD8 ; v3(82.83,140.2) UV1.AD32 ; v3(82.81,126.55) 82.76,126.6 UV1.G31 ; UV1.R27 v3(80.31,133) ; v3(78.88,125.15) UV1.F26 ; UV1.E28 v3(80.18,124.6) ; UV1.F24 77.38,125.32 v3(77.46,125.25) ; v3(62.33,127.42) 62.96,127.42 UV1.H6 ; v3(64.93,138.95) UV1.AC9 ; UV1.N27 v3(80.18,131.8) ; UV1.AF32 v3(82.73,141.8) ; UV1.U27 v3(80.18,134.2) ; UV1.AB32 82.67,138.6 v3(82.74,138.67) ; UV1.AC26 v3(78.58,139.8) UV1.AD25 ; UV1.P32 v3(82.83,132.2) ; UV1.AE27 v3(80.31,141) ; v3(82.83,133.7) 82.73,133.8 UV1.T32 ; v3(72.58,126.55) UV1.H17 ; UV1.G8 64.46,126.47 64.46,125.92 UV1.F8 v3(64.11,125.4) ; UV1.AH32 82.23,143.4 v3(82.55,143.71) ; v3(79.19,137.8) UV1.AA27 ; v3(82.81,135.4) UV1.V32 ; UV1.J7 v3(63.38,128.6) ; UV1.AC27 v3(80.18,139.8) ; UV1.Y32 v3(82.88,137) ; UV1.T6 62.61,133.8 v3(62.48,133.67) ; UV1.F22 v3(75.78,125.25) ; v3(80.41,128.2) UV1.J27 ; UV1.F12 v3(67.78,125.25) ; v3(63.51,130.6) UV1.M6 ; UV1.G27 v3(80.18,126.2) ; UV1.F20 v3(74.18,125.22) ; UV1.F14 v3(69.38,125.2) ; UV1.B14 v3(69.38,122.87) ; v3(71.18,125.25) UV1.F16 ; UV1.B12 v3(67.78,122.8)
  BOTTOM w0.305: v3(120.45,79.27) 120.94,78.78 JCPU1.AE4 ; v3(66.51,128.6) 66.91,129 UV1.K11 ; JCPU1.E10 141,84.73 v3(141.47,85.2) ; JCPU1.AL2 114.94,76.67 v3(114.47,76.2) ; JCPU1.F14 140,88.73 v3(140.47,89.2) JCPU1.F15 ; JCPU1.E16 140.9,90.73 v3(140.44,90.27) ; JCPU1.E1 141,75.73 v3(141.47,76.2) ; v3(130.47,107.2) JCPU1.R32 ; JCPU1.K33 136,107.73 v3(136.47,108.2) 136.94,108.67 JCPU1.J34 ; JCPU1.B7 v3(143.47,82.2) ; v3(136.47,77.2) JCPU1.K3 ; JCPU1.AR10 v3(111.47,84.2) 111.94,84.67 JCPU1.AP10 ; v3(141.47,79.2) 141,78.73 JCPU1.E4 ; v3(136.47,78.2) JCPU1.K4 ; v3(114.47,80.2) JCPU1.AL5 ; v3(117.47,84.2) JCPU1.AH9 ; v3(129.47,106.2) JCPU1.T31 ; JCPU1.G31 139,105.73 v3(139.47,106.2) 139.94,106.67 JCPU1.F32 ; v3(127.47,84.2) 127,83.73 JCPU1.W9 ; JCPU1.J26 137,100.73 v3(137.47,101.2) JCPU1.H26 ; v3(143.47,94.2) 143,93.73 JCPU1.C19 ; v3(110.47,78.27) 110.93,78.73 JCPU1.AR4 ; JCPU1.AP34 112,108.73 v3(112.47,109.2) JCPU1.AN34 ; JCPU1.J30 136.94,104.67 v3(136.47,104.2) ; v3(131.43,102.3) 131,102.73 JCPU1.R28 ; v3(110.47,81.2) 110.94,81.67 JCPU1.AR7 ; v3(117.47,85.2) JCPU1.AH10 ; JCPU1.A19 145,93.73 v3(145.47,94.2) ; v3(129.47,85.2) JCPU1.U11 ; v3(130.47,80.2) JCPU1.T6 ; JCPU1.A27 145,101.73 v3(145.47,102.2) ; v3(123.47,84.2) JCPU1.AB9 ; JCPU1.AC11 122.94,85.67 v3(122.47,85.2) ; v3(139.47,104.2) 139,103.73 JCPU1.G29 ; JCPU1.A31 145,105.73 v3(145.47,106.2) ; v3(139.47,86.2) 139,85.73 JCPU1.G11 ; JCPU1.F28 139.94,102.67 v3(139.47,102.2) 139,101.73 JCPU1.G27 ; v3(125.47,85.2) 125.94,85.67 JCPU1.Y11 ; v3(129.47,104.2) JCPU1.T29 ; v3(114.47,90.2) JCPU1.AL15 ; v3(113.47,95.2) JCPU1.AM20 ; JCPU1.G4 139,78.73 v3(139.47,79.2) ; JCPU1.AH6 v3(117.47,81.2) 117.94,81.67 JCPU1.AH7 ; v3(112.47,93.2) 112.94,93.67 JCPU1.AN19 ; v3(116.47,85.2) 116.94,85.67 JCPU1.AJ11 ; v3(142.47,88.2) 142,87.73 JCPU1.D13 ; v3(142.47,110.2) 142,109.73 JCPU1.D35 ; JCPU1.C13 143,87.73 v3(143.47,88.2) ; JCPU1.AK11 115.94,85.67 v3(115.47,85.2) ; v3(136.47,110.2) 136,109.73 JCPU1.K35 ; v3(145.47,100.2) 145,99.73 JCPU1.A25 ; JCPU1.W6 127,80.73 v3(127.47,81.2) JCPU1.W7 ; v3(137.48,86.17) 137.48,86.2 137,85.73 JCPU1.J11 ; JCPU1.AL19 114.94,93.67 v3(114.47,93.2) ; JCPU1.C10 143,84.73 v3(143.47,85.2) ; v3(113.47,96.2) JCPU1.AM21 ; v3(142.47,106.2) 142,105.73 JCPU1.D31 ; JCPU1.D19 v3(142.47,93.2) ; JCPU1.F10 140,84.73 v3(140.47,85.2) ; JCPU1.K7 136,81.73 v3(136.47,82.2) ; JCPU1.C30 143,104.73 v3(143.47,105.2) ; JCPU1.W1 127,75.73 v3(127.47,76.2) ; v3(109.47,77.13) 109.94,77.6 JCPU1.AT3 ; v3(128.47,85.2) JCPU1.V11 ; v3(116.47,79.2) 116.94,79.67 JCPU1.AJ5 ; JCPU1.F20 139.99,94.73 v3(140.49,94.23) ; v3(128.47,84.2) JCPU1.V10 ; v3(119.47,82.2) 119.94,82.67 JCPU1.AF8 ; v3(131.47,84.2) JCPU1.R10 ; JXDP1.9 v3(93.75,76.23) ; v3(114.47,77.2) 114.94,77.67 JCPU1.AL3 ; JCPU1.C7 v3(142.47,82.2) ; v3(136.47,84.2) 136,83.73 JCPU1.K9 ; v3(126.47,110.2) JCPU1.W35 ; JCPU1.AB6 123.91,80.73 123.43,81.2 v3(123.43,81.38) ; v3(145.47,104.2) 145,103.73 JCPU1.A29 ; JCPU1.AP13 111.94,87.67 v3(111.47,87.2) ; v3(112.47,87.2) 112.94,87.67 JCPU1.AN13 ; JCPU1.B34 v3(143.47,109.2) 143,108.73 JCPU1.C34 ; JCPU1.F9 140,83.73 v3(140.47,84.2) ; v3(145.47,108.2) 145,107.73 JCPU1.A33 ; v3(117.47,83.2) JCPU1.AH8 ; JCPU1.W33 v3(126.47,108.2) ; JXDP1.19 v3(93.73,81.23) ; v3(113.47,93.2) 113.94,93.67 JCPU1.AM19 ; v3(130.47,78.2) JCPU1.T4 ; JCPU1.H11 137.95,85.73 138.46,86.23 v3(138.51,86.23) ; v3(114.47,85.2) JCPU1.AL10 ; JCPU1.AL1 114.94,75.67 v3(114.47,75.2) ; JCPU1.AF6 119.94,80.67 v3(119.47,80.2) ; JCPU1.AE3 v3(120.47,78.2) ; JCPU1.AB1 123.94,75.67 v3(123.47,75.2) ; JCPU1.B16 v3(143.47,91.2) ; v3(144.47,94.2) 144,93.73 JCPU1.B19 ; v3(140.47,83.2) 140,82.73 JCPU1.F8 ; v3(139.47,75.2) JCPU1.G1 ; JCPU1.K8 135.47,82.26 v3(135.47,82.2) ; v3(142.47,108.2) 142,107.73 JCPU1.D33 ; v3(113.47,97.2) JCPU1.AM22 ; v3(136.53,79.24) 136.04,79.73 JCPU1.K5 ; v3(114.48,87.2) 114.94,86.75 JCPU1.AL12 ; JCPU1.C16 v3(142.47,91.2) ; JCPU1.H6 v3(137.47,81.2) ; v3(144.47,97.2) JCPU1.A22 ; JCPU1.N29 132.99,103.73 133.22,103.95 133.23,103.95 133.41,104.14 v3(133.49,104.14) 133.49,104.23 133.94,104.68 JCPU1.M30 ; v3(143.47,79.2) JCPU1.B4 ; v3(142.47,104.2) 142,103.73 JCPU1.D29 ; v3(145.47,82.2) 145,81.73 JCPU1.A7 ; v3(120.47,85.2) JCPU1.AE10 ; JCPU1.AP16 111.94,90.67 v3(111.47,90.2) ; JCPU1.G2 139,76.73 v3(139.47,77.2) ; v3(136.47,80.2) 136.94,80.67 JCPU1.J6 ; JCPU1.W3 127,77.73 v3(127.47,78.2) ; JCPU1.F30 140,104.73 v3(140.47,105.2) ; v3(130.47,77.2) JCPU1.T3 ; JCPU1.T26 129.94,100.73 v3(129.47,101.2) ; v3(114.47,84.2) JCPU1.AL9 ; v3(114.47,96.2) JCPU1.AL21 ; v3(113.47,90.2) 113.94,90.67 JCPU1.AM16 ; JCPU1.C32 v3(142.47,107.2) ; JCPU1.M34 133.94,108.63 v3(133.5,108.19) ; JCPU1.B13 144,87.73 v3(144.47,88.2) JCPU1.A13 ; JCPU1.E19 140.94,93.68 v3(140.44,93.18) ; JCPU1.G3 139,77.73 v3(139.47,78.2) ; v3(143.47,76.2) 143,75.73 JCPU1.C1 ; v3(128.47,102.2) JCPU1.U27 ; v3(140.47,101.2) 140,100.73 JCPU1.F26 ; v3(114.47,82.2) JCPU1.AL7 ; v3(127.47,79.2) 127,78.73 JCPU1.W4 ; v3(113.47,98.2) JCPU1.AM23 ; v3(130.47,101.2) 130.94,100.73 JCPU1.R26 ; JCPU1.AD7 122,81.73 v3(122.47,82.2) ; v3(133.47,78.2) JCPU1.N4 ; JCPU1.D4 142,78.73 v3(142.47,79.2) JCPU1.C4 ; v3(141.47,88.2) 141,87.73 JCPU1.E13 ; v3(130.47,83.2) JCPU1.T9 ; v3(112.47,99.2) JCPU1.AN24 ; JCPU1.AF11 119.94,85.67 v3(119.47,85.2) ; JXDP1.6 v3(93.73,74.73) ; v3(139.47,110.18) 139.41,110.18 138.95,109.73 JCPU1.G35 ; v3(120.47,84.2) JCPU1.AE9 ; JCPU1.AE6 v3(120.47,81.2) 120.94,81.67 JCPU1.AE7 ; v3(117.47,79.2) JCPU1.AH4 ; v3(111.47,78.2) 111.94,78.67 JCPU1.AP4 ; JCPU1.C24 143,98.73 v3(143.47,99.2) ; v3(114.47,97.2) JCPU1.AL22 ; v3(111.47,81.2) 111.94,81.67 JCPU1.AP7 ; v3(140.47,81.2) 140,80.73 JCPU1.F6 ; JCPU1.H10 138,84.73 v3(138.47,85.2) ; JCPU1.AM24 v3(113.47,99.2) 113.94,99.67 JCPU1.AM25 ; v3(134.47,85.2) JCPU1.M11 ; v3(133.47,83.2) JCPU1.N9 ; JCPU1.AB3 v3(123.47,78.2) 123.94,78.67 JCPU1.AB4 ; JCPU1.N33 132.95,107.73 v3(133.5,107.18) 133.94,106.74 JCPU1.M32 ; v3(112.47,78.2) 112.94,78.67 JCPU1.AN4 ; v3(109.45,78.24) 109.94,78.73 JCPU1.AT4 ; JCPU1.AK5 115.47,79.26 v3(115.47,79.2) ; v3(114.47,95.2) JCPU1.AL20 ; v3(138.47,82.2) 138,81.73 JCPU1.H7 ; v3(117.47,77.2) JCPU1.AH2 ; JCPU1.AP27 v3(111.47,102.2) ; JCPU1.F4 140,78.73 v3(140.47,79.2) ; v3(118.47,80.2) 118.94,80.67 JCPU1.AG6 ; v3(130.47,105.2) JCPU1.R30 ; JCPU1.C28 143,102.73 v3(143.47,103.2) ; v3(110.47,93.2) 110.94,93.67 JCPU1.AR19 ; v3(129.47,110.2) JCPU1.T35 ; v3(133.47,75.2) JCPU1.N1 ; v3(110.47,109.2) JCPU1.AR34 ; v3(117.47,80.2) JCPU1.AH5 ; v3(140.47,86.2) 140,85.73 JCPU1.F11 ; UV1.M12 67.98,130.83 67.01,131.8 UV1.N11 ; v3(109.47,87.2) 109.94,87.67 JCPU1.AT13 ; JCPU1.AL4 114.94,78.67 v3(114.47,78.2) ; v3(112.47,90.2) 112.94,90.67 JCPU1.AN16 ; JCPU1.D16 v3(141.47,91.2) ; JCPU1.AR13 110.94,87.67 v3(110.47,87.2) ; v3(117.47,78.2) JCPU1.AH3 ; JCPU1.AM13 113.94,87.67 v3(113.47,87.2) ; JCPU1.AD11 121.94,85.67 v3(121.47,85.2) ; v3(110.47,90.2) 110.94,90.67 JCPU1.AR16 ; JCPU1.F17 139.38,91.17 v3(139.38,91.11) ; JCPU1.AM4 113.47,78.26 v3(113.47,78.2) ; v3(127.47,85.2) 127,84.73 JCPU1.W10 ; JCPU1.J32 136.94,106.67 v3(136.47,106.2) 136,105.73 JCPU1.K31 ; JCPU1.AN10 v3(113.47,84.2) 113.94,84.67 JCPU1.AM10 ; v3(133.47,77.2) JCPU1.N3 ; v3(118.47,85.2) 118.94,85.67 JCPU1.AG11 ; v3(114.47,89.2) JCPU1.AL14 ; v3(127.47,105.2) JCPU1.V30 ; v3(133.47,103.2) JCPU1.M28 ; JCPU1.AP19 111.94,93.67 v3(111.47,93.2) ; v3(137.47,103.2) 137,102.73 JCPU1.J28 ; v3(133.47,101.2) JCPU1.M26 ; v3(130.47,84.2) JCPU1.T10 ; v3(133.47,76.2) JCPU1.N2 ; v3(109.47,84.2) 109.94,84.67 JCPU1.AT10 ; JCPU1.A16 v3(144.47,91.2) ; v3(130.47,75.2) JCPU1.T1 ; JCPU1.E7 v3(140.47,82.2) ; JCPU1.AN7 112.94,81.67 v3(112.47,81.2) ; v3(123.47,82.2) JCPU1.AB7 ; JCPU1.AT19 109.94,93.67 v3(109.47,93.2) ; v3(127.47,107.2) JCPU1.V32 ; JCPU1.AB10 124.02,84.73 124.17,84.88 124.18,84.89 124.19,84.89 124.24,84.93 124.28,84.98 124.29,85 124.47,85.18 v3(124.47,85.2) 124.94,85.67 JCPU1.AA11 ; JCPU1.B10 144,84.73 v3(144.47,85.2) ; v3(117.47,76.2) JCPU1.AH1 ; v3(142.47,85.2) 142,84.73 JCPU1.D10 ; JCPU1.AL18 114.94,92.67 v3(114.47,92.2) JCPU1.AL17 ; JCPU1.F34 139.94,108.67 v3(139.47,108.2) 139,107.73 JCPU1.G33 ; v3(135.47,80.2) JCPU1.L6 ; JCPU1.A10 145,84.73 v3(145.47,85.2) ; v3(109.47,108.2) JCPU1.AT33 ; v3(127.47,109.2) JCPU1.V34 ; v3(109.47,81.2) 109.94,81.67 JCPU1.AT7 ; v3(143.47,77.2) 143,76.73 JCPU1.C2 ; v3(136.47,76.2) JCPU1.K2 ; v3(112.47,96.2) JCPU1.AN21 ; JCPU1.F12 140,86.73 v3(140.47,87.2) ; v3(120.47,76.2) JCPU1.AE1 ; v3(109.47,90.2) 109.94,90.67 JCPU1.AT16 ; v3(136.47,85.2) 136,84.73 JCPU1.K10 ; JCPU1.D7 v3(141.47,82.2) ; v3(130.47,81.2) JCPU1.T7 ; JXDP1.3 v3(93.73,73.23) ; v3(114.47,99.2) JCPU1.AL24 ; v3(140.47,95.2) JCPU1.F21 ; JCPU1.AM7 113.94,81.67 v3(113.47,81.2) ; JCPU1.AP1 112.03,75.73 v3(112.47,76.17) 112.94,76.64 JCPU1.AN2 ; v3(133.47,79.2) JCPU1.N5 ; JCPU1.F24 139.03,98.73 v3(138.99,98.77) ; v3(114.47,86.2) JCPU1.AL11 ; v3(134.47,101.2) JCPU1.L26 ; v3(124.47,110.2) JCPU1.AA35 ; JCPU1.K29 v3(135.47,104.2) ; v3(133.47,81.2) JCPU1.N7 ; v3(133.47,80.2) JCPU1.N6 ; v3(131.47,79.2) JCPU1.R5 ; v3(130.47,108.26) JCPU1.R34 ; v3(114.47,81.2) JCPU1.AL6 ; v3(133.47,84.2) JCPU1.N10 ; v3(109.47,109.2) JCPU1.AT34 ; v3(139.47,93.2) JCPU1.F18 ; v3(110.47,97.2) JCPU1.AR22 ; v3(114.47,98.2) JCPU1.AL23 ; v3(109.47,107.2) JCPU1.AT32 ; v3(134.47,80.2) JCPU1.M6 ; v3(132.47,79.2) JCPU1.P5 ; v3(135.47,85.2) JCPU1.L11 ; v3(138.47,80.2) JCPU1.G5 ; v3(142.47,102.2) 142,101.73 JCPU1.D27 ; JXDP1.25 v3(93.7,84.23) ; v3(110.47,76.16) 110.94,76.63 JCPU1.AR2 ; v3(114.47,83.2) JCPU1.AL8 ; v3(127.47,103.2) JCPU1.V28 ; v3(139.47,94.2) JCPU1.F19
  BOTTOM w0.33: v3(139.47,82.2) JCPU1.F7 ; JCPU1.H6 137.94,80.67 v3(137.47,80.2) ; JCPU1.AN10 112.94,84.67 v3(112.47,84.2) ; JCPU1.E25 v3(141.47,100.26) ; v3(110.47,84.2) 110.94,84.67 JCPU1.AR10 ; JCPU1.C26 v3(143.47,100.2) ; JCPU1.D25 v3(142.47,100.26) ; JCPU1.AH7 v3(117.47,82.2)
  BOTTOM w0.35: v3(69.06,127.92) UV1.H14 ; v3(76.13,128.5) 76.03,128.5 75.58,128.95 UV1.K22 ; UV1.N25 v3(78.16,131.8) ; v3(64.77,131.82) 65.35,132.4 UV1.P9
  BOTTOM w0.356: v3(74.23,136.01) 73.78,136.46 UV1.Y20 ; JDIMM1.2 91.74,26.17
  BOTTOM w0.381: UC3.3 159.69,118.24 159.54,118.39 v3(159.54,118.8) ; PU703.1 47.42,167.23 v3(47.75,167.57) 47.44,167.88 PU703.2 ; UC2.3 100.46,96.83 v3(100.2,97.08) ; UH2.3 180.57,127.63 180.41,127.79 180.41,127.99 v3(180.39,128.01) ; v3(136.47,76.2) 136,75.73 JCPU1.K1 ; JIO1.1 2.5,176.69 2.82,176.37 v3(2.82,175.95) ; JCPU1.B2 144,76.73 v3(144.47,77.2) 144.94,77.67 JCPU1.A3 ; JIO1.39 1.78,186.45 v3(1.78,187) ; v3(7.57,186.31) JIO1.40 ; UV1.R11 66.98,132.88 v3(67.44,133.34) ; JCPU1.N35 132.94,110.38 v3(132.99,110.44) ; JCPU1.N31 JCPU1.M30 ; JCPU1.A4 v3(144.47,79.2)
  BOTTOM w0.4: v3(70.08,141.44) 70.03,141.44 UV1.AE14 ; v3(71.46,139.77) 71.67,139.77 71.98,139.46 UV1.AC17 ; UV1.N11 66.83,131.95 66.83,132.65 UV1.R11 ; UV1.Y6 62.98,136.97 v3(63.38,136.57) ; UV1.Y10 v3(66.33,137.8) UV1.AB10 ; v3(65.38,134.2) UV1.U9
  BOTTOM w0.457: v3(68.45,136.01) 68.86,135.6 UV1.V13 UV1.U15 70.05,134.6 70.85,133.8 UV1.T16 70.98,133.76 v3(71.38,133.37) 71.78,132.96 UV1.R17 71.79,132.8 v3(72.33,132.26) 72.78,131.81 UV1.N18 ; v3(74.3,132.2) 73.78,132.71 UV1.R20 73.78,132.84 v3(73.28,133.34) 73.26,133.34 72.81,133.8 UV1.T18 72.57,134.01 72.54,134.01 71.96,134.6 UV1.U17 71.57,134.81 71.57,134.84 70.98,135.42 UV1.V16 70.83,135.6 69.98,136.45 UV1.Y15 69.96,136.6 v3(69.41,137.15) 68.98,137.58 UV1.AA13 ; UV1.N21 74.78,131.7 v3(75.3,131.18) ; UV1.N16 70.89,131.8 v3(70.49,132.2) 69.98,132.7 UV1.R15 69.47,133.31 v3(69.47,133.4) 69.08,133.8 UV1.T13 ; 162.65,120.11 v3(162.65,120.15) ; UV1.R12 67.98,132.67 v3(68.45,132.2) 68.85,131.8 UV1.N13 ; UV1.T21 74.57,134.01 74.54,134.01 73.96,134.6 UV1.U20 UV1.V18 72.74,135.6 v3(72.33,136.01) 71.78,136.55 UV1.Y17 71.78,136.77 71.2,137.36 71.2,137.38 UV1.AA16
  BOTTOM w0.5: v3(66.33,137.8) UV1.AA11 ; UV1.AA16 70.46,138.15 UV1.AB15
  BOTTOM w0.508: C112.2 200.92,163.63 v3(201.42,163.12) ; v3(19.5,198.87) 19.88,198.49 C344.2 ; JMINI3.29 287,171.35 v3(287.34,171.69) 286.88,172.15 JMINI3.27 ; JMINI2.15 199.37,157.82 v3(199.41,157.79) ; CC137.2 149.52,96.45 v3(148.91,95.84) ; v3(234.95,159.37) 235.21,159.63 JCAM1.8 ; C603.2 192.65,148.31 v3(192.12,147.78) ; 162.65,120.11 163.03,119.73 C1554.2 ; RH70.2 157.54,117.72 v3(157.16,118.1) ; PC675.2 106.94,121.61 PC669.2 PC670.2 v3(108.14,123.18) ; JTCH1.6 181.02,140.11 180.79,139.88 v3(180.79,139.31) ; JFAN1.6 52.71,92.33 v3(52.23,92.81) ; v3(215.46,159.95) C605.2 C607.1 ; JFAN1.4 52.11,89.43 v3(52.33,89.65) ; D86.1 192.54,141.55 192.83,141.26 v3(192.83,140.85) ; YH2.2 161.95,157.44 v3(162.18,157.22) ; v3(2.67,187.38) JIO1.41 ; v3(83.69,56.76) 82.46,57.99 JSATA1.4 ; JMINI1.54 287.81,201.75 v3(288.18,201.39) ; CV143.2 v3(87.95,92.76) ; v3(240.22,164.9) 240.22,165.34 C464.2 241.12,165.66 C467.2 ; JMINI2.18 202.62,151.62 v3(203.39,152.39) ; v3(218.45,164.35) 217.87,164.35 217.49,164.73 JLVDS1.44 ; R75.2 v3(17.47,198.87) ; v3(201.74,99.81) 201.96,100.03 CH2.2 ; JMINI3.34 276.5,169.35 v3(275.94,168.8) ; JSPK1.6 v3(185.59,14.17) ; CV94.2 78.68,151.7 v3(78.51,151.54) ; JMINI3.50 v3(276.23,162.95) ; C302.2 189.09,146.18 v3(189.1,146.19) ; JMINI3.15 284.33,180.15 v3(283.99,180.5) ; CV329.2 RV184.2 94.02,100.5 v3(94.15,100.62) ; YH2.4 157.89,155.84 v3(157.46,156.28) ; v3(120.78,115.43) 120.78,116.03 PC942.2 ; JLVDS1.42 224.89,167.95 v3(225.16,167.68) ; PR509.1 120.12,144.06 PR507.1 v3(119.25,143.82) ; v3(287.19,165.75) JMINI3.43 ; PQ610.3 100.21,121.4 100.27,121.47 ; v3(82.34,153.56) 81.89,153.11 PC731.2 ; JTCH1.7 184.97,146.41 185.29,146.09 v3(185.29,145.47) ; v3(48.44,91.56) 47.66,92.33 JFAN1.5 ; JRTC1.2 243.26,153.57 243.42,153.41 v3(243.42,152.83) ; CV142.2 v3(88.84,92.76) ; CV146.2 v3(69.03,92.38) ; v3(241.24,163.88) 241.92,163.88 C463.2 242.5,164.58 C468.2 C466.2 ; v3(162.65,120.15) 162.65,120.72 RH227.2 ; v3(109.03,130.04) PR684.2 ; v3(155.42,150.27) 155.97,150.27 156.37,150.67 CH63.2 ; v3(166.93,122.47) 167.26,122.81 RH47.2 ; v3(45.79,166.3) 45.79,166.87 PC720.2 ; v3(93.32,98.52) 92.88,98.52 CV177.2 ; C614.2 C612.2 275.53,205.39 v3(275.49,205.35) ; v3(199.04,169.81) 199.54,169.31 JLVDS1.41 ; v3(119.25,144.64) PC548.1 119.48,145.27 119.81,145.6 PR512.1 ; C1555.2 59.53,91.46 v3(59.87,91.8) ; JMINI1.43 277.96,204.02 v3(278.53,204.59) ; JIO1.42 3.73,175.31 v3(2.8,175.31) ; CV95.2 80.14,146.8 79.95,146.61 79.95,146.62 v3(79.94,146.62) ; RH119.2 184.06,132.58 v3(184.52,132.12) ; v3(207.33,167.69) 206.09,166.45 JLVDS1.43 ; v3(258.64,186.43) 258.32,186.74 C611.2 ; v3(207.58,159.69) 207.58,159.31 207.3,159.03 207.3,158.25 ; v3(263.84,199.82) 263.84,200.71 263.56,201 JMINI1.15 ; CV185.2 CV181.2 58.55,112.64 v3(58.23,112.96) ; C306.2 193.66,143.53 v3(193.55,143.42) ; CV179.2 v3(93.34,96.07) ; v3(179.14,135.25) 179.14,135.44 179.66,135.96 CH44.2 ; C595.2 v3(197.82,145.43) ; C608.2 195.52,148.45 v3(195.71,148.26) ; v3(70.23,148.96) CV342.2 RV238.2 ; CV152.2 v3(93.31,99.62) ; PR529.1 128.27,147.45 PR528.2 128.58,147.68 128.88,147.98 129.21,147.98 129.57,148.34 v3(129.57,148.58) ; v3(287.27,174.55) JMINI3.21 ; RH231.2 163.6,123.14 163.6,122.59 v3(163.58,122.56) ; v3(267.96,195.65) JMINI1.18 ; CV210.2 RV120.2 61.52,94.72 v3(61.79,94.99) ; v3(62.23,112.96) CV351.2 RV196.2 ; v3(105.92,98.92) 105.65,98.66 RC79.2 105.17,98.65 RC67.2 ; v3(240.16,153.41) 239.46,154.1 JRTC1.3 ; RC81.2 103.57,101.53 v3(102.55,100.51) ; CV156.2 v3(70.81,92.38) ; v3(274.76,203.76) JMINI1.35 ; YV1.2 74.64,148.81 v3(74.17,149.28) ; v3(162.12,155.12) 161.61,154.61 CH13.1 ; PR22.2 10.14,170.72 PC14.2 9.07,170.88 v3(8.83,171.12) ; CH11.2 179.01,122.96 v3(178.85,122.8) ; CV357.2 67.54,148.15 v3(67.43,148.03) ; CV151.2 87.06,93.03 v3(87.32,92.78) ; v3(57.13,103.66) 56.3,103.66 55.87,104.09 RV117.1 55.87,105.01 56.12,105.26 CV353.2 ; v3(24.61,178.55) 23.94,178.55 ; JSATA1.13 v3(79.92,41.48) ; v3(216.16,150.61) 215.52,149.98 215.52,149.91 JMINI2.50 ; v3(287.15,168.76) 286.91,168.76 286.72,168.95 JMINI3.35 ; RC94.2 101.72,116.5 v3(102.05,116.83) ; v3(176.21,152.64) 175.81,152.24 RH146.2 ; v3(158.44,152.44) 158.44,151.58 CH64.2 ; v3(210.63,160.14) 210.63,159.06 JMINI2.35 ; v3(57.47,107.62) 57.14,107.95 RV198.2 ; v3(268.25,205.49) C1167.2 ; PC940.2 127.83,116.03 v3(127.83,115.43) ; v3(205.83,148.4) 205.83,148.81 205.68,148.96 205.68,149.27 JMINI2.26 ; JMINI2.34 208.84,148.84 208.55,148.55 v3(208.55,148.33) ; JMINI3.53 287.23,188.6 v3(288.04,189.41) ; v3(276.19,172.52) 276.54,172.52 276.57,172.55 JMINI3.26 ; PC216.2 v3(151.77,88.14) ; RV243.2 67.07,150.43 66.68,150.04 66.68,148.95 v3(66.5,148.77) ; C7.2 v3(41.09,91.33) ; PC511.2 128.16,138.03 v3(129.67,138.03) ; RV107.1 CV138.2 v3(93.34,104.96) ; v3(180.39,128.01) 179.96,128.44 CH56.2 CH55.2 ; C610.2 280.84,190.67 v3(280.75,190.76) ; PC941.2 124.14,116.03 v3(124.14,115.43) ; v3(264.42,202.17) 264.42,203.38 264.06,203.73 261.68,203.73 261.16,203.22 JMINI1.9 ; C1551.2 155.34,157.8 v3(155.78,157.36) ; v3(188.09,149.91) 188.52,149.48 Q24.3 ; v3(181.04,128.01) 181.04,128.48 CH57.2 ; C300.2 233.05,164.51 232.49,163.95 C299.2 232.49,163.71 v3(233.15,163.05) ; v3(93.33,97.71) 92.8,97.71 CV176.2 ; JDIMM1.205 v3(90.29,46.1) ; v3(203.89,148.26) C604.2 ; JMINI2.54 219.95,154.24 219.66,153.95 v3(218.6,153.95) ; JMINI2.9 196.85,158.64 196.85,158.64 196.98,158.51 196.98,158.08 v3(197.08,157.98) ; JMINI2.29 207.94,157.18 207.94,156.82 v3(207.65,156.54) ; C481.2 v3(245.3,181.66) ; RH176.2 151.69,146.5 v3(151.89,146.29) ; v3(260.86,196.59) 260.16,196.59 259.16,195.58 JMINI1.4 ; v3(288.72,185.68) 288.94,185.89 C1524.2 ; RC68.2 v3(150.63,88.06) ; PC943.2 117.1,116.09 v3(117.1,115.43) ; CV180.2 v3(66.36,91.87) ; v3(93.29,105.87) 93.27,105.85 CV139.2 ; v3(55.86,134.71) 55.86,134.5 56.19,134.18 RV111.1 ; JCAM1.6 233.21,162.34 v3(233.17,162.38) ; PR521.2 PC500.1 124.72,149.46 v3(124.97,149.72) 125.41,149.72 PC510.2 ; RC77.2 104.26,95.18 103.94,94.86 v3(103.63,94.86) ; v3(159.2,119.88) 159.7,119.88 160.28,120.45 RH230.2 ; CV150.2 CV147.2 71.69,92.64 v3(71.44,92.38) ; JXDP1.28 v3(92.58,85.52) ; D1.2 50,95.88 v3(50,97.3) ; RC59.1 103.19,111.69 v3(103,111.88) ; v3(83.63,37.01) 83.02,36.4 JSATA1.17 ; C301.2 234.89,167.82 234.55,167.49 234.08,167.49 v3(233.72,167.85) ; JMINI1.21 269.16,203.36 v3(269.81,204.02) ; v3(293.82,168.63) R15.2 ; JSATA1.11 v3(79.57,44.02) ; v3(159.08,44.63) 157.69,43.25 JDIMM1.206 ; JMINI3.18 278.69,175.75 v3(278.95,176.01) ; CC18.2 CC17.2 v2(99.39,82.35) v3(98.87,82.87) ; JTCH1.8 v3(185.54,138.81) ; v3(274.36,195.74) JMINI1.34 ; C46.2 24.12,205.54 C47.2 24.83,205.35 v3(25.91,205.35) ; v3(86.11,95.05) 85.61,94.56 CV324.2 RV131.2 ; JCAM1.9 v3(226.91,159.73) ; v3(234.98,157.51) 235.82,158.35 JCAM1.10 ; v3(83.16,153.56) 83.67,153.05 PC732.2 ; RC56.2 103.81,113.59 v3(101.22,113.59) ; C298.2 v3(200.42,173.18) ; v3(182.31,130.12) 181.96,130.47 RH81.1 ; JDIMM2.205 v3(85.74,33.57) ; JXDP1.27 v3(92.58,71.37) ; CH14.1 157.95,154.61 157.43,155.13 v3(157.43,155.36) ; v3(67.12,91.87) 67.25,92 CV189.2 ; CH17.2 157.8,123.24 157.57,123.02 157.57,123.01 157.35,122.79 157.34,122.79 157.06,122.51 v3(156.73,122.51) ; CH65.2 164.78,116.96 v3(164.79,116.96) ; CC21.2 v3(101.22,94.4) ; JSATA1.1 80.23,61.8 v3(79.82,61.39) ; v3(213.43,156.01) JMINI2.43 ; v3(191.33,162.11) 190.92,161.7 JMINI2.53 ; v3(271.16,192.76) JMINI1.26 ; v3(56.44,128.27) RV88.1 ; v3(283.97,182.55) 283.97,182.55 JMINI3.9 ; JDIMM2.206 v3(160.44,33.17) ; JRTC1.4 v3(245.81,154.8) ; JSATA1.7 80.71,54.18 80.61,54.28 v3(80.08,54.28) ; RV242.2 CV341.2 72.38,148.15 v3(72.76,148.53) ; CV130.2 v3(93.34,96.96) ; JMINI2.4 193.79,151.02 193.79,150.62 193.93,150.48 v3(193.93,150.13) ; JMINI3.4 275.94,184.55 275.66,184.84 v3(275.59,184.84) ; JSPK1.5 v3(176.74,10.32) ; CV145.2 68.14,92.61 v3(68.37,92.38) ; v3(204.92,156.39) JMINI2.21 ; v3(77.55,151.47) YV1.4 ; JMINI1.29 272.36,203.37 v3(271.97,203.76) 271.56,203.35 JMINI1.27 ; JSATA1.19 v3(83.08,33.86) ; v3(280.76,195.72) JMINI1.50 ; CV144.2 v3(69.92,92.38)
  BOTTOM w1.524: 244.41,199.06 244.41,184.97 244.4,184.95
  vias: v2(10.1,164.58) v2(58.69,152.96) v2(60.52,160.52) v2(87.7,125.15) v2(90.69,151.13) v2(104.27,34.22) v2(111.57,120.11) v2(118.37,93.46) v2(121.97,127.04) v2(123.14,136.1) v2(123.76,136.01) v2(135.07,119.56) v2(137.16,26.79) v2(151.07,138.17) v2(168.02,81.52) v2(168.66,102.35) v2(195.67,155.08) v2(202.44,44.19) v3(0.5,199.44) v3(0.5,182.56) v3(0.5,174.12) v3(0.5,165.67) v3(0.5,157.23) v3(0.5,148.79) v3(0.5,140.35) v3(1.21,169.98) v3(1.59,191.7) v3(1.78,194.87) v3(1.97,167.82) v3(2,138.85) v3(2.41,172.08) v3(3.81,195.82) v3(3.88,190.49) v3(6.03,191.38) v3(6.29,194.49) v3(8.49,219.6) v3(8.5,217.12) v3(8.49,211.52) v3(8.49,203.44) v3(12.48,138.85) v3(17.47,200.91) v3(17.47,199.89) v3(18.48,200.91) v3(18.48,199.89) v3(18.48,198.87) v3(19.5,200.91) v3(19.5,199.89) v3(22.47,152.72) v3(22.47,152.14) v3(22.96,138.85) v3(24.78,152.72) v3(24.78,152.14) v3(28.64,141.85) v3(29.22,141.85) v3(29.39,220.85) v3(29.38,218.02) v3(29.39,212.23) v3(29.38,209.97) v3(29.39,203.61) v3(29.38,201.92) v3(29.39,194.99) v3(29.38,193.86) v3(29.39,186.37) v3(29.39,177.75) v3(31.55,137.06) v3(32.89,174.25) v3(35.84,99.4) v3(36.51,153.85) v3(36.51,153.22) v3(37.15,153.85) v3(37.15,153.22) v3(38.74,143.82) v3(38.74,140.71) v3(38.71,131.99) v3(40.32,142.23) v3(41.91,143.82) v3(41.91,140.71) v3(43.25,124.47) v3(44.39,174.25) v3(44.41,115.77) v3(45.02,133.15) v3(45.02,132.51) v3(45.03,87.85) v3(45.21,130.36) v3(45.21,129.72) v3(45.66,133.15) v3(45.66,132.51) v3(45.85,130.36) v3(45.85,129.72) v3(49.66,160.33) v3(50.1,160.71) v3(52.59,171.35) v3(52.73,87.85) v3(60.42,87.85) v3(60.84,171.35) v3(61.06,102.46) v3(62.23,122.16) v3(63.15,121.4) v3(64.73,121.2) v3(66.87,120.89) v3(67.98,120.41) v3(68.12,87.85) v3(69.09,171.35) v3(70.68,154.3) v3(71.88,120.83) v3(73.41,120.51) v3(74.67,120.51) v3(75.71,120.51) v3(76.01,57.32) v3(76.01,48.66) v3(76.01,40) v3(76.01,31.34) v3(77.34,171.35) v3(77.31,77.1) v3(77.98,82.73) v3(78.23,19.99) v3(78.17,17.45) v3(78.55,85.02) v3(79.5,81.21) v3(79.69,121.34) v3(80.01,16.5) v3(80.08,21.01) v3(80.84,120.07) v3(81.09,122.16) v3(81.98,19.99) v3(82.04,17.58) v3(86.41,125.7) v3(86.59,174.25) v3(86.87,125.21) v3(87.74,10.75) v3(88.01,147.95) v3(87.95,121.8) v3(87.95,121.22) v3(87.95,120.61) v3(88.2,102.46) v3(88.71,145.53) v3(88.65,143.06) v3(91.56,20.75) v3(91.56,19.23) v3(91.56,17.71) v3(91.56,16.18) v3(91.74,12.58) v3(92.06,31.65) v3(92.18,39.85) v3(92.18,38.33) v3(92.2,25.71) v3(92.78,132.27) v3(93.03,128.83) v3(93.41,32.04) v3(93.6,23.45) v3(93.68,18.09) v3(93.68,15.8) v3(94.22,39.85) v3(94.22,38.33) v3(94.22,36.81) v3(94.43,33.9) v3(94.85,31.65) v3(94.85,30.13) v3(94.95,20.75) v3(94.95,19.23) v3(94.95,17.71) v3(94.95,16.18) v3(95.34,12.56) v3(95.59,174.25) v3(95.82,133.34) v3(95.76,129.15) v3(96.66,10.75) v3(97.39,40.24) v3(97.39,37.95) v3(97.41,33.26) v3(97.39,31.65) v3(97.39,30.13) v3(97.49,18.47) v3(97.49,16.94) v3(97.49,15.42) v3(99.25,12.63) v3(99.52,20.37) v3(99.52,18.09) v3(99.68,39.85) v3(99.68,38.33) v3(99.68,33.18) v3(99.68,31.65) v3(99.68,30.13) v3(99.68,28.61) v3(100.79,19.99) v3(100.79,18.47) v3(100.79,16.94) v3(100.79,15.42) v3(101.73,39.85) v3(101.73,38.33) v3(102.54,12.55) v3(103,40.24) v3(103,37.95) v3(103.33,19.99) v3(103.33,18.47) v3(103.33,16.94) v3(103.33,15.42) v3(103.71,33.8) v3(103.68,32.67) v3(103.69,31.65) v3(103.69,30.13) v3(103.69,25.61) v3(104.34,12.56) v3(104.59,174.25) v3(104.6,18.09) v3(104.9,23.93) v3(104.96,39.85) v3(104.96,38.33) v3(104.96,33.8) v3(104.96,31.65) v3(104.96,30.13) v3(104.96,25.68) v3(105.22,12.63) v3(105.59,10.75) v3(106.2,19.99) v3(106.2,18.47) v3(106.2,16.94) v3(106.2,15.42) v3(107.5,39.85) v3(107.5,38.33) v3(107.5,36.81) v3(107.5,31.65) v3(107.5,30.13) v3(107.5,25.74) v3(107.64,23.59) v3(107.76,12.56) v3(108.77,32.04) v3(108.77,29.75) v3(108.77,25.74) v3(108.78,23.6) v3(108.74,20.79) v3(108.74,19.26) v3(108.74,17.74) v3(108.74,16.21) v3(109.14,12.52) v3(110.01,18.12) v3(110.01,15.83) v3(110.64,39.85) v3(110.64,38.33) v3(110.64,32.95) v3(110.65,31.65) v3(110.65,30.13) v3(110.65,25.36) v3(110.64,23.59) v3(110.94,12.38) v3(111.41,20.79) v3(111.41,19.26) v3(111.41,17.74) v3(111.41,16.21) v3(112.74,12.4) v3(113.22,25.64) v3(113.35,24.12) v3(113.59,174.25) v3(114.47,88.2) v3(114.47,79.2) v3(115.84,8.75) v3(116.33,94.96) v3(116.83,94.23) v3(117.12,94.96) v3(117.21,91.01) v3(117.17,90.35) v3(117.63,96.75) v3(118.2,88.87) v3(118.37,113.67) v3(118.37,112.49) v3(118.37,111.31) v3(118.36,94.96) v3(118.55,91.02) v3(119.39,95.06) v3(119.66,96.75) v3(119.69,91.01) v3(120.04,88.94) v3(120.39,94.96) v3(120.46,113.67) v3(120.46,112.49) v3(120.46,111.31) v3(120.83,91.06) v3(121.4,91.9) v3(121.69,96.75) v3(121.85,91.08) v3(121.88,88.94) v3(122.15,145.75) v3(122.3,113.67) v3(122.3,112.49) v3(122.3,111.31) v3(122.42,94.96) v3(122.83,94) v3(122.75,90.98) v3(123.24,145.6) v3(123.18,92.6) v3(123.37,153.06) v3(123.6,96.75) v3(123.63,90.76) v3(123.6,88.94) v3(124.1,95.1) v3(124.09,8.75) v3(124.14,144.33) v3(124.14,142.8) v3(124.39,90.78) v3(124.54,154.42) v3(124.46,111.31) v3(124.56,113.67) v3(124.56,112.49) v3(125.1,143.69) v3(125.34,90.7) v3(125.37,95.1) v3(125.5,88.94) v3(125.6,142.74) v3(125.67,144.26) v3(125.76,96.75) v3(125.91,93.62) v3(126.42,90.78) v3(126.49,94.96) v3(126.59,172.75) v3(126.56,111.31) v3(126.74,93.11) v3(126.74,91.97) v3(126.75,113.67) v3(126.75,112.49) v3(127.05,90.76) v3(127.22,88.94) v3(127.31,95.08) v3(127.59,174.25) v3(127.63,93.62) v3(127.63,91.4) v3(127.79,96.75) v3(127.83,56.07) v3(127.83,55.46) v3(127.83,54.86) v3(127.83,54.25) v3(128.52,94.96) v3(128.45,93.24) v3(128.45,92.16) v3(128.77,90.76) v3(128.87,88.94) v3(129.4,93.68) v3(129.4,92.67) v3(129.4,91.65) v3(129.47,95.07) v3(129.66,94.44) v3(129.82,96.75) v3(130.05,155.12) v3(130.49,90.78) v3(130.55,94.96) v3(131,156.2) v3(131.03,88.94) v3(131.07,94.54) v3(131.48,109.21) v3(131.63,94.93) v3(131.85,96.75) v3(132.02,159.88) v3(132.15,151.95) v3(132.27,157.28) v3(132.34,8.75) v3(132.35,93.64) v3(132.35,92.69) v3(132.58,94.96) v3(132.58,91.92) v3(132.58,91.02) v3(132.99,88.94) v3(133.09,94.29) v3(133.22,25.64) v3(133.16,10.28) v3(133.48,19.86) v3(133.48,18.34) v3(133.48,16.82) v3(133.48,15.29) v3(133.59,91.52) v3(133.64,39.85) v3(133.64,38.33) v3(133.64,36.81) v3(133.79,95.02) v3(133.88,96.75) v3(133.96,150.51) v3(134.11,94.29) v3(134.08,33.48) v3(134.11,25.71) v3(134.11,23.61) v3(134.15,92.98) v3(134.18,56.05) v3(134.18,55.44) v3(134.18,54.83) v3(134.18,54.22) v3(134.25,31.65) v3(134.25,30.13) v3(134.25,28.61) v3(134.49,111.2) v3(134.59,94.96) v3(134.59,91.92) v3(134.59,91.02) v3(134.62,12.56) v3(134.69,10.28) v3(135.01,20.25) v3(135.01,17.96) v3(135.1,94.29) v3(135.09,88.94) v3(135.14,92.98) v3(135.39,174.25) v3(135.53,90.65) v3(135.63,91.52) v3(135.62,40.24) v3(135.62,37.95) v3(135.66,96.75) v3(135.69,94.93) v3(135.76,152.2) v3(135.77,31.65) v3(135.77,30.13) v3(135.77,25.36) v3(136.11,94.29) v3(136.21,10.28) v3(136.34,142.99) v3(136.27,90.42) v3(136.3,19.86) v3(136.3,18.34) v3(136.3,16.82) v3(136.3,15.29) v3(136.46,24.5) v3(136.6,94.96) v3(136.6,91.92) v3(136.6,91.02) v3(137.04,94.29) v3(137.09,92.98) v3(137.06,88.94) v3(137.2,141.99) v3(137.25,90.5) v3(137.49,94.89) v3(137.61,39.85) v3(137.61,38.33) v3(137.66,91.46) v3(137.73,10.28) v3(137.8,33.84) v3(137.8,31.65) v3(137.8,30.13) v3(137.8,28.61) v3(137.75,25.45) v3(137.87,90.6) v3(137.95,96.75) v3(138.06,94.29) v3(138.1,92.98) v3(138.54,12.35) v3(138.84,20.67) v3(138.84,19.15) v3(138.84,17.62) v3(138.84,16.1) v3(139.64,39.85) v3(139.64,38.33) v3(139.64,36.81) v3(139.64,32.04) v3(139.64,29.75) v3(139.96,23.68) v3(140.11,18) v3(140.11,15.72) v3(140.34,25.45) v3(140.59,8.75) v3(141.38,20.67) v3(141.38,19.15) v3(141.38,17.62) v3(141.38,16.1) v3(142.1,39.85) v3(142.1,38.33) v3(142.1,36.81) v3(142.1,31.65) v3(142.1,30.13) v3(142.1,28.61) v3(142.14,12.52) v3(143.19,174.25) v3(143.92,19.99) v3(143.92,18.47) v3(143.92,16.94) v3(143.92,15.42) v3(144.69,133.53) v3(144.72,23.8) v3(144.8,38.33) v3(144.78,33.77) v3(144.8,31.65) v3(144.8,30.13) v3(144.8,28.61) v3(144.8,25.34) v3(144.85,12.56) v3(145.04,147.26) v3(145.29,150.04) v3(145.57,20.37) v3(145.57,18.09) v3(146.01,25.4) v3(146.07,40.24) v3(146.07,37.95) v3(146.17,31.67) v3(146.17,30.15) v3(146.75,147.63) v3(146.84,19.99) v3(146.84,18.47) v3(146.84,16.94) v3(146.84,15.42) v3(147.34,39.85) v3(147.34,38.33) v3(147.32,36.95) v3(148.6,152.03) v3(148.83,31.65) v3(148.83,30.13) v3(148.74,12.52) v3(148.85,25.47) v3(149.14,20.8) v3(149.14,19.27) v3(149.14,17.75) v3(149.14,16.22) v3(149.93,157.66) v3(150.03,39.85) v3(150.03,38.33) v3(150.03,36.96) v3(150.03,33.9) v3(150.36,32.04) v3(150.36,29.75) v3(150.37,25.47) v3(150.43,18.13) v3(150.43,15.84) v3(150.99,174.25) v3(151.31,138.76) v3(151.51,147.99) v3(151.77,158.68) v3(151.89,138.74) v3(152.3,20.77) v3(152.3,19.25) v3(152.3,17.72) v3(152.3,16.2) v3(152.29,10.75) v3(152.34,12.56) v3(152.57,39.85) v3(152.57,30.13) v3(154.71,145.62) v3(156.66,133.72) v3(157.16,146.87) v3(157.57,126.98) v3(157.99,127.43) v3(158.18,145.66) v3(158.56,140.93) v3(158.62,139.06) v3(158.62,132.51) v3(158.56,131.12) v3(158.69,142.04) v3(158.79,174.25) v3(159.01,144.96) v3(159.87,144.38) v3(160.21,143.31) v3(160.59,139.12) v3(160.6,136.56) v3(160.59,133.59) v3(160.78,143.38) v3(161.23,134.61) v3(161.61,129.29) v3(161.78,145.13) v3(161.99,133.59) v3(161.99,10.75) v3(162.63,133.85) v3(162.69,132.77) v3(163.01,151.88) v3(163.32,133.98) v3(163.71,131.5) v3(163.77,142.03) v3(163.88,155.06) v3(164.09,126.61) v3(164.28,152.52) v3(164.34,125.21) v3(164.47,157.03) v3(164.48,76.51) v3(164.7,143.3) v3(164.84,145.45) v3(164.87,77.08) v3(165.09,76.51) v3(165.32,138.84) v3(165.48,77.08) v3(165.67,17.07) v3(165.67,14.53) v3(166.49,129.27) v3(166.59,174.25) v3(166.65,138.84) v3(166.65,135.58) v3(167.32,144.39) v3(167.26,141.34) v3(167.49,156.23) v3(167.51,18.09) v3(167.58,13.52) v3(167.97,133.96) v3(168.12,129.27) v3(168.26,144.48) v3(168.27,143.75) v3(168.28,131.37) v3(169.48,14.6) v3(169.55,17.01) v3(170.22,132.75) v3(170.94,40.57) v3(170.94,39.96) v3(171.18,143.86) v3(171.14,134.6) v3(171.52,34.66) v3(171.68,145.24) v3(171.69,10.75) v3(172.38,139.12) v3(172.38,138.14) v3(172.39,135.67) v3(172.85,129.35) v3(173.04,147.75) v3(173.29,32.63) v3(173.5,130.69) v3(173.93,145.28) v3(173.92,144.59) v3(173.89,129.28) v3(173.99,42.28) v3(174.31,142.1) v3(174.39,174.25) v3(174.41,131.12) v3(174.59,144.73) v3(174.55,134.09) v3(174.75,42.28) v3(174.94,127.37) v3(175.52,42.28) v3(175.63,156.26) v3(175.64,89.33) v3(175.83,149.66) v3(176.09,88.95) v3(176.21,156.9) v3(176.35,145.72) v3(176.35,128.21) v3(177.8,141.15) v3(178.75,36.19) v3(179.01,20.41) v3(179.01,19.5) v3(179.53,146.87) v3(179.77,143.5) v3(180.28,141.02) v3(180.28,25.2) v3(181.34,113.91) v3(182.19,174.25) v3(182.96,8.05) v3(184.02,75.05) v3(184.34,69.33) v3(184.34,67.81) v3(184.34,66.28) v3(184.34,31.17) v3(184.98,27.99) v3(185.04,142.67) v3(185.1,25.33) v3(185.87,69.33) v3(185.87,67.81) v3(185.87,66.28) v3(186.39,26.66) v3(186.88,22.15) v3(187.39,69.33) v3(187.39,67.81) v3(187.39,66.28) v3(187.83,28.06) v3(187.9,25.26) v3(189.99,174.25) v3(192.24,8.05) v3(192.98,110.54) v3(194.88,158.61) v3(197.79,174.25) v3(200.22,164.46) v3(200.41,163.12) v3(200.41,162.11) v3(200.56,151.75) v3(201.42,162.11) v3(201.55,164.39) v3(202.44,163.12) v3(202.44,162.11) v3(202.57,164.39) v3(202.95,155.76) v3(203.2,82.6) v3(203.74,0.5) v3(204.4,27.35) v3(205.15,171.25) v3(205.59,174.25) v3(206.69,171.63) v3(208.15,80.32) v3(208.15,78.79) v3(208.15,77.27) v3(209.64,144.39) v3(209.68,80.32) v3(209.68,78.79) v3(209.68,77.27) v3(210.38,168.71) v3(211.14,69.84) v3(211.2,80.32) v3(211.2,78.79) v3(211.2,77.27) v3(211.39,167.82) v3(213.24,0.5) v3(214.07,128.34) v3(214.06,127.74) v3(214.06,127.16) v3(214.66,128.32) v3(214.64,127.74) v3(214.64,127.16) v3(214.79,27.38) v3(216.25,27.33) v3(216.98,30.91) v3(217.11,82.16) v3(217.49,139.12) v3(219.52,32.63) v3(219.64,128.43) v3(219.64,127.67) v3(219.64,126.91) v3(220.26,172.75) v3(221.95,71.99) v3(221.95,71.38) v3(221.95,70.77) v3(223.24,10.08) v3(226.19,24.31) v3(226.19,22.02) v3(226.63,71.66) v3(226.63,71.05) v3(226.63,70.44) v3(227.71,46.03) v3(227.71,42.09) v3(227.71,25.07) v3(227.84,21.26) v3(229.24,42.92) v3(229.3,21.96) v3(229.43,24.18) v3(229.49,44.95) v3(231.29,37.94) v3(231.29,29.55) v3(232.79,56.23) v3(234,62.73) v3(234.06,63.68) v3(234.63,63.24) v3(235.21,63.68) v3(235.14,62.73) v3(235.29,173.04) v3(236.86,172.27) v3(237.47,172.27) v3(239.21,164.9) v3(239.21,163.88) v3(239.21,162.87) v3(240.22,163.88) v3(240.22,162.87) v3(240.79,159.16) v3(241.24,164.9) v3(241.24,162.87) v3(244.03,183.82) v3(244.62,183.82) v3(245.2,183.82) v3(245.74,149.98) v3(246.51,149.98) v3(247.09,131.4) v3(247.09,123.77) v3(247.09,116.14) v3(247.09,108.51) v3(247.09,100.88) v3(247.09,68.99) v3(247.27,149.98) v3(247.46,182.3) v3(247.97,179.19) v3(248.54,88.06) v3(248.54,85.46) v3(249.43,182.36) v3(249.75,142.87) v3(250.26,179.12) v3(250.57,89.21) v3(250.57,84.32) v3(251.97,182.45) v3(252.48,85.27) v3(252.54,88.19) v3(252.8,179.06) v3(254.59,147.45) v3(254.59,134.4) v3(254.84,182.48) v3(256.09,148.95) v3(258.76,167.69) v3(264.49,176.72) v3(265.25,176.72) v3(265.53,148.95) v3(266.02,176.72) v3(266.57,209.25) v3(266.89,183.12) v3(266.89,182.51) v3(267.53,183.12) v3(267.53,182.51) v3(267.7,209.25) v3(269.37,158.8) v3(269.37,157.28) v3(269.37,155.63) v3(269.69,166.04) v3(270.16,213.71) v3(270.32,174.55) v3(270.27,166.04) v3(270.69,218.7) v3(270.89,158.8) v3(270.89,157.28) v3(270.89,155.63) v3(272.04,189.98) v3(272.42,158.8) v3(272.42,157.28) v3(272.42,155.63) v3(272.62,189.98) v3(273.09,174.23) v3(274.32,183.97) v3(279.99,177.57) v3(280.6,177.56) v3(280.79,192.1) v3(280.76,191.47) v3(284.16,175.57) v3(285.19,218.7) v3(286.2,213.29) v3(286.26,206.11) v3(286.26,205.5) v3(286.26,204.89) v3(286.26,204.28) v3(287.15,166.61) v3(287.76,166.61) v3(287.85,167.25) v3(291.47,209.48) v3(291.47,207) v3(293.5,210.56) v3(293.5,205.98) v3(295.1,169.76) v3(295.1,168.24) v3(295.34,209.67) v3(295.53,207.25) v3(297.02,186.27) v3(297.02,185.66) v3(297.63,186.27) v3(297.63,185.66) v3(298.78,169.76) v3(298.78,168.24) v3(299.4,181.75) v3(299.81,203.77) v3(299.81,200.75) v3(299.91,189.73) v3(300.33,188.2) v3(300.33,186.43) v3(300.33,184.65) v3(300.33,182.87) v3(301.19,169.76) v3(301.19,168.24) v3(301.87,170.7) v3(302.1,185.41) v3(302.09,181.75) v4(9.72,160.45) v4(9.72,158.61) v4(9.78,159.57) v4(10.35,160.45) v4(10.42,159.57) v4(10.35,158.61) v4(10.99,160.45) v4(10.99,158.61) v4(11.05,159.57) v4(11.62,160.45) v4(11.62,158.61) v4(11.69,159.57) v4(13.91,157.79) v4(14.54,157.79) v4(17.78,161.72) v4(17.85,160.14) v4(17.85,158.61) v4(18.42,161.72) v4(18.48,160.14) v4(18.48,158.61) v4(18.86,157.28) v4(19.37,161.72) v4(19.43,160.14) v4(19.43,158.61) v4(19.5,157.28) v4(20,161.72) v4(20.07,160.14) v4(20.07,158.61) v4(21.15,184.84) v4(21.15,184.2) v4(21.78,185.47) v4(21.78,184.84) v4(21.78,184.2) v4(22.42,185.47) v4(22.42,184.84) v4(22.42,184.2) v4(23.05,185.47) v4(23.05,184.84) v4(23.05,184.2) v4(23.69,185.47) v4(23.69,184.84) v4(23.69,184.2) v4(55.31,147.91) v4(55.44,146.17) v4(55.44,144.58) v4(55.37,142.87) v4(55.37,141.15) v4(55.37,139.44) v4(55.37,137.72) v4(59.06,158.42) v4(59.06,157.79) v4(59.06,157.15) v4(59.06,156.52) v4(59.06,155.88) v4(59.69,158.42) v4(59.69,157.79) v4(59.69,157.15) v4(59.69,156.52) v4(59.69,155.88) v4(60.07,168.65) v4(60.33,158.42) v4(60.33,157.79) v4(60.33,157.15) v4(60.33,156.52) v4(60.33,155.88) v4(60.45,168.14) v4(60.9,168.65) v4(60.96,158.42) v4(60.96,157.79) v4(60.96,157.15) v4(60.96,156.52) v4(60.96,155.88) v4(61.28,168.14) v4(61.6,158.42) v4(61.6,157.79) v4(61.6,157.15) v4(61.6,156.52) v4(61.6,155.88) v4(61.72,168.65) v4(62.1,168.14) v4(82.15,169.81) v4(82.15,168.35) v4(82.36,165.7) v4(82.36,165.06) v4(82.55,169.12) v4(82.95,169.81) v4(82.95,168.35) v4(87.38,151.36) v4(88.01,151.36) v4(88.65,151.36) v4(89.28,151.36) v4(99.82,146.74) v4(100.46,146.74) v4(101.09,146.74) v4(101.41,125.72) v4(101.41,124.83) v4(101.41,123.94) v4(102.3,125.72) v4(102.3,124.83) v4(102.3,123.94) v4(104.01,133.78) v4(104.08,140.39) v4(104.08,137.47) v4(104.71,140.39) v4(104.71,137.47) v4(104.65,133.78) v4(106.55,133.02) v4(106.55,132.39) v4(107.19,133.02) v4(107.19,132.39) v4(107.82,146.99) v4(107.82,133.02) v4(107.82,132.39) v4(108.46,146.99) v4(109.09,146.99) v4(111.76,121.97) v4(111.76,121.34) v4(112.4,121.97) v4(112.4,121.34) v4(116.38,147.96) v4(116.78,148.47) v4(117.24,148.97) v4(117.73,134.55) v4(117.73,133.91) v4(117.73,133.28) v4(117.73,132.64) v4(117.73,132.01) v4(117.73,131.37) v4(118.62,134.55) v4(118.62,133.91) v4(118.62,133.28) v4(118.62,132.64) v4(118.62,132.01) v4(118.62,131.37) v4(119.51,134.55) v4(119.51,133.91) v4(119.51,133.28) v4(119.51,132.64) v4(119.51,132.01) v4(119.51,131.37) v4(120.4,136.52) v4(120.4,134.55) v4(120.4,133.91) v4(120.4,133.28) v4(120.4,132.64) v4(120.4,132.01) v4(120.4,131.37) v4(121.03,136.52) v4(121.29,134.55) v4(121.29,133.91) v4(121.29,133.28) v4(121.29,132.64) v4(121.29,132.01) v4(121.29,131.37) v4(122.18,134.55) v4(122.18,133.91) v4(122.18,133.28) v4(122.18,132.64) v4(122.18,132.01) v4(122.18,131.37) v4(123.95,134.55) v4(123.95,133.91) v4(123.95,133.28) v4(123.95,132.64) v4(123.95,132.01) v4(123.95,131.37) v4(124.84,134.55) v4(124.84,133.91) v4(124.84,133.28) v4(124.84,132.64) v4(124.84,132.01) v4(124.84,131.37) v4(125.03,121.59) v4(125.03,120.96) v4(125.03,120.32) v4(125.03,119.69) v4(125.73,134.55) v4(125.73,133.91) v4(125.73,133.28) v4(125.73,132.64) v4(125.73,132.01) v4(125.73,131.37) v4(125.92,122.16) v4(126.62,134.55) v4(126.62,133.91) v4(126.62,133.28) v4(126.62,132.64) v4(126.62,132.01) v4(126.62,131.37) v4(126.94,122.16) v4(134.6,122.79) v4(134.6,122.15) v4(134.6,121.52) v4(134.6,120.88) v4(135.23,123.17) v4(135.23,122.53) v4(135.23,121.9) v4(135.23,121.26) v4(163.45,104.26) v4(164.09,104.26) v4(164.72,104.26) v4(165.36,104.26) v4(166.37,97.78) v4(167.01,97.78) v4(167.26,101.91) v4(167.26,101.27) v4(167.26,100.64) v4(167.32,84.7) v4(167.32,84.06) v4(167.32,83.43) v4(167.32,82.79) v4(167.32,82.16) v4(167.9,101.27) v4(167.9,100.64) v4(167.96,84.7) v4(167.96,84.06) v4(167.96,83.43) v4(167.96,82.79) v4(167.96,82.16) v4(168.28,97.78) v4(168.53,101.27) v4(168.53,100.64) v4(168.59,84.7) v4(168.59,84.06) v4(168.59,83.43) v4(168.59,82.79) v4(168.59,82.16) v4(168.91,97.78) v4(169.23,84.7) v4(169.23,84.06) v4(169.23,83.43) v4(169.23,82.79) v4(169.23,82.16) v4(175.77,96.45) v4(175.77,94.92) v4(176.21,95.56) v4(176.28,87.05) v4(176.25,86.1) v4(176.6,96.45) v4(176.61,94.92) v4(176.72,86.57) v4(177.17,87.05) v4(177.17,86.1) v4(192.34,58.73) v4(192.79,59.3) v4(197.8,38.47) v4(197.8,37.71) v4(198.57,38.47) v4(198.57,37.71) v4(200.73,44.82) v4(200.73,44.19) v4(201.36,46.09) v4(201.36,45.46) v4(201.36,44.82) v4(201.36,44.19) v4(201.36,43.55) v4(201.49,57.46) v4(201.61,55.93) v4(201.61,55.11) v4(201.61,54.28) v4(202,46.09) v4(202,45.46) v4(202,44.82) v4(202.63,46.09) v4(202.63,45.46) v4(202.63,44.82) v4(203.27,46.09) v4(203.27,45.46) v4(203.27,44.82) v4(204.28,37.58) v4(204.28,36.95) v4(204.92,37.58) v4(204.92,36.95) v4(205.55,37.58) v4(205.55,36.95) v4(206.31,37.96) v4(206.31,37.33) v4(206.95,37.96) v4(206.95,37.33) v4(207.58,37.96) v4(207.58,37.33) v4(207.71,54.22) v4(208.47,54.22) v4(209.23,54.22) v4(210,54.22) v4(218.38,42.92) v4(218.38,42.15) v4(218.38,41.39) v4(218.38,40.63)
