# Allegro board LA9932PR10-0703A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PCIE_EXP: length 220.7
  TOP w0.102: v3(228.27,32.69) 228.56,32.4 228.88,32.4 229.13,32.65 JEXP1.11
  IN1 w0.114: v3(228.27,32.69) 227.71,32.69 225.68,30.67 222.56,30.67 222.12,30.22 196.45,30.22 195.47,31.2 194.59,31.2 193.48,32.31 180.56,32.31 178.79,30.53 171.52,30.53 169.8,32.25 169.8,38.41 167.75,40.46 162.47,40.46 157,45.94 157,77.76 154.41,80.35 154.41,101.69 156.71,103.99 156.71,107.49 150.73,113.47 150.73,114.05 146.26,118.52 146.26,133.3 146.9,133.93 146.9,139.51 149.67,142.28 149.67,149.75 150.72,150.8 155.89,150.8 156.68,151.59 158.91,151.59 160.04,152.72 163.71,152.72 163.83,152.84 v3(164.12,153.13)
  BOTTOM w0.089: UH1.AF45 165.39,146.78 165.39,146.98 165.29,147.08 165.19,147.08 165.04,146.93 164.94,146.93 164.84,147.02 164.84,148.26 164.85,148.27 164.85,148.35 164.86,148.35 164.86,148.37
  BOTTOM w0.102: 164.86,148.37 164.86,149.07 164.54,149.38 164.54,149.77 163.79,150.52 163.79,152.8 164.01,153.02 v3(164.12,153.13)
CLK_PCIE_EXP#: length 221.2
  TOP w0.102: JEXP1.9 228.31,32.15 v3(228.27,32.11)
  IN1 w0.114: v3(163.54,153.13) 163.42,153.01 159.92,153.01 158.79,151.88 156.56,151.88 155.77,151.09 150.6,151.09 149.38,149.87 149.38,142.4 146.6,139.63 146.6,134.06 145.97,133.42 145.97,118.39 150.43,113.93 150.43,113.35 156.42,107.37 156.42,104.11 154.12,101.81 154.12,80.23 156.71,77.64 156.71,45.82 162.35,40.17 167.63,40.17 169.51,38.29 169.51,32.13 171.39,30.24 178.91,30.24 180.68,32.02 193.36,32.02 194.46,30.91 195.35,30.91 196.33,29.93 222.24,29.93 222.68,30.37 225.8,30.37 227.83,32.4 227.98,32.4 v3(228.27,32.11)
  BOTTOM w0.089: UH1.AF43 165.16,145.87 165.16,146.36 164.6,146.92 164.6,148.37
  BOTTOM w0.102: v3(163.54,153.13) 163.54,150.42 164.28,149.67 164.28,149.28 164.6,148.96 164.6,148.37
CLK_PCIE_LAN: length 98.5
  TOP w0.102: U31.44 240.82,160.36 240.96,160.22 240.97,160.22 241.09,160.1 241.09,159.91 v3(240.92,159.74)
  IN4 w0.114: v3(168.47,165.02) 168.76,165.31 171.25,165.31 171.57,165.64 177.12,165.64 182.1,160.66 199.18,160.66 199.28,160.76 235.09,160.76 235.62,160.23 237.49,160.23 237.71,160.45 241.02,160.45 241.21,160.26 241.21,160.03 v3(240.92,159.74)
  BOTTOM w0.089: UH1.AA42 167.39,145.41 167.39,145.89 167.59,146.09 167.59,146.33 167.42,146.49 167.42,146.88 167.41,146.89 167.41,147.04 167.61,147.23 167.64,147.23 168,147.59 168.01,147.59 168.16,147.74 168.16,147.82 168.16,147.82 168.16,147.84
  BOTTOM w0.102: v3(168.47,165.02) 168.37,165.12 168.13,165.12 167.89,164.89 167.89,161.55 168.31,161.13 168.31,153.53 168.16,153.37 168.16,147.84
CLK_PCIE_LAN#: length 98.5
  TOP w0.102: v3(241.5,159.74) 241.34,159.91 241.34,160.21 241.22,160.33 U31.45
  IN4 w0.114: v3(241.5,159.74) 241.5,160.38 241.14,160.75 237.59,160.75 237.36,160.52 235.75,160.52 235.21,161.05 199.16,161.05 199.06,160.95 182.22,160.95 177.24,165.93 171.45,165.93 171.13,165.6 v3(168.47,165.6)
  BOTTOM w0.089: UH1.AA44 167.22,146.15 167.09,146.15 167.01,146.23 167.01,146.37 167.17,146.53 167.17,146.53 167.18,146.54 167.18,146.78 167.17,146.79 167.17,147.14 167.51,147.48 167.54,147.48 167.91,147.84
  BOTTOM w0.102: 167.91,147.84 167.91,153.48 168.06,153.63 168.06,161.03 167.64,161.45 167.64,164.99 168.02,165.38 168.24,165.38 v3(168.47,165.6)
CLK_PCIE_MINI1: length 149.5
  IN4 w0.114: v3(263.15,200.2) 263,200.05 262.61,200.05 262.15,199.6 262.15,194.93 261.37,194.14 261.37,181.22 254.2,174.05 248.28,174.05 241.55,167.33 239.33,167.33 237.34,165.34 233.55,165.34 232.26,164.05 219.91,164.05 219.69,163.83 218.19,163.83 217.97,164.06 204.26,164.06 203.08,165.24 199.24,165.24 198.65,165.83 188,165.83 185.58,163.41 181.99,163.41 177.48,167.92 169.68,167.92 169.36,167.6 v3(169.36,167.02)
  BOTTOM w0.089: 168.67,150.27 168.67,150.26 168.68,150.25 168.68,150.17 168.68,150.16 168.68,149.23 169.11,148.8 169.11,148.36 168.03,147.27 168.03,147 167.96,146.93 167.9,146.93 167.77,147.06 167.68,147.06 167.6,146.98 167.6,146.77 UH1.Y45
  BOTTOM w0.102: 168.67,150.27 168.67,153.09 168.8,153.22 168.8,164.01 169.69,164.91 169.69,166.69 v3(169.36,167.02) ; v3(263.15,200.2) 262.82,199.87 262.36,199.87 262.21,200.02 262.21,200.72 262.42,200.93 262.66,200.93 262.76,201.03 JMINI1.13
CLK_PCIE_MINI1#: length 149.5
  IN4 w0.114: v3(263.15,199.62) 263,199.76 262.73,199.76 262.45,199.47 262.45,194.81 261.66,194.02 261.66,181.1 254.32,173.76 248.4,173.76 241.67,167.04 239.45,167.04 237.46,165.05 233.68,165.05 232.38,163.76 220.03,163.76 219.81,163.54 218.07,163.54 217.84,163.77 204.13,163.77 202.96,164.95 199.12,164.95 198.53,165.53 188.12,165.53 185.7,163.12 181.87,163.12 177.36,167.63 169.8,167.63 169.65,167.48 169.65,167.31 v3(169.94,167.02)
  BOTTOM w0.089: UH1.Y43 167.77,145.82 167.77,146.29 168.27,146.79 168.27,147.17 169.36,148.26 169.36,148.9 168.92,149.33 168.92,150.27
  BOTTOM w0.102: JMINI1.11 261.96,199.91 262.25,199.62 v3(263.15,199.62) ; 168.92,150.27 168.92,152.99 169.05,153.11 169.05,163.91 169.94,164.8 v3(169.94,167.02)
CLK_PCIE_MINI2: length 59.2
  IN4 w0.114: v3(166.22,165.32) 166.12,165.22 166.12,164.71 166.3,164.53 171.16,164.53 171.67,165.03 176.55,165.03 181.42,160.16 197.05,160.16 198.22,158.99 198.22,158.12 v3(198.29,158.06)
  BOTTOM w0.089: UH1.AE42 165.68,145.79 165.99,146.1 165.99,146.3 165.77,146.52 165.77,146.81 165.9,146.93 165.9,148.24 165.9,148.25 165.9,148.33 165.91,148.33 165.91,148.35
  BOTTOM w0.102: v3(198.29,158.06) JMINI2.13 ; v3(166.22,165.32) 166.22,160.56 165.63,159.97 165.63,158.32 165.3,157.99 165.3,154.04 165.9,153.44 165.9,152.11 165.42,151.63 165.42,150.15 165.91,149.66 165.91,148.35
CLK_PCIE_MINI2#: length 58.7
  IN4 w0.114: v3(197.68,158.17) 197.93,158.42 197.93,158.87 196.93,159.87 181.3,159.87 176.43,164.74 171.79,164.74 171.28,164.23 166.18,164.23 165.83,164.59 165.83,165.13 v3(165.63,165.32)
  BOTTOM w0.089: UH1.AE44 165.55,146.1 165.48,146.1 165.37,146.21 165.37,146.35 165.57,146.55 165.57,146.94 165.65,147.03 165.65,148.35
  BOTTOM w0.102: v3(165.63,165.32) 165.97,164.99 165.97,160.66 165.38,160.08 165.38,158.43 165.05,158.1 165.05,153.94 165.65,153.34 165.65,152.22 165.17,151.73 165.17,150.04 165.24,149.97 165.65,149.55 165.65,148.35 ; v3(197.68,158.17) 197.68,158.2 JMINI2.11
CLK_PCIE_MINI3: length 153.2
  IN4 w0.114: v3(270.47,177.46) 270.77,177.16 270.77,176.58 270.33,176.14 257.4,176.14 254.53,173.26 248.6,173.26 241.88,166.54 239.66,166.54 236.23,163.11 234.81,163.11 233.54,161.84 205.36,161.84 203.32,163.88 198.98,163.88 198.31,164.55 188.03,164.55 186.09,162.62 181.67,162.62 177.57,166.72 171.12,166.72 170.86,166.45 168.57,166.45 v3(168.28,166.74)
  BOTTOM w0.089: UH1.AD45 166.15,146.73 166.15,147.68 166.4,147.93 166.4,148.51 166.39,148.51 166.39,148.59 166.38,148.6 166.38,148.62
  BOTTOM w0.102: v3(168.28,166.74) 167.95,166.41 167.41,166.41 166.9,165.91 166.9,160.52 167.07,160.35 167.07,158.34 165.85,157.12 165.85,154.19 166.38,153.66 166.38,148.62 ; JMINI3.13 284.78,180.95 284.63,181.09 283.97,181.09 281,178.12 273.24,178.12 271.76,176.65 270.83,176.65 270.58,176.9 270.58,177.36 v3(270.47,177.46)
CLK_PCIE_MINI3#: length 153.6
  IN4 w0.114: v3(271.06,177.46) 271.06,176.46 270.45,175.85 257.52,175.85 254.65,172.97 248.72,172.97 242,166.25 239.78,166.25 236.35,162.82 234.93,162.82 233.66,161.55 205.24,161.55 203.2,163.59 198.86,163.59 198.19,164.26 188.15,164.26 186.22,162.33 181.54,162.33 177.45,166.42 171.24,166.42 170.98,166.16 v3(168.28,166.16)
  BOTTOM w0.089: 166.64,148.62 166.64,147.83 166.39,147.58 166.39,146.54 166.19,146.33 166.19,145.86 UH1.AD43
  BOTTOM w0.102: JMINI3.11 284.8,181.75 284.39,181.35 283.87,181.35 280.9,178.38 273.13,178.38 271.65,176.9 270.93,176.9 270.83,177 270.83,177.23 v3(271.06,177.46) ; 166.64,148.62 166.64,153.76 166.1,154.3 166.1,157.02 167.32,158.24 167.32,160.45 167.16,160.62 167.16,165.8 167.51,166.16 v3(168.28,166.16)
CLK_PCIE_MMI: length 182.9
  TOP w0.102: v3(181.74,29.2) 181.74,29.11 182.29,28.56 182.29,28.34 182.56,28.06 U38.3
  IN1 w0.114: v3(181.74,29.2) 181.74,29.61 181.52,29.84 180.23,29.84 179.81,29.42 170.82,29.42 168.68,31.56 168.68,38 167.3,39.39 161.42,39.39 155.92,44.89 155.92,77.32 152.81,80.43 152.81,101.62 155.63,104.44 155.63,106.99 145.18,117.44 145.18,133.74 145.82,134.38 145.82,139.95 148.59,142.73 148.59,150.2 152.03,153.63 154.64,153.63 154.95,153.94 163.96,153.94 165.87,155.84 v3(167.01,155.84)
  BOTTOM w0.089: UH1.AB45 166.9,147.2 167.41,147.71 167.41,150.15
  BOTTOM w0.102: v3(167.01,155.84) 167.58,155.28 167.58,153.85 167.41,153.68 167.41,150.15
CLK_PCIE_MMI#: length 182.8
  TOP w0.102: v3(182.37,29.2) 182.25,29.07 182.25,28.96 182.54,28.67 182.54,28.44 182.67,28.31 182.74,28.31 182.88,28.46 U38.2
  IN1 w0.114: v3(167.01,155.26) 166.72,155.55 165.99,155.55 164.08,153.65 155.07,153.65 154.76,153.34 152.15,153.34 148.88,150.08 148.88,142.61 146.11,139.83 146.11,134.26 145.47,133.62 145.47,117.56 155.92,107.11 155.92,104.31 153.1,101.49 153.1,80.55 156.21,77.44 156.21,45.01 161.55,39.68 167.42,39.68 168.98,38.12 168.98,31.68 170.94,29.71 179.69,29.71 180.11,30.13 181.64,30.13 182.03,29.73 182.03,29.54 v3(182.37,29.2)
  BOTTOM w0.089: UH1.AB43 166.78,145.88 166.78,146.33 166.59,146.52 166.59,147.24 166.65,147.3 166.65,147.3 167.16,147.81 167.16,150.04 167.16,150.04 167.16,150.12 167.15,150.13 167.15,150.15
  BOTTOM w0.102: 167.15,150.15 167.15,153.78 167.32,153.96 167.32,155.17 167.23,155.26 v3(167.01,155.26)
CLK_PCIE_VGA: length 109.1
  TOP w0.102: v3(86.83,147.96) 86.83,148.54 87.06,148.77 114.41,148.77 117.66,152.02 118.87,152.02 119.38,152.53 119.38,155.46 118.26,156.58 v3(118.26,158.55)
  IN4 w0.114: v3(118.26,158.55) 118.3,158.59 118.3,159.06 118.7,159.46 132.53,159.46 134.39,157.6 134.77,157.6 138.73,153.63 138.73,152.95 140.92,150.76 151.46,150.76 153.52,148.7 164.44,148.7 166.56,146.58 166.56,142.71 166.68,142.59 v3(167.28,142.59)
  BOTTOM w0.089: UV1.AK30 81.76,144.58 82.26,144.58 82.45,144.77 83.82,144.77 ; v3(167.28,142.59) 167.26,142.57 167.02,142.57 166.79,142.79 UH1.AB36
  BOTTOM w0.102: v3(86.83,147.96) 86.83,146.68 84.92,144.77 83.82,144.77
CLK_PCIE_VGA#: length 109.1
  TOP w0.102: v3(118.85,158.55) 118.52,158.22 118.52,156.68 119.64,155.57 119.64,152.42 118.98,151.77 117.76,151.77 114.51,148.52 87.17,148.52 87.09,148.44 87.09,148.29 87.2,148.18 v3(87.42,147.96)
  IN4 w0.114: v3(118.85,158.55) 118.59,158.8 118.59,158.94 118.82,159.17 132.41,159.17 134.27,157.3 134.65,157.3 138.44,153.51 138.44,152.83 140.8,150.47 151.34,150.47 153.4,148.41 164.32,148.41 166.27,146.46 166.27,142.59 166.56,142.3 167.01,142.3 167.28,142.02 v3(167.28,141.94)
  BOTTOM w0.089: UH1.AB35 167.19,141.94 v3(167.28,141.94) ; 83.82,144.52 83.81,144.52 83.8,144.52 83.72,144.52 83.71,144.53 82.55,144.53 82.49,144.47 82.49,144.39 82.55,144.33 82.55,144.2 82.42,144.07 82.31,144.07 UV1.AK32
  BOTTOM w0.102: 83.82,144.52 85.03,144.52 87.09,146.57 87.09,147.63 v3(87.42,147.96)
CLK_SIO_14M: length 86.8
  TOP w0.089: 177.22,144.64 176.99,144.64 RH157.1
  TOP w0.102: U46.A32 182.12,74.44 v3(182.64,74.96) ; 177.22,144.64 178.31,144.64 178.78,145.11 179.9,145.11 v1(180.37,144.64) 183.65,144.64 v3(185.64,142.65)
  IN4 w0.102: v3(185.64,142.65) 186.24,142.65 189.45,139.44 189.45,113.39 191.73,111.11 191.73,97.35 189.54,95.16 189.54,90.21 189.14,89.82 189.14,80.29 185.36,76.51 184.86,76.51 183.32,74.96 v3(182.64,74.96)
CLK_TP_SIO: length 64.2
  TOP w0.102: R3736.1 188.22,119.61 R902.2 188.74,120.13 188.74,120.66 189.33,121.25 202.13,121.25 v3(202.31,121.43) ; U51.A37 211.43,84.85 v3(211.52,84.95)
  IN4 w0.102: v3(202.31,121.43) 202.16,121.28 201.87,121.28 201.58,120.98 201.58,120.33 201.89,120.01 201.89,117.12 201.23,116.45 201.23,113.47 200.79,113.03 200.79,101.08 201.11,100.76 201.11,98.16 202.15,97.11 206.8,97.11 212.33,91.57 212.33,90.15 212.18,89.99 212.18,84.41 211.7,83.94 211.61,83.94 211.38,84.16 211.38,84.81 v3(211.52,84.95)
CLKA0: length 39.8
  TOP w0.089: v3(87.4,102.46) UV4.J12
  TOP w0.127: RV187.1 92.27,102 91.74,102 v3(91.56,102.18)
  IN1 w0.114: v3(87.4,102.46) 87.65,102.46 88.14,101.97 91.35,101.97 v3(91.56,102.18)
  IN4 w0.114: v3(87.4,102.46) 87.4,102.46 87.4,102.7 87.76,103.05 87.76,103.5 88.14,103.88 88.14,104.38 86.96,105.56 86.67,105.56 86.44,105.79 86.44,106.86 86.22,107.08 86.22,110.05 86.34,110.18 86.91,110.18 87.18,110.44 87.18,111.76 86.1,112.84 85.77,112.84 85.36,112.43 85.2,112.43 84.71,112.91 84.71,113.08 85.12,113.49 85.12,114.18 81.92,117.39 81.92,118.58 82.03,118.69 82.36,118.69 82.59,118.92 82.59,119.44 82.36,119.67 82.03,119.67 81.92,119.78 81.92,120.75 79.57,123.09 79.57,125.91 79.19,126.29 79.19,126.73 v3(79.46,127)
  BOTTOM w0.089: UV4.J12 v3(87.4,102.46)
  BOTTOM w0.13: v3(79.46,127) UV1.H26
CLKA0#: length 41.1
  TOP w0.089: v3(86.6,102.46) UV4.J11
  TOP w0.127: v3(91.56,101.59) 91.69,101.73 92.26,101.73 RV188.1
  IN1 w0.114: v3(86.6,102.46) 86.76,102.46 87.16,102.06 87.76,102.06 88.06,101.77 91.38,101.77 v3(91.56,101.59)
  IN4 w0.114: v3(86.6,102.46) 87,102.86 87.28,102.86 87.56,103.14 87.56,103.58 87.94,103.96 87.94,104.29 86.87,105.36 86.59,105.36 86.23,105.71 86.23,106.78 86.01,107 86.01,110.14 86.25,110.38 86.83,110.38 86.98,110.53 86.98,111.68 86.02,112.64 85.86,112.64 85.44,112.23 85.11,112.23 84.51,112.83 84.51,113.16 84.92,113.57 84.92,114.1 81.71,117.3 81.71,118.66 81.95,118.89 82.27,118.89 82.39,119.01 82.39,119.35 82.27,119.47 81.95,119.47 81.71,119.7 81.71,120.66 79.37,123.01 79.37,125.82 78.98,126.21 78.98,126.67 v3(78.66,127)
  BOTTOM w0.089: UV4.J11 v3(86.6,102.46)
  BOTTOM w0.13: UV1.H25 v3(78.66,127)
CLKA1: length 38.1
  TOP w0.089: UV3.J12 v3(61.06,103.26)
  TOP w0.127: RV189.1 55.95,102.8 57.17,102.8 57.22,102.86 v3(57.33,102.96)
  IN1 w0.114: v3(57.33,102.96) 57.43,102.86 60.42,102.86 60.62,103.06 60.95,103.06 61.06,103.18 v3(61.06,103.26)
  IN4 w0.114: v3(64.97,126.13) 64.89,126.22 64.89,126.47 65.01,126.6 65.23,126.6 65.53,126.3 65.53,119.38 65.42,119.26 65.33,119.26 65.1,119.03 65.1,118.52 65.33,118.29 65.77,118.29 65.89,118.16 65.89,117.84 65.77,117.71 65.33,117.71 65.1,117.48 65.1,116.97 65.33,116.74 65.67,116.74 65.77,116.64 65.77,116.34 63.62,114.18 63.62,112.95 63.45,112.79 62.84,112.79 62.47,112.42 62.47,112.09 62.67,111.9 62.67,111.74 62.43,111.5 62.26,111.5 61.91,111.85 61.56,111.85 61.22,111.51 61.22,111.16 61.57,110.8 61.57,110.26 61.08,109.76 61.08,105.04 60.38,104.34 60.38,103.73 60.66,103.44 60.88,103.44 v3(61.06,103.26)
  BOTTOM w0.089: UV3.J12 v3(61.06,103.26)
  BOTTOM w0.13: v3(64.97,126.13) 64.97,126.14 64.97,126.18 65.38,126.58 UV1.G9
CLKA1#: length 39.5
  TOP w0.089: UV3.J11 v3(61.86,103.26)
  TOP w0.127: v3(57.33,102.38) 57.17,102.54 56.08,102.54 RV190.1
  IN1 w0.114: v3(57.33,102.38) 57.61,102.66 60.5,102.66 60.71,102.86 UV3.J11 v3(61.86,103.26)
  IN4 w0.114: v3(64.97,126.98) 65.15,126.8 65.32,126.8 65.74,126.38 65.74,119.29 65.5,119.06 65.42,119.06 65.3,118.95 65.3,118.6 65.42,118.49 65.85,118.49 66.1,118.24 66.1,117.76 65.85,117.51 65.42,117.51 65.3,117.4 65.3,117.05 65.42,116.94 65.76,116.94 65.98,116.72 65.98,116.25 63.82,114.09 63.82,112.87 63.53,112.58 62.92,112.58 62.68,112.34 62.68,112.18 62.87,111.98 62.87,111.65 62.51,111.29 62.18,111.29 61.83,111.65 61.65,111.65 61.42,111.42 61.42,111.24 61.78,110.89 61.78,110.18 61.28,109.68 61.28,104.96 60.58,104.26 60.58,103.81 60.75,103.65 61.48,103.65 v3(61.86,103.26)
  BOTTOM w0.089: UV3.J11 v3(61.86,103.26)
  BOTTOM w0.13: v3(64.97,126.98) UV1.H9
CLKRUN#: length 141.6
  TOP w0.102: U51.A32 215.65,82.54 v3(215.9,82.8) ; U39.15 208.76,108.1 208.41,108.45 208.41,110.24 v3(208.89,110.72) ; U46.B20 188.87,71.5 v3(189.21,71.16) ; v3(162.72,122.34) 162.69,122.31 RH90.2
  IN2 w0.089: 162.72,125 162.72,125.18 163.2,125.66 163.2,128.53 162.27,129.45 162.27,130.18 v3(161.79,130.66)
  IN2 w0.127: v3(162.72,122.34) 162.72,125
  IN3 w0.127: v3(189.21,71.16) 189.12,71.16 188.85,71.43 188.85,72 189.07,72.21 190.39,72.21 190.78,72.6 196.94,72.6 198.23,73.89 200.65,73.89 201.87,75.11 201.87,76.51 202.82,77.46 204.35,77.46 205.17,78.29 211.58,78.29 212.17,78.87 214.18,78.87 215.43,80.12 217.25,80.12 217.78,80.65 217.78,82.44 216.98,83.24 216.34,83.24 215.9,82.8 v3(215.9,82.8) ; v3(208.89,110.72) 208.89,112.4 207.19,114.1 200.21,114.1 199.64,113.53 186.15,113.53 184.38,115.31 177.74,115.31 177.19,115.85 174.82,115.85 174.45,116.22 172.46,116.22 171.88,116.81 169.75,116.81 169.6,116.65 167.92,116.65 166.16,118.42 165.76,118.42 165.56,118.62 165.56,120.36 163.78,122.14 162.91,122.14 v3(162.72,122.34)
  IN4 w0.102: v3(208.89,110.72) 209.72,109.9 209.72,103.58 217.35,95.95 217.35,84.24 215.9,82.8 v3(215.9,82.8)
  BOTTOM w0.089: v3(161.79,130.66) 161.88,130.57 UH1.AN7
  BOTTOM w0.102: v1(188.38,70.37) 189.17,71.16 v3(189.21,71.16)
CLKTESTA: length 11.4
  TOP w0.089: CV85.1 59.07,136.21 v3(59.18,136.33) 59.31,136.33 v2(59.69,136.71)
  IN1 w0.089: v3(59.18,136.33) 59.82,135.69 60.31,135.69 60.76,135.25 60.76,132.53 63.53,129.76 63.77,129.76 v3(64.12,129.41)
  BOTTOM w0.089: v3(64.12,129.41) 64.53,129 UV1.K8
CLKTESTB: length 11.8
  TOP w0.089: CV86.1 59.62,135.75 59.25,135.75 v3(59.18,135.69) 59.18,134.5 v2(59.42,134.25)
  IN1 w0.089: v3(63.32,129.38) 62.75,129.38 60.48,131.65 60.48,135.13 60.17,135.44 59.44,135.44 v3(59.18,135.69)
  BOTTOM w0.089: UV1.L7 63.78,129.85 v3(63.32,129.38)
COMP: length 4.7
  TOP w0.102: v3(126.75,146.55) 126.75,147.06 126.62,147.18 126.62,147.75 v1(126.3,148.07)
  TOP w0.254: v3(126.75,146.55) 126.56,146.74 PR539.2 126,145.87 PC525.2
  BOTTOM w0.203: v3(126.75,146.55) 126.43,146.55 126.1,146.21 PU500.7
COMP_VGA: length 6.5
  TOP w0.203: PU600.7 23.78,145.59 24,145.36 24,144.97 24.26,144.72 24.77,144.72 25.02,144.47
  TOP w0.254: PC611.2 25,143.23 PC614.1 25.02,144.47 ; PC611.2 PR638.2 ; PC611.2 24.13,142.37 PC613.1
CONTACTLESS_DET#: length 277.8
  TOP w0.102: v3(74.31,93.93) 74.31,92.46 72.49,90.64 59.41,90.64 v1(58.71,89.94) 57.81,89.04 49,89.04 46.71,91.33 42.72,91.33 41.77,92.28 JUSH1.4 ; RPH19.1 186.5,134.76 v3(188.04,133.23)
  IN2 w0.127: v3(179.78,133.53) 179.96,133.35 179.96,127.16 180.84,126.27 185.63,126.27 186.98,124.92 186.98,113.8 184.74,111.55 184.74,100.78 183.76,99.8 183.76,95.9 183.76,95.9 183.76,95.02 183.76,95.02 183.76,91 184.84,89.92 184.84,88.9 183.97,88.04 183.97,82.58 179.98,78.59 179.98,76.84 178.75,75.62 v3(178.06,75.62)
  IN3 w0.127: v3(74.31,93.93) 74.47,93.76 76.92,93.76 77.61,94.45 80.18,94.45 80.57,94.06 85.65,94.06 86.05,93.65 88.54,93.65 90.91,91.29 90.91,81.11 89.08,79.27 89.08,78.1 89.71,77.46 89.71,76.55 89.08,75.91 89.08,63.63 91.29,61.42 106.43,61.42 116.1,51.74 143.68,51.74 151.47,59.54 156.69,59.54 172.45,75.3 173.8,75.3 174.71,76.21 176.4,76.21 177,75.62 v3(178.06,75.62)
  BOTTOM w0.089: 177.42,134.1 176.23,134.1 176.14,134.2 175.68,134.2 175.43,134.45 174.96,134.45 UH1.C16
  BOTTOM w0.102: v3(188.04,133.23) 187.58,132.77 185.05,132.77 184.25,133.57 183.19,133.57 182.86,133.9 180.44,133.9 180.08,133.53 v3(179.78,133.53) 179.39,133.53 178.82,134.1 177.42,134.1
CPPE#: length 86.1
  TOP w0.102: RP20.7 208.46,146.33 208.64,146.51 209.37,146.51 209.63,146.76 209.63,147.5 209.81,147.68 211.52,147.68 211.88,148.03 211.88,150.94 211.33,151.49 208.47,151.49 v3(208.4,151.56)
  IN3 w0.089: 179.38,132.77 178.96,132.77 178.41,133.32 v3(177.99,133.32)
  IN3 w0.127: v3(213.69,134.95) 213.16,134.42 203.14,134.42 202.44,133.72 193.78,133.72 193.66,133.61 191.6,133.61 190.38,134.83 184.58,134.83 183.64,133.88 181.59,133.88 180.48,132.77 179.38,132.77
  BOTTOM w0.089: v3(177.99,133.32) 177.8,133.51 176.09,133.51 175.93,133.36 175.6,133.36 175.56,133.31 UH1.B13
  BOTTOM w0.102: JMINI2.37 210.95,155.97 210.57,155.59 209.21,155.59 208.4,154.78 v3(208.4,151.56) 208.78,151.18 216.34,151.18 216.93,150.6 216.93,143.98 213.96,141.01 v1(213.96,136.83) 213.96,135.22 v3(213.69,134.95)
CPU_B+: length 2.8
  BOTTOM w0.508: PR526.2 129.99,138.66 130.3,138.34 130.3,136.83
  vias: v1(106.3,155.06) v4(113.67,138.86) v4(113.67,138.23) v4(113.67,137.59) v4(114.3,138.86) v4(114.3,138.23) v4(114.3,137.59) v4(114.94,138.86) v4(114.94,138.23) v4(114.94,137.59) v4(131.57,133.98) v4(131.57,133.34) v4(131.57,132.71) v4(132.21,133.98) v4(132.21,133.34) v4(132.21,132.71) v4(132.84,133.98) v4(132.84,133.34) v4(132.84,132.71)
CPU_DETECT#: length 172.1
  TOP w0.102: U46.A3 191.73,65.06 191.86,64.92 191.86,64.23 192,64.09 192,63.85 192.35,63.51 192.35,62.73 191.9,62.28 191.9,61.9 v1(191.1,61.11) 190.78,60.79 v3(190.63,60.79) 190.63,60.59 190.88,60.34 190.88,59.65 190.62,59.4 RP4.6
  IN3 w0.127: v3(93.89,58.26) 94.44,57.71 97.84,57.71 98.79,58.66 105.77,58.66 115.1,49.33 150.73,49.33 152.89,51.49 160.72,51.49 163.1,53.87 169.53,53.87 170.62,54.95 183.13,54.95 187.35,59.17 188.22,59.17 189.83,60.79 v3(190.63,60.79)
  IN4 w0.089: 108.74,93.97 110.17,93.97 111,94.8 111,106.73 v3(111.47,107.2)
  IN4 w0.102: v3(93.89,58.26) 95.91,60.28 95.91,79.33 99.28,82.7 99.28,85.55 107.7,93.97 108.74,93.97
  BOTTOM w0.089: v3(111.47,107.2) JCPU1.AP32
CPU_DMI: length 11.7
  TOP w0.089: v3(141.47,101.2) 141.85,101.58 v4(141.85,104.99) 141.85,108.84 143.26,110.25 143.26,111.1 RC48.1
  BOTTOM w0.089: JCPU1.E26 141,100.73 v3(141.47,101.2)
CPU_DMI#: length 11.8
  TOP w0.089: v3(142.47,101.2) 142.09,101.58 142.09,108.74 143.5,110.15 143.5,110.96 RC46.1
  BOTTOM w0.089: v3(142.47,101.2) 142,100.73 JCPU1.D26
CPU_DPLL: length 9.9
  TOP w0.089: RC40.1 139.85,110.95 v4(139.85,105.83) 139.85,105.05 139.63,104.82 139.22,104.82 138.85,104.46 138.85,103.58 v3(138.47,103.2)
  BOTTOM w0.089: JCPU1.H28 138,102.73 v3(138.47,103.2)
CPU_DPLL#: length 9.8
  TOP w0.089: v3(139.47,103.2) 139.09,103.58 139.09,104.36 139.32,104.58 139.73,104.58 140.1,104.95 v4(140.1,107.91) 140.1,111.12 RC38.1
  BOTTOM w0.089: JCPU1.G28 139,102.73 v3(139.47,103.2)
CPU_EDP_HPD: length 130.9
  TOP w0.102: U27.1 197.83,165.32 197.61,165.54 v3(197.61,166.87) ; v3(131.68,164.43) 135.29,160.81 138.05,160.81 140.45,158.41 140.45,156.4 142.3,154.55 142.3,150.8 140.69,149.19 140.69,138.38 138.69,136.38 v1(138.69,130.36) RC75.1 137.84,116.26 QC3.2
  IN2 w0.127: v3(131.68,164.43) 133.19,164.43 133.68,163.95 139.12,163.95 140.46,165.29 140.46,165.71 141.83,167.08 146.9,167.08 147.96,168.14 149.67,168.14 150.16,168.63 150.89,168.63 152.27,170.01 154.86,170.01 156.54,171.69 174.12,171.69 174.71,171.11 190.96,171.11 195.2,166.87 v3(197.61,166.87)
CPU_PLTRST#: length 254
  TOP w0.102: v3(158.73,125.76) 158.65,125.68 154.81,125.68 153.7,124.56 150.99,124.56 147.58,127.98 147.58,141.55 v3(147.2,141.93) ; v3(138.96,146.8) 138.92,146.76 133.33,146.76 v1(130.71,149.37) 128.92,151.16 122.88,151.16 120.33,148.62 118.36,148.62 116.2,146.46 110.99,146.46 110.61,146.08 102.41,146.08 98.08,141.75 98.08,140.97 97.62,140.51 97.62,138.3 97.37,138.05 97.37,122.82 98.08,122.11 98.08,121.66 98.21,121.53 98.62,121.53 98.74,121.4 98.74,121.17 98.62,121.05 98.21,121.05 98.08,120.92 98.08,120.67 98.21,120.54 99.53,120.54 99.66,120.41 99.66,120.17 99.53,120.04 98.21,120.04 98.08,119.92 98.08,119.57 98.18,119.47 100.67,119.47 100.8,119.34 100.8,119.09 100.67,118.96 98.18,118.96 98.08,118.86 98.08,118.55 98.18,118.45 101.66,118.45 101.78,118.32 101.78,118.07 101.66,117.94 98.18,117.94 98.08,117.84 98.08,117.52 98.18,117.41 101.57,117.41 101.69,117.29 101.69,117.03 101.57,116.91 98.18,116.91 98.08,116.8 98.08,116.5 98.18,116.4 101.86,116.4 101.98,116.27 101.98,116.02 101.86,115.89 98.18,115.89 98.08,115.79 98.08,115.48 98.18,115.38 100.18,115.38 100.31,115.26 100.31,115 100.18,114.87 98.18,114.87 98.08,114.77 98.08,114.48 98.21,114.35 99.55,114.35 99.68,114.23 99.68,113.9 99.55,113.77 97.46,113.77 97.33,113.65 97.33,113.34 97.44,113.24 98.97,113.24 99.1,113.11 99.1,112.86 98.97,112.73 96.79,112.73 96.66,112.61 96.66,112.37 96.79,112.24 100.66,112.24 100.79,112.12 100.79,111.86 100.66,111.74 96.79,111.74 96.66,111.61 96.66,111.35 96.79,111.23 100.9,111.23 101.03,111.1 101.03,110.85 100.9,110.72 96.79,110.72 96.66,110.59 96.66,110.34 96.79,110.21 98.93,110.21 99.06,110.08 99.06,109.83 98.93,109.7 96.79,109.7 96.66,109.58 96.66,109.32 96.79,109.2 99.39,109.2 99.51,109.07 99.51,108.81 99.39,108.69 96.79,108.69 96.66,108.56 96.66,108.31 96.79,108.18 98.26,108.18 98.36,108.08 98.36,107.77 98.26,107.67 96.79,107.67 96.66,107.54 96.66,106.88 96.79,106.75 97.98,106.75 98.08,106.65 98.08,106.35 97.98,106.25 96.79,106.25 96.66,106.12 96.66,105.87 96.79,105.74 97.98,105.74 98.08,105.64 98.08,105.33 97.98,105.23 96.79,105.23 96.66,105.1 96.66,104.85 96.79,104.72 97.98,104.72 98.08,104.62 98.08,104.32 97.98,104.21 96.79,104.21 96.66,104.09 96.66,103.83 96.79,103.71 98.16,103.71 98.29,103.58 98.29,100.74 98.16,100.61 97.46,100.61 97.33,100.49 97.33,100.23 97.46,100.1 100.29,100.1 100.42,99.98 100.42,99.72 100.29,99.6 97.46,99.6 97.33,99.47 97.33,99.22 97.46,99.09 101.13,99.09 101.26,98.96 101.26,98.73 101.13,98.61 97.47,98.61 97.35,98.48 97.35,98.2 97.47,98.07 103.33,98.07 103.46,97.95 103.46,95.78 103.33,95.65 103.01,95.65 102.88,95.78 102.88,97.44 102.76,97.56 102.39,97.56 102.26,97.44 102.26,95.78 102.13,95.65 101.78,95.65 101.65,95.78 101.65,97.44 101.55,97.54 101.25,97.54 101.14,97.44 101.14,95.78 101.02,95.66 100.76,95.66 100.64,95.78 100.64,97.44 100.55,97.53 v3(99.6,97.53)
  IN4 w0.102: v3(147.2,141.93) 143.51,141.93 138.96,146.48 v3(138.96,146.8)
  BOTTOM w0.089: UH1.AU4 160.8,128.91 160.49,128.6 160.49,128.37 160.73,128.13 160.73,127.97 160.06,127.3 160.06,126.62
  BOTTOM w0.102: 160.06,126.62 160.06,126.55 159.28,125.76 v3(158.73,125.76) ; v3(99.6,97.53) 100.73,98.66 RC66.2
CPU_PLTRST#_R: length 30.5
  BOTTOM w0.089: JCPU1.AT26 108.93,100.73 108.74,100.53
  BOTTOM w0.102: RC23.1 96.98,82.49 98.38,83.89 98.38,97.91 100.04,99.57 v1(101.03,99.57) RC66.1 RC64.2 104.83,100.14 108.34,100.14 108.74,100.53
CPU_PWR_DEBUG: length 131.4
  TOP w0.102: v1(150.85,95.67) RC85.2 RC89.1 149.15,99.71 141.11,99.71 138.62,102.2 v3(137.47,102.2)
  IN3 w0.089: 146.33,99.81 140.84,99.81 138.46,102.2 v3(137.47,102.2)
  IN3 w0.127: v3(95.44,78.1) 95.44,72.12 101.66,65.9 107.7,65.9 114.37,59.24 144.65,59.24 147.26,61.85 147.26,99.18 146.62,99.81 146.33,99.81
  BOTTOM w0.089: v3(137.47,102.2) JCPU1.H27
  BOTTOM w0.102: RC22.1 95.52,78.02 v3(95.44,78.1)
CPU_PWR_DEBUG_R: length 3.8
  BOTTOM w0.102: v1(97.96,78.22) 97.88,78.22 97.67,78.02 RC22.2 96.52,77.56 95.43,77.56 95.29,77.71 95.02,77.71 95,77.73 JXDP1.12
CPU_SSC_DPLL: length 10.5
  TOP w0.089: RC44.1 141.8,111.04 141.8,110.44 v4(141.28,109.93) 141.09,109.74 141.09,102.58 v3(141.47,102.2)
  BOTTOM w0.089: JCPU1.E27 141,101.73 v3(141.47,102.2)
CPU_SSC_DPLL#: length 10.5
  TOP w0.089: v3(140.47,102.2) 140.85,102.58 140.85,109.84 141.56,110.54 141.56,111.03 RC42.1
  BOTTOM w0.089: JCPU1.F27 140,101.73 v3(140.47,102.2)
CPU_VTT_ON: length 17.8
  TOP w0.102: v3(191.12,72.18) 190.75,71.81 U46.B17 ; RP6.2 187.51,59.17 187.24,59.44 187.24,59.85 187.52,60.12 188.06,60.12 v3(188.17,60.02) 188.49,60.02 v1(189.3,60.82)
  IN4 w0.102: v3(188.17,60.02) 188.21,60.02 188.89,60.7 188.89,60.84 189.48,61.42 189.48,62.14 190.69,63.36 190.69,64.04 191.18,64.52 191.18,72.12 v3(191.12,72.18)
CPUSB#: length 45.4
  TOP w0.102: JEXP1.2 225.62,30.09 226.34,30.81 226.34,34.69 227.3,35.64 227.3,36.48 225.35,38.42 v1(221.68,38.42) v3(221.01,38.42) ; U41.9 232.05,62.48 231.98,62.54 231.65,62.54 231.58,62.48 v3(231.33,62.48) 231.29,62.48 CE10.1
  IN1 w0.102: v3(231.33,62.48) 230.89,62.04 230.89,61.59 221.93,52.63 221.93,39.35 v3(221.01,38.42)
CRT_IREF: length 4.2
  TOP w0.102: RH97.2 169.04,146.55 169.04,144.21 v3(169.24,144.01)
  BOTTOM w0.089: UH1.U40 169.24,144.24 v3(169.24,144.01)
CRT_SWITCH: length 142.1
  TOP w0.102: U46.B52 181.87,62.96 181.62,62.72 v3(181.62,61.85)
  IN2 w0.127: v3(141.67,152.01) 147.56,152.01 150.59,148.99 150.59,137.37 151,136.95 151,119.94 153.32,117.62 153.32,110.19 155.63,107.88 155.63,104.44 152.69,101.5 152.69,91.65 155.01,89.34 155.01,82.1 158.14,78.96 158.14,63.53 159.58,62.09 v3(164.64,62.09)
  BOTTOM w0.102: v3(181.62,61.85) 179.05,61.85 177.71,63.19 165.74,63.19 v3(164.64,62.09) ; v3(141.67,152.01) v1(141.67,154.1) 141.67,158.36 141.42,158.61 137.23,158.61 136.97,158.87 135.52,158.87 135.2,158.55 135.2,157.92 135.13,157.85 U6.30
CS_1.35V: length 2.8
  TOP w0.102: PR201.2 176.07,89.7 175.86,89.92 175.38,89.92 v1(175.31,89.98)
  TOP w0.203: PR201.2 176.54,89.44 176.54,88.79 176.72,88.62 PU200.13
CSA0#_0: length 33.5
  TOP w0.089: UV4.G12 v3(87.4,104.06)
  IN4 w0.127: v3(87.4,104.06) 87.4,104.07 87,104.47 85.52,104.47 85.16,104.83 85.16,110.88 85.28,111 86.17,111 86.3,111.13 86.3,111.47 86.17,111.6 84.85,111.6 83.88,112.57 83.88,114.25 81.09,117.04 81.09,118.97 78.47,121.59 78.47,124.94 77.43,125.97 77.43,126.4 77.21,126.62 76.84,126.62 76.59,126.88 76.59,127.31 v3(76.16,127.75)
  BOTTOM w0.089: UV4.G12 v3(87.4,104.06)
  BOTTOM w0.13: v3(76.16,127.75) UV1.H22
CSA1#_0: length 31.1
  TOP w0.089: UV3.L12 v3(61.06,104.06)
  IN4 w0.127: v3(61.06,104.06) 61.47,104.47 62.06,104.47 62.26,104.66 62.26,109.11 62.55,109.4 62.55,110.42 62.71,110.58 62.89,110.58 63.18,110.29 63.43,110.05 63.6,110.05 63.8,110.25 63.8,110.43 63.27,110.96 63.27,111.14 63.47,111.34 63.65,111.34 64.07,110.91 64.25,110.91 64.45,111.11 64.45,111.29 64.02,111.71 64.02,111.89 64.45,112.32 64.45,113.83 66.72,116.11 66.72,118.88 66.23,119.37 66.23,122.01 67.06,122.83 67.06,126.22 67.19,126.35 v3(67.81,126.35)
  BOTTOM w0.089: UV3.L12 v3(61.06,104.06) ; UV1.G13 68.06,126.6 v3(67.81,126.35)
CSS_GC: length 44.9
  TOP w0.254: v3(48.3,159.41) 46.83,159.41 46.01,160.23 46.01,164.05 46.46,164.5 46.46,164.97 46.24,165.19 45.47,165.19 45.15,164.87 34.33,164.87 PR702.1 ; v3(44.45,139.01) 43.82,139.64 43.82,140.1 43.69,140.23 PU800.10
  BOTTOM w0.254: v3(44.45,139.01) 44.79,139.01 45,139.22 45,142.46 44.34,143.12 44.34,147.63 48.58,151.87 v1(48.58,157.09) 48.58,159.13 v3(48.3,159.41)
CSSN_1: length 131.9
  TOP w0.254: PQ701.3 39.41,166.59 43.69,170.87 50.48,170.87 51.06,170.3 52.57,170.3 53.21,169.65 v3(53.21,169.28) PR705.2 ; PQ703.2 146.5,165.53 146,165.04 PR707.1 145.58,165.04 144.78,165.84 144.78,166.2 143.99,167 143.99,169.73 143.5,170.21 143.5,172.29 v3(143.38,172.41)
  IN1 w0.254: v3(143.38,172.41) 143.1,172.12 129.75,172.12 126.97,169.34 119.03,169.34 117.32,171.06 111.35,171.06 106.27,165.98 97.44,165.98 96.24,164.77 88.2,164.77 85.98,167 78.11,167 77.34,167.76 72.71,167.76 72.33,167.38 56.9,167.38 55.5,168.77 53.25,168.77 53.09,168.93 53.09,169.15 v3(53.21,169.28)
  BOTTOM w0.254: v3(53.21,169.28) 53.02,169.09 53.02,168.85 PR703.1 53.23,168.04 52.76,167.57 v1(52.74,167.57) 52.08,167.57 51.89,167.76 PR744.2 50.92,167.22 50.18,167.22 49.51,167.88 PU703.5
CSSP_1: length 134.9
  TOP w0.254: PQ703.5 149.23,165.53 148.78,165.98 148.78,166.61 148.21,167.19 145.98,167.19 PR706.1 145.4,166.61 144.91,166.61 144.37,167.15 144.37,169.88 143.88,170.37 143.88,172.32 v3(143.97,172.41) ; PQ702.3 35.6,165.55 38.91,165.55 43.85,170.49 50.33,170.49 50.9,169.92 52.41,169.92 52.71,169.62 52.71,169.41 v3(52.58,169.28) 52.33,169.03 PR704.2
  IN1 w0.254: v3(143.97,172.41) 143.97,172.21 143.49,171.74 129.9,171.74 127.13,168.96 118.87,168.96 117.16,170.68 111.51,170.68 106.43,165.6 97.6,165.6 96.39,164.39 88.05,164.39 85.82,166.61 77.95,166.61 77.19,167.38 72.87,167.38 72.49,167 56.74,167 55.34,168.39 53.09,168.39 52.71,168.77 52.71,169.15 v3(52.58,169.28)
  BOTTOM w0.254: v3(52.58,169.28) 52.58,168.91 PR703.2 PR736.1
CVT_LVDS_A0+: length 9.6
  TOP w0.089: U27.41 202.02,166.62 202.31,166.91 202.31,167.68 203.15,168.52 203.71,168.52 v4(205.52,170.33) 205.87,170.68 205.87,171.68 v3(206.01,171.82)
  BOTTOM w0.089: JLVDS1.32 206.04,170.16 206.04,170.61 205.87,170.78 205.87,171.68 v3(206.01,171.82)
CVT_LVDS_A0-: length 9.6
  TOP w0.089: v3(205.43,171.82) 205.58,171.68 205.58,170.8 203.59,168.81 203.03,168.81 202.02,167.8 202.02,167.03 201.62,166.63 U27.42
  BOTTOM w0.089: JLVDS1.33 205.54,170.71 205.58,170.74 205.58,171.68 v3(205.43,171.82)
CVT_LVDS_A1+: length 8.1
  TOP w0.089: v3(206.97,171.07) 206.82,170.93 206.82,170.36 v4(205.14,168.68) 204.08,167.62 203.63,167.62 203.47,167.46 202.82,166.8 202.82,166.57 202.82,166.57 U27.39
  BOTTOM w0.089: v3(206.97,171.07) 206.88,170.99 206.88,170.68 207.04,170.52 207.04,170.18 JLVDS1.30
CVT_LVDS_A1-: length 8.1
  TOP w0.089: U27.40 202.42,166.59 202.53,166.69 202.53,166.93 v4(203.27,167.67) 203.51,167.91 203.95,167.91 204.93,168.89 205.33,169.29 206.53,170.48 206.53,170.93 v3(206.38,171.07)
  BOTTOM w0.089: JLVDS1.31 206.54,170.63 206.59,170.68 206.59,170.86 v3(206.38,171.07)
CVT_LVDS_A2+: length 9.1
  TOP w0.089: U27.37 203.62,166.56 203.7,166.64 204.4,166.64 207.96,170.2 207.96,171.31 v3(208.11,171.45)
  BOTTOM w0.089: JLVDS1.28 208.04,170.79 207.94,170.9 207.94,171.28 v3(208.11,171.45)
CVT_LVDS_A2-: length 9.1
  TOP w0.089: U27.38 203.22,166.57 203.58,166.93 204.28,166.93 207.67,170.32 207.67,171.31 v3(207.53,171.45)
  BOTTOM w0.089: v3(207.53,171.45) 207.64,171.34 207.64,170.9 207.54,170.79 JLVDS1.29
CVT_LVDS_ACLK+: length 10.9
  TOP w0.089: U27.35 205.51,164.92 205.78,165.19 205.78,166.75 209.58,170.55 v3(209.58,171.45)
  BOTTOM w0.089: JLVDS1.25 209.54,170.22 209.54,170.6 209.33,170.81 209.33,171.28 209.5,171.45 v3(209.58,171.45)
CVT_LVDS_ACLK-: length 10.9
  TOP w0.089: U27.36 204.99,165.32 205.1,165.21 205.39,165.21 205.49,165.31 205.49,166.87 209.29,170.67 209.29,171.18 209.04,171.43 v3(209.04,171.69)
  BOTTOM w0.089: JLVDS1.26 v3(209.04,171.69)
CVT_LVDS_B0+: length 13.2
  TOP w0.089: v3(211.18,171.21) 210.82,170.85 210.82,169.66 210.44,169.28 209.96,169.28 v4(208.74,168.06) 206.67,165.99 206.67,164.56 205.43,163.32 U27.31
  BOTTOM w0.089: JLVDS1.22 211.04,170.6 210.83,170.81 210.83,171.16 210.91,171.24 211.15,171.24 v3(211.18,171.21)
CVT_LVDS_B0-: length 13.2
  TOP w0.089: v3(210.77,171.62) 210.77,171.21 210.53,170.97 210.53,169.78 210.32,169.57 209.84,169.57 208.53,168.27 206.38,166.11 206.38,164.68 205.31,163.61 205.04,163.61 204.94,163.72 U27.32
  BOTTOM w0.089: JLVDS1.23 210.54,171.29 210.77,171.51 v3(210.77,171.62)
CVT_LVDS_B1+: length 12.1
  TOP w0.089: U27.29 205.9,162.52 207.56,164.18 207.56,165.56 v4(207.94,165.94) 209.97,167.97 210.87,167.97 v3(211.36,168.46)
  BOTTOM w0.089: JLVDS1.20 212.04,169.88 212.04,169.15 v3(211.36,168.46)
CVT_LVDS_B1-: length 12.1
  TOP w0.089: v3(210.94,168.88) 210.94,168.46 210.75,168.27 209.85,168.27 207.27,165.68 207.27,164.3 205.78,162.81 205.15,162.81 205.04,162.92 U27.30
  BOTTOM w0.089: v3(210.94,168.88) 211.36,168.88 211.75,169.27 211.75,169.37 211.68,169.44 211.61,169.44 211.54,169.51 JLVDS1.21
CVT_LVDS_B2+: length 14.1
  TOP w0.089: U27.27 205.11,161.72 205.21,161.62 206.56,161.62 208.45,163.51 208.45,165.19 210.31,167.06 211.63,167.06 v3(212.36,167.79)
  BOTTOM w0.089: v3(212.36,167.79) 213.04,168.47 213.04,169.18 JLVDS1.18
CVT_LVDS_B2-: length 14
  TOP w0.089: U27.28 205.12,162.12 205.33,161.92 206.44,161.92 208.15,163.63 v4(208.15,164.01) 208.15,165.31 210.19,167.35 211.51,167.35 211.95,167.79 v3(211.95,168.2)
  BOTTOM w0.089: JLVDS1.19 212.54,169.4 212.75,169.2 212.75,168.59 212.36,168.2 v3(211.95,168.2)
CVT_LVDS_BCLK+: length 16.9
  TOP w0.089: v3(213.93,167.94) 213.79,168.09 213.72,168.09 213.55,167.92 213.55,167.44 212.24,166.13 210.76,166.13 209.34,164.71 209.34,163.13 208.11,161.9 206.94,160.73 v4(206.57,160.73) 205.09,160.73 204.9,160.92 204.9,160.92 U27.25
  BOTTOM w0.089: JLVDS1.15 214.54,169.56 214.54,169.28 214.8,169.02 214.8,168.24 214.5,167.94 v3(213.93,167.94)
CVT_LVDS_BCLK-: length 16.8
  TOP w0.089: v3(213.93,168.52) 213.79,168.38 213.6,168.38 213.26,168.04 213.26,167.56 212.12,166.42 210.64,166.42 209.04,164.83 209.04,163.25 v4(207.9,162.11) 206.82,161.03 205.21,161.03 204.92,161.32 U27.26
  BOTTOM w0.089: v3(213.93,168.52) 214.23,168.23 214.38,168.23 214.5,168.36 214.5,168.9 214.44,168.96 214.1,168.96 214.04,169.03 JLVDS1.16
D_CLKRUN#: length 133.5
  TOP w0.102: RP5.4 188.14,75.82 v3(188.28,75.68) 188.5,75.46 v1(188.5,74.67) 188.5,73.77 188.62,73.65 U46.A19
  IN2 w0.127: v3(147.51,159.95) 148.21,160.65 150.85,160.65 154.13,157.37 154.13,157.13 157.13,154.12 162.43,154.12 162.88,154.57 165.84,154.57 166.77,153.65 171.16,153.65 171.59,154.08 177.04,154.08 177.41,153.71 186.32,153.71 189.52,150.51 189.52,149.78 193.38,145.92 193.38,144.18 193.97,143.59 193.97,142.11 195.46,140.61 195.46,136.99 196.24,136.21 196.24,128.99 193.21,125.96 193.21,118.37 192.53,117.69 192.53,105.15 192.64,105.04 192.64,95.47 189.81,92.64 189.81,86.23 189.26,85.68 189.26,79.82 187.76,78.32 187.76,76.2 v3(188.28,75.68)
  BOTTOM w0.102: v3(147.51,159.95) 147.34,160.12 JDOCK1.111
D_DLDRQ1#: length 138.5
  TOP w0.102: v3(187.05,75.68) 187.14,75.77 RP5.2 ; v3(187.3,71.16) 186.87,71.59 U46.B24
  IN2 w0.127: v3(148.15,159.25) 148.15,158.04 150.05,156.14 154.4,156.14 156.92,153.62 162.64,153.62 163.09,154.06 165.61,154.06 166.53,153.14 171.43,153.14 171.86,153.57 176.83,153.57 177.2,153.21 186.11,153.21 189.02,150.3 189.02,149.57 192.88,145.71 192.88,142.48 194.95,140.4 194.95,136.78 195.73,136 195.73,129.2 192.7,126.17 192.7,118.58 192.02,117.9 192.02,104.93 192.13,104.83 192.13,95.68 189.3,92.85 189.3,86.44 188.75,85.89 188.75,80.15 187.05,78.46 v3(187.05,75.68)
  IN4 w0.102: v3(187.3,71.16) 187.15,71.16 186.96,71.35 186.96,72.08 188.14,73.26 188.14,74.81 187.77,75.17 187.56,75.17 v3(187.05,75.68)
  BOTTOM w0.102: v1(186.82,70.35) 187.3,70.83 v3(187.3,71.16) ; v3(148.15,159.25) 148.4,159.25 148.84,159.69 JDOCK1.117
D_LAD0: length 147.4
  TOP w0.102: v3(184.08,71.03) 184.13,71.03 184.6,71.49 184.6,71.94 184.37,72.17 U46.B29
  IN2 w0.127: v3(184.08,71.03) 184.64,71.03 184.91,71.3 184.91,72.44 185.29,72.82 187.37,72.82 189.9,75.36 189.9,81.4 189.76,81.54 189.76,85.47 190.32,86.02 190.32,91.57 193.14,94.39 193.14,101.31 194.01,102.18 194.01,109.83 193.71,110.13 193.71,124.72 197.52,128.53 197.52,139.34 194.48,142.39 194.48,143.8 193.89,144.39 193.89,146.6 192.29,148.2 191.47,148.2 189.78,149.89 189.78,150.61 186.42,153.97 177.75,153.97 176.8,154.92 173.32,154.92 173.06,154.66 170.14,154.66 166.31,154.66 165.28,155.69 163.64,155.69 162.33,154.38 157.24,154.38 154.5,157.12 154.5,157.41 151,160.9 146.56,160.9 144.95,159.29 v3(144.27,159.29)
  BOTTOM w0.102: v1(183.83,70.22) 184.08,70.47 v3(184.08,71.03) ; v3(144.27,159.29) 143.84,159.72 JDOCK1.97
D_LAD1: length 151.4
  TOP w0.102: U46.B28 184.87,72.06 184.96,71.97 184.96,71.76 v3(185.55,71.17)
  IN2 w0.127: v3(144.27,159.88) 144.27,160.01 145.42,161.15 151.14,161.15 154.81,157.48 154.81,157.17 157.35,154.63 162.22,154.63 163.01,155.42 163.01,157.98 165.48,160.45 177.09,160.45 181.92,155.62 186.75,155.62 191.17,151.19 191.17,150.47 192.05,149.6 192.98,149.6 195.92,146.65 195.92,141.56 195.92,141.3 197.78,139.44 197.78,128.43 193.97,124.62 193.97,110.23 194.27,109.93 194.27,102.07 193.4,101.2 193.4,94.29 190.57,91.46 190.57,85.91 190.02,85.36 190.02,81.64 190.16,81.5 190.16,75.26 187.47,72.57 186.37,72.57 185.99,72.19 185.99,71.43 185.73,71.17 v3(185.55,71.17)
  BOTTOM w0.102: v3(185.55,71.17) 185.23,70.85 v1(185.23,70.41) ; v3(144.27,159.88) 144.34,159.95 JDOCK1.99
D_LAD2: length 135.2
  TOP w0.102: v3(185.85,74.01) 185.62,73.78 U46.A25
  IN2 w0.127: v3(185.85,74.01) 186.5,74.67 186.5,74.99 186.38,75.11 186.38,78.57 188.24,80.43 188.24,86.1 188.79,86.65 188.79,93.06 191.62,95.89 191.62,104.62 191.51,104.72 191.51,118.11 192.19,118.79 192.19,130.89 194.45,133.15 194.45,140.19 192.34,142.29 192.34,145.52 188.51,149.36 188.51,150.09 185.9,152.7 176.99,152.7 176.62,153.06 173.85,153.06 173.17,152.38 172.22,152.38 171.72,151.88 167.07,151.88 165.4,153.55 163.3,153.55 162.85,153.11 156.66,153.11 154.14,155.63 148,155.63 145.16,158.47 v3(145.16,158.8)
  BOTTOM w0.102: v3(185.85,74.01) 185.08,74.01 v1(185,73.93) ; v3(145.16,158.8) 145.16,159.38 145.48,159.69 145.48,160.14 145.34,160.28 JDOCK1.103
D_LAD3: length 135.8
  TOP w0.102: v3(186.53,74.07) 186.12,73.66 U46.A24
  IN2 w0.127: v3(186.53,74.07) 186.88,74.43 186.88,75.17 186.63,75.42 186.63,78.46 188.49,80.32 188.49,85.99 189.05,86.55 189.05,92.96 191.87,95.78 191.87,104.72 191.76,104.83 191.76,118.01 192.44,118.69 192.44,126.28 195.48,129.31 195.48,135.9 194.7,136.68 194.7,140.3 192.62,142.37 192.62,145.6 188.76,149.47 188.76,150.19 186,152.95 177.09,152.95 176.73,153.32 173.66,153.32 172.98,152.63 172.11,152.63 171.62,152.14 167.18,152.14 165.5,153.81 163.19,153.81 162.75,153.36 156.77,153.36 154.25,155.88 148.11,155.88 145.8,158.19 v3(145.8,158.8)
  BOTTOM w0.102: JDOCK1.105 145.84,159.35 145.8,159.31 v3(145.8,158.8) ; v3(186.53,74.07) 186.53,74.89 v1(186.23,75.19)
D_LFRAME#: length 149.2
  TOP w0.102: U46.B23 v3(187.37,71.74)
  IN2 w0.127: v3(147.96,163.95) 147.96,163.31 149.06,162.21 151.52,162.21 154.55,159.18 161.4,159.18 164.05,161.82 164.05,162.06 164.52,162.52 168.49,162.52 171.63,165.67 173.9,165.67 182.55,157.02 187.33,157.02 192.6,151.74 194.53,151.74 196.89,149.39 196.89,147.82 197.39,147.32 197.39,143.9 199.18,142.12 199.18,127.85 196.79,125.46 196.79,118.5 196.38,118.09 196.38,102.11 194.79,100.53 194.79,93.71 192.98,91.89 192.98,89.68 192.09,88.79 192.09,85.17 191.73,84.81 191.73,80.69 190.41,79.37 190.41,74.26 188.82,72.67 188.14,72.67 187.37,71.89 v3(187.37,71.74)
  BOTTOM w0.102: v1(187.91,72.05) 187.6,71.74 v3(187.37,71.74) ; v3(147.96,163.95) 146.84,162.83 JDOCK1.109
D_SERIRQ: length 133.5
  TOP w0.102: RP5.3 187.64,76.37 v3(187.64,75.68) 187.64,75.43 188.12,74.96 U46.A20
  IN2 w0.127: v3(187.64,75.68) 187.37,75.96 187.37,78.41 189,80.05 189,85.78 189.56,86.34 189.56,92.75 192.38,95.57 192.38,104.93 192.27,105.04 192.27,117.8 192.95,118.48 192.95,126.06 195.99,129.1 195.99,136.11 195.21,136.89 195.21,140.51 193.13,142.59 193.13,145.82 189.27,149.68 189.27,150.4 186.21,153.46 177.3,153.46 176.94,153.83 171.73,153.83 171.3,153.39 166.64,153.39 165.71,154.32 162.98,154.32 162.54,153.87 157.03,153.87 154.51,156.39 150.16,156.39 148.59,157.96 148.59,159.5 v3(148.21,159.88)
  BOTTOM w0.102: v1(188.25,75.09) 187.66,75.68 v3(187.64,75.68) ; v3(148.21,159.88) 148.34,160.01 JDOCK1.115
DAI_12MHZ#: length 147.1
  TOP w0.102: R1654.1 264.12,150.84 264.12,150.64 263.36,149.88 253.86,149.88 v1(251.18,152.56) 251.19,152.56 250.15,153.59 250.15,153.99 250.15,153.99 250.15,154.21 249.15,155.21 v3(249.15,156.65)
  IN4 w0.102: v3(249.15,156.65) 249.15,156.43 248.41,155.69 234.01,155.69 229.63,151.31 223.89,151.31 218.02,157.18 204.15,157.18 203.49,156.52 199.39,156.52 198.82,157.09 196.46,157.09 195.52,158.03 181.76,158.03 176.53,163.26 165.78,163.26 164.08,164.96 v3(163.13,164.96)
  BOTTOM w0.102: v3(163.13,164.96) 162.86,164.96 161.7,163.8 161.7,160.92 160.69,159.91 156.63,159.91 156.02,160.52 156.02,162.22 155.05,163.19 150.68,163.19 149.45,164.42 145,164.42 144.34,163.76 141.48,163.76 140.84,163.12 JDOCK1.89
DAI_BCLK#: length 148.4
  TOP w0.102: v3(248.57,156.65) 248.57,155.09 249.39,154.27 249.39,153.56 v1(252.27,150.68) 253.56,149.39 263.64,149.39 264.68,150.43 264.68,150.51 R1668.1
  IN4 w0.102: v3(248.57,156.65) 248.1,156.17 233.81,156.17 229.43,151.79 224.09,151.79 218.22,157.66 203.95,157.66 203.38,157.09 199.52,157.09 199.04,157.57 196.66,157.57 195.21,159.02 191.79,159.02 191.29,158.52 181.96,158.52 176.73,163.74 165.98,163.74 164.12,165.6 v3(163.13,165.6)
  BOTTOM w0.102: JDOCK1.77 137.84,163.08 137.48,163.44 137.48,165.85 138.01,166.39 154.27,166.39 156.21,168.33 157.48,168.33 157.99,167.82 160.91,167.82 v3(163.13,165.6)
DAI_DI: length 170.6
  TOP w0.102: U74.24 274.73,153.67 v3(274.82,153.75)
  IN2 w0.127: v3(138.24,165.86) 137.43,166.66 137.43,168.92 139.06,170.54 139.06,171.24 141.23,173.42 193.24,173.42 194.34,172.32 198.86,172.32 200.8,170.37 207.82,170.37 210.94,167.25 218.2,167.25 220.29,165.15 220.29,155.55 222.75,153.09 228.55,153.09 231.17,155.71 241.89,155.71 246.49,151.12 249.13,151.12 250.84,152.83 251.36,152.83 253.46,154.93 258.57,154.93 261.24,157.6 264.57,157.6 266.96,155.21 273.36,155.21 v3(274.82,153.75)
  BOTTOM w0.102: v3(138.24,165.86) 138.24,165.85 138.3,165.85 139.34,164.81 JDOCK1.83 ; v3(274.82,153.75) v1(274.41,153.34)
DAI_DO#: length 164
  TOP w0.102: R1097.1 266.78,150.94 267.43,151.59 v1(267.43,152.26) 267.43,152.94 v3(266.96,153.41)
  IN2 w0.127: v3(266.96,153.41) 266.96,154.49 264.36,157.09 261.45,157.09 258.78,154.42 253.67,154.42 251.51,152.26 251.15,152.26 249.5,150.62 246.27,150.62 241.68,155.21 231.38,155.21 228.76,152.58 222.54,152.58 219.78,155.34 219.78,164.94 217.99,166.74 210.73,166.74 207.61,169.87 200.56,169.87 198.62,171.81 194.13,171.81 193.03,172.91 141.44,172.91 139.56,171.03 139.56,170.33 139.08,169.85 v3(139.08,165.85)
  BOTTOM w0.102: v3(139.08,165.85) 139.84,165.09 JDOCK1.85
DAI_LRCK#: length 167.2
  TOP w0.102: v3(271.29,152.82) U74.18
  IN2 w0.127: v3(271.29,152.82) 271.29,154.44 270.78,154.96 266.85,154.96 264.46,157.34 261.35,157.34 258.68,154.68 253.56,154.68 251.47,152.58 251.11,152.58 249.4,150.87 246.38,150.87 241.79,155.46 231.28,155.46 228.65,152.83 222.65,152.83 220.04,155.44 220.04,165.05 218.09,166.99 210.84,166.99 207.71,170.12 200.7,170.12 198.75,172.06 194.23,172.06 193.13,173.16 141.34,173.16 139.31,171.13 139.31,170.43 138.8,169.92 138.8,166.82 138.66,166.69 138.66,165.68 138.25,165.27 v3(138.24,165.27)
  BOTTOM w0.102: v3(138.24,165.27) 138.24,165.27 138.24,165.28 138.34,165.18 JDOCK1.79 ; v3(271.29,152.82) v1(270.87,153.24)
DAT_DDC2_CRT: length 153.6
  IN4 w0.102: v3(136.46,150.42) 136.35,150.42 135.93,150.84 135.93,151.27 135.57,151.63 134.43,151.63 131.85,154.21 131.85,154.76 129.87,156.75 122.04,156.75 121.36,156.07 111.63,156.07 110.73,155.17 108.28,155.17 102.14,149.03 89.34,149.03 88.9,149.46 80.53,149.46 80.53,149.46 80.25,149.46 78.52,147.73 72.99,147.73 72.26,148.45 68.46,148.45 65.5,151.41 59.31,151.41 58.57,152.15 52.66,152.15 45.72,159.09 45.38,159.09 39.17,165.3 35.56,165.3 34.01,166.85 30.33,166.85 18.62,178.55 8.76,178.55 8,179.31 8,179.71 v3(8.15,179.86)
  BOTTOM w0.102: v3(8.15,179.86) 7.98,179.69 7.98,178.89 7.76,178.68 7.44,178.68 7.24,178.89 7.15,178.89 7.02,178.75 JIO1.10 ; v3(136.46,150.42) 136.35,150.42 135.93,150.84 U6.12
DAT_DDC2_DOCK: length 28.9
  TOP w0.102: v3(135.78,150.42) 135.17,149.81 132.9,149.81 129.54,153.18 127.67,153.18 125.95,154.9 125.95,161.88 127.73,163.65 127.73,165.69 129.01,166.97 129.01,167.66 v3(128.83,167.83)
  BOTTOM w0.102: v3(135.78,150.42) 135.53,150.67 U6.13 ; v3(128.83,167.83) 129.03,168.03 129.03,168.16 128.84,168.36 JDOCK1.46
DAT_KBD: length 143.5
  TOP w0.102: RP8.7 210.88,89.92 211.15,89.65 211.15,89.49 v3(211,89.33) ; U51.B41 210.68,82.58 v3(211.11,82.15)
  IN1 w0.102: v3(138.51,170.78) 138.51,169.49 140.15,167.85 140.15,163.43 139.74,163.02 139.74,159.06 140.34,158.46 140.34,155.35 144.6,151.08 144.6,141.97 145.33,141.25 145.33,134.58 145.09,134.34 144.87,134.34 v3(144.69,134.17)
  IN4 w0.102: v3(211.11,82.15) 210.77,82.49 210.77,82.9 210.89,83.01 210.89,88.27 211.08,88.46 211.08,89.26 v3(211,89.33)
  BOTTOM w0.102: v3(138.51,170.78) 138.28,170.55 138.28,170.42 138.34,170.36 JDOCK1.80 ; v3(211,89.33) 211.18,89.51 211.18,89.99 210.61,90.57 206.15,90.57 203.07,93.65 195.6,93.65 192.89,96.37 186.54,96.37 174.56,108.35 170.68,108.35 165.85,113.17 158.12,113.17 156.9,114.39 155.67,114.39 153.1,116.96 153.1,117.9 147.92,123.09 147.92,132.5 146.05,134.37 144.89,134.37 v3(144.69,134.17)
DAT_MSE: length 134.4
  TOP w0.102: RP8.5 209.88,89.74 209.95,89.67 209.95,89.51 v3(209.78,89.34) ; U51.B42 v3(210.18,82.73)
  IN1 w0.102: v3(137.8,159.82) 137.64,159.67 137.33,159.67 136.84,159.18 136.84,155.31 137.61,154.55 140.17,154.55 143.92,150.8 143.92,132.93 144.31,132.54 144.51,132.54 v3(144.69,132.36)
  IN4 w0.102: v3(209.78,89.34) 209.95,89.16 209.95,87.46 209.55,87.05 209.55,83.74 209.77,83.52 210.34,83.52 210.44,83.42 210.44,82.99 v3(210.18,82.73)
  BOTTOM w0.102: JDOCK1.73 136.84,160.2 136.7,160.06 136.7,159.95 137.01,159.64 137.62,159.64 v3(137.8,159.82) ; v3(144.69,132.36) 144.84,132.52 146.43,132.52 147.46,131.49 147.46,122.72 152.43,117.75 152.43,116.34 156.05,112.71 165.67,112.71 170.49,107.89 174.37,107.89 186.35,95.91 192.7,95.91 195.42,93.2 202.67,93.2 205.77,90.1 209.67,90.1 209.95,89.82 209.95,89.51 v3(209.78,89.34)
DAT_TP_SIO: length 63.9
  TOP w0.102: U51.B40 v3(211.18,82.73) ; v3(202.31,120.84) 202.13,121.02 189.42,121.02 188.97,120.56 188.97,120.13 R903.2 189.49,119.61 R3735.1
  IN4 w0.102: v3(211.18,82.73) 211.18,83.49 211.4,83.71 211.8,83.71 212.41,84.32 212.41,89.9 212.56,90.05 212.56,91.67 206.89,97.34 202.25,97.34 201.33,98.25 201.33,100.85 201.02,101.17 201.02,112.93 201.46,113.38 201.46,116.36 202.12,117.02 202.12,120.11 201.8,120.42 201.8,120.89 201.96,121.05 202.11,121.05 v3(202.31,120.84)
DC_BLOCK_GC: length 59.4
  TOP w0.254: PR700.2 25.48,177.59 25.17,177.89 v3(24.62,177.89) ; v3(41.33,138.17) 41.33,138.64 41.32,138.64 PU800.7
  BOTTOM w0.254: v3(24.62,177.89) v1(26.62,175.89) 32.97,169.54 43.56,169.54 44.52,168.58 44.52,166.93 45.12,166.32 45.12,165.72 45.02,165.61 45.02,164.2 45.53,163.69 45.53,152.34 42.67,149.48 42.67,148.8 42.33,148.46 42.33,145.6 40.9,144.17 40.9,139.41 41.33,138.97 v3(41.33,138.17)
DC_IN_SS: length 4.1
  TOP w0.254: PC820.1 35.31,140.33 35.31,140.35 35.08,140.57 PR831.2 35.51,141.6 35.88,141.23 v3(36.37,141.23) PU800.34
DDBIA0_0: length 30.5
  BOTTOM w0.089: UV1.H27 80.04,127.4 80.34,127.7 80.65,127.7 80.85,127.9 82.41,127.9 82.63,127.67 83.04,127.67 83.25,127.88 ; UV5.P13 88.98,107.24 90.2,107.24 90.21,107.24
  BOTTOM w0.13: 83.25,127.88 84.82,127.88 88.13,124.57 88.13,123.4 v1(88.63,122.91) 89.3,122.24 89.3,111.8 90.76,110.34 90.76,107.77 90.24,107.24 90.21,107.24
DDBIA0_1: length 21
  TOP w0.089: UV4.D2 v3(79.4,107.26)
  IN1 w0.089: 82.18,109.89 82.18,108.52 82.11,108.45 79.19,108.45 79,108.26 79,107.67 79.4,107.26 v3(79.4,107.26)
  IN1 w0.127: 82.18,109.89 82.18,112.4 81.19,113.38 81.19,119.64 v3(81.27,119.71)
  BOTTOM w0.1: v3(81.27,119.71) 81.27,121.24 79.78,122.72 UV1.A27
DDBIA0_2: length 32
  BOTTOM w0.089: UV1.C23 76.88,123.9 76.88,123.25 76.81,123.18 76.81,122.62 77.26,122.16 ; UV5.D2 79.44,98.5 79.44,97.84 79.31,97.72 78.93,97.72 78.68,97.46 78.16,97.46 78.04,97.58
  BOTTOM w0.13: 77.26,122.16 77.26,121.14 78.54,119.86 v1(78.54,117.78) 78.54,115.84 76.19,113.49 76.19,99.43 78.04,97.58
DDBIA0_3: length 43.3
  TOP w0.089: UV4.P13 v3(88.2,98.46)
  IN1 w0.127: v3(73.43,121.67) 74.23,120.87 74.23,118.82 73.5,118.08 73.5,100.23 78.23,95.49 82.88,95.49 85.45,98.07 87.81,98.07 v3(88.2,98.46)
  BOTTOM w0.089: 73.18,121.92 73.18,123.17 73.08,123.27 73.08,123.9 UV1.C19
  BOTTOM w0.1: 73.18,121.92 v3(73.43,121.67)
