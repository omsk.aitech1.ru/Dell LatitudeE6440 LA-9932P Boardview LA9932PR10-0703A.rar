# Allegro board LA9932PR10-0703A.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VDDA_AVDD on TOP (solid shape): 278.07,155 278.07,153.22 277.92,153.07 277.5,153.07 277.22,152.79 276.92,152.79 276.79,152.92 276.79,154.81 276.92,154.95 277.39,154.95 277.53,155.09 277.98,155.09
+VDDA_AVDD on TOP (solid shape): 283.67,161.55 283.67,160.79 283.53,160.65 283.53,160.38 283.41,160.26 282.46,160.26 282.36,160.37 282.36,160.93 282.5,161.07 282.5,161.53 282.6,161.63 283.59,161.63
+VDDA_AVDD on IN4 (solid shape): 278.05,153.71 278.05,152.96 277.86,152.77 276.94,152.77 276.76,152.95 276.76,153.78 276.86,153.88 277.88,153.88
+VDDA_AVDD on IN4 (solid shape): 283.57,160.59 283.57,159.43 283.5,159.36 282.48,159.36 282.38,159.46 282.38,160.6 282.54,160.76 283.4,160.76
+VDDA_AVDD2 on TOP (solid shape): 279.85,161.54 280.79,161.54 280.86,161.47 280.86,160.9 280.7,160.74 280.7,159.94 280.65,159.86 278.72,159.86 278.52,160.05 278.52,160.5 278.33,160.7 275.34,160.7 274.96,161.08 274.95,161.08 274.78,161.25 274.78,161.52 274.87,161.61 274.88,161.62 274.9,161.62 275.48,161.62 275.51,161.62 275.58,161.69 279.7,161.69
+VDDA_PVDD on TOP (solid shape): 275.69,163.25 275.69,162.09 275.47,161.87 273.77,161.87 273.39,162.25 273.39,163.13 273.51,163.24 274.05,163.24 274.19,163.39 275.55,163.39
+VDDA_PVDD on TOP (solid shape): 269.34,164.87 269.34,164.57 269.65,164.26 270.26,164.26 270.37,164.15 270.37,162.16 270.13,161.92 269.81,161.92 269.09,162.64 268.31,162.64 268.31,162.65 267.5,162.65 267.34,162.8 267.34,163.88 267.27,163.95 266.89,163.95 266.7,164.14 266.7,164.96 266.77,165.03 269.19,165.03
+VDDA_PVDD on IN2 (solid shape): outline of 126 points within 266.71,161.91 275.65,164.63
+VDDC_CT on TOP (solid shape): 75.94,139.47 75.94,138.99 76.28,138.65 76.28,138.09 76.05,137.87 74.85,137.87 74.81,137.87 74.78,137.87 74.08,137.87 73.98,137.98 73.98,138.5 74.61,139.12 74.61,139.41 74.78,139.58 75.83,139.58
GND on TOP (solid shape): 105.13,141.35 105.13,140.3 104.96,140.13 103.89,140.13 103.82,140.21 103.82,141.32 103.93,141.44 105.03,141.44
GND on TOP (solid shape): 105.13,137.62 105.13,136.58 104.96,136.41 103.89,136.41 103.82,136.49 103.82,137.6 103.93,137.72 105.03,137.72
GND on TOP (solid shape): 114.87,121.97 114.87,118.86 114.62,118.61 111.51,118.61 111.13,118.99 111.13,121.91 111.51,122.29 114.56,122.29
GND on TOP (solid shape): 135.52,56.05 135.52,51.22 134.85,50.54 126.62,50.54 126.23,50.94 126.23,56.18 126.42,56.37 135.2,56.37
GND on TOP (solid shape): 210.59,55.87 210.59,54.31 210.12,53.84 207.71,53.84 207.33,54.22 207.33,55.92 207.74,56.33 210.14,56.33
GND on TOP (solid shape): 237.97,172.53 237.97,171.1 237.91,171.04 236.53,171.04 236.51,171.06 236.51,172.56 236.66,172.71 237.79,172.71
GND on TOP (solid shape): 281.13,178.65 281.13,177.37 280.93,177.17 279.71,177.17 279.53,177.35 279.53,178.51 279.82,178.81 280.98,178.81
GND on TOP (solid shape): 287.86,206.32 287.86,203.74 287.39,203.28 284.27,203.28 283.81,203.73 283.81,206.49 284.35,207.02 287.16,207.02
GND on TOP (solid shape): 88.65,121.9 88.65,116.96 88.6,116.92 87.71,116.92 87.63,116.99 87.63,121.85 87.86,122.07 88.48,122.07
GND on TOP (solid shape): 29.65,142.3 29.65,141.43 29.56,141.34 28.1,141.34 27.9,141.54 27.9,142.32 28.07,142.48 29.47,142.48
GND on TOP (solid shape): 88.58,127.14 88.58,125.62 87.66,124.7 87.01,124.7 86.17,125.53 86.17,126.24 86.33,126.39 86.33,127.17 86.38,127.22 88.49,127.22
GND on TOP (solid shape): 108.27,132.96 108.84,132.96 108.89,132.9 108.89,131.54 108.8,131.45 106.43,131.45 106.2,131.68 106.2,133.18 106.3,133.29 107.93,133.29
GND on TOP (solid shape): 212.03,70.03 212.03,69.08 211.9,68.95 211.65,68.95 211.33,69.27 211.14,69.27 210.89,69.52 210.89,70.03 211.01,70.16 211.9,70.16
GND on TOP (solid shape): 135.8,123.21 135.8,119.59 135.07,118.86 132.02,118.86 131.87,119.01 131.87,122.78 132.12,123.03 134.27,123.03 134.8,123.55 135.45,123.55
GND on TOP (solid shape): 153,139.27 153,137.69 152.91,137.59 151.04,137.59 150.77,137.85 150.77,139.11 151.03,139.37 152.9,139.37
GND on TOP (solid shape): 194.12,61.08 194.12,58.16 193.87,57.9 192.71,57.9 192.07,58.55 192.07,59.85 193.36,61.14 194.06,61.14
GND on TOP (solid shape): 270.52,185.47 270.52,181.8 270.17,181.46 266.86,181.46 266.39,181.93 266.39,185.22 266.96,185.79 270.19,185.79
GND on TOP (solid shape): 181.68,26.15 181.68,25.7 181.57,25.59 180.86,25.59 180.56,25.29 180.56,25.09 180.43,24.96 179.95,24.96 179.74,25.16 179.74,26.18 179.82,26.25 181.57,26.25
GND on TOP (solid shape): 220.54,43.17 220.54,40.38 220.16,40 218.12,40 217.87,40.25 217.87,43.3 218.25,43.68 220.03,43.68
GND on TOP (solid shape): 270.64,166.06 270.64,164.71 270.46,164.53 269.79,164.53 269.64,164.68 269.64,165.05 269.17,165.52 268.07,165.52 267.84,165.75 267.84,166.58 267.92,166.65 270.04,166.65
GND on TOP (solid shape): 281.86,192.95 281.86,191.49 281.66,191.29 281.66,189.49 281.41,189.23 280.76,189.23 280.63,189.36 280.63,189.65 280.46,189.83 280.46,192.97 280.56,193.07 281.74,193.07
GND on TOP (solid shape): 288.4,168.45 288.4,167.01 287.76,166.36 285.89,166.36 285.32,166.92 284.82,166.92 284.76,166.99 284.76,168.31 284.8,168.34 285.57,168.34 286.24,169.01 287.85,169.01
GND on TOP (solid shape): 172.25,40.54 172.25,39.78 172.09,39.61 169.04,39.61 168.98,39.68 168.98,40.25 169.1,40.38 170.5,40.38 170.69,40.57 170.69,40.69 170.82,40.82 171.97,40.82
GND on TOP (solid shape): 45.99,133.48 45.99,131.17 46.6,130.56 46.6,126.56 46.44,126.41 43.96,126.41 43.49,126.88 43.49,128.62 42.1,130.01 42.1,133.93 42.29,134.12 45.35,134.12
GND on TOP (solid shape): 202.5,58.85 202.5,53.84 202.44,53.77 200.79,53.77 200.73,53.84 200.73,56.51 200.34,56.89 199.77,56.89 199.63,57.02 199.63,58.21 199.71,58.28 200.79,58.28 201.55,59.05 202.31,59.05
GND on TOP (solid shape): 223.01,73.22 223.01,68.62 222.84,68.45 222.09,68.45 221.88,68.66 221.88,70.29 221.56,70.61 221.56,73.28 221.73,73.45 222.79,73.45
GND on TOP (solid shape): 166.05,106.02 166.05,104.13 165.65,103.72 163.31,103.72 163.17,103.86 163.17,104.49 163.27,104.59 164.52,104.59 164.73,104.8 164.73,106.01 164.88,106.16 165.91,106.16
GND on TOP (solid shape): 170.82,86.03 170.82,85.08 171.52,84.38 171.52,81.34 171.41,81.23 168.74,81.23 167.01,79.49 165.8,79.49 165.58,79.71 165.58,85.4 165.71,85.52 166.75,85.52 167.39,86.16 170.69,86.16
GND on TOP (solid shape): 110.77,36 110.77,33.22 110.87,33.11 110.87,33.09 110.88,33.08 110.88,32.75 109.92,31.79 108.6,31.79 108.19,31.38 103.56,31.38 103.4,31.54 103.4,36.6 103.89,37.1 109.67,37.1
GND on TOP (solid shape): 181.48,21.66 181.48,20.93 180.49,19.94 180.49,19.31 180.28,19.09 178.86,19.09 178.55,19.4 178.55,21.57 178.62,21.64 179.49,21.64 179.54,21.59 180.66,21.59 180.78,21.7 181.44,21.7
GND on TOP (solid shape): 204.75,47.02 204.75,44.78 204.6,44.63 203.33,44.63 202.63,43.93 202.63,41.71 202.43,41.51 201.35,41.51 201.05,41.81 201.05,43.21 200.41,43.84 200.41,47.04 200.92,47.55 204.22,47.55
GND on TOP (solid shape): 128.08,145.21 128.08,144.52 127.7,144.14 126.81,144.14 126.68,144.01 126.68,143.99 126.58,143.89 126.58,141.7 127.02,141.26 127.02,140.68 126.94,140.6 126.46,140.6 126.36,140.7 126.36,141 125.89,141.47 124.27,141.47 123.83,141.91 123.83,144.9 124.21,145.28 128.02,145.28
GND on TOP (solid shape): 169.17,102.42 169.17,99.56 170.05,98.67 170.05,97.65 169.93,97.53 165.99,97.53 165.93,97.46 165.74,97.27 164.82,97.27 164.69,97.41 164.69,98.92 164.82,99.05 165.74,99.05 165.93,99.24 165.93,100.51 165.67,100.76 165.67,102.35 165.99,102.67 168.91,102.67
GND on TOP (solid shape): 205.81,38.72 205.81,38.5 206.06,38.25 207.74,38.25 207.9,38.09 207.9,37.26 207.29,36.65 207.29,35.26 207.17,35.14 203.23,35.14 202.95,35.42 202.95,36.76 203.14,36.95 203.71,36.95 203.77,37.01 203.77,38.47 204.11,38.81 205.72,38.81
GND on TOP (solid shape): 84.23,170.44 84.23,170.02 84.22,169.99 83.87,168.78 83.78,167.54 83.78,167.51 82.52,166.25 82.52,161.12 82.32,160.92 81.27,160.92 81.15,161.04 81.15,166.12 81.5,166.47 81.5,170.07 82.02,170.59 84.08,170.59
GND on TOP (solid shape): 175.83,89.46 175.83,89.33 175.96,89.21 176.09,89.21 176.28,89.02 176.28,88.76 176.32,88.73 176.32,88.7 176.4,88.61 176.4,87.75 176.34,87.68 176.28,87.68 176.21,87.75 176.21,88.51 176.11,88.61 176.08,88.64 176.05,88.67 176.02,88.7 176.01,88.7 175.98,88.73 175.86,88.73 175.39,89.21 175.39,89.4 175.52,89.53 175.77,89.53
GND on TOP (solid shape): 215.95,129.49 215.95,128.76 215.96,128.74 215.96,125.63 215.81,125.48 214.88,125.48 214.67,125.69 214.22,125.69 213.81,126.1 213.81,128.41 214.67,129.28 214.69,129.28 214.89,129.39 214.99,129.59 215,129.6 215.1,129.71 215.74,129.71
GND on TOP (solid shape): 22.67,153.79 22.67,152.02 22.67,150.8 22.61,150.74 22.54,150.74 22.48,150.8 22.48,151.82 22.25,152.05 22.24,152.07 22.24,152.09 22.24,152.16 22.23,152.23 22.23,152.62 22.24,152.68 22.24,152.74 22.24,152.89 22.04,153.09 21.85,153.09 21.78,153.15 21.78,153.79 21.85,153.85 22.61,153.85
GND on TOP (solid shape): 25,153.68 25,152.85 25.02,152.83 25.02,152.8 25.01,152.72 25.02,152.62 25.02,152.23 25.01,152.16 25.01,152.09 25.01,152.07 25,152.05 24.7,151.76 24.7,150.74 24.65,150.68 24.52,150.68 24.47,150.74 24.47,151.9 24.58,152.01 24.58,152.96 24.45,153.09 23.97,153.09 23.88,153.18 23.88,153.73 23.96,153.81 24.87,153.81
GND on TOP (solid shape): 134.01,28.86 136.01,28.86 138.38,26.49 138.38,23.36 137.61,22.59 136.62,22.59 136.5,22.71 136.5,24.09 135.7,24.9 135.02,24.9 134.72,25.2 133.57,25.2 133.49,25.28 133.17,25.39 132.89,25.18 132.87,25.16 131.1,25.16 130.34,25.92 130.34,28.87 130.63,29.17 130.63,29.34 130.92,29.63 133.25,29.63
GND on TOP (solid shape): 64.14,165.65 64.14,162.84 63.96,162.66 62.77,162.66 62.55,162.44 62.55,160.53 62.83,160.25 63.9,160.25 64.07,160.07 64.07,157.15 63.94,157.02 62.8,157.02 62.51,156.73 62.51,151.87 62.22,151.57 55.6,151.57 55.23,151.95 55.23,155.24 56.07,156.09 58.22,156.09 58.68,156.54 58.68,163.88 59.12,164.33 59.12,165.09 59.12,165.09 59.12,165.86 59.19,165.93 63.86,165.93
GND on TOP (solid shape): 196.09,158.74 196.09,158.34 195.99,158.23 195.52,158.23 195.39,158.11 195.39,157.33 195.55,157.17 196.11,157.17 196.38,157.44 196.38,157.75 196.87,158.23 197.18,158.23 197.32,158.1 197.32,157.36 196.47,156.52 196.47,152.69 197.16,152.01 199.93,152.01 202.56,152.01 203.02,152.47 203.02,154.61 203.03,154.61 203.03,155.15 203.02,155.15 203.02,155.23 202.68,155.58 202.68,155.86 202.81,155.99 203.14,155.99 203.67,155.46 203.67,151.68 202.78,150.79 196.28,150.79 195.14,151.93 195.14,155.37 194.63,155.88 194.63,158.74 194.76,158.87 195.97,158.87
GND on TOP (solid shape): 80.09,87.35 84.09,83.35 80.09,79.35 77.01,79.35 77.01,86.35 76.87,86.92 76.48,87.35
GND on TOP (solid shape): 242.85,177.75 241.75,175.09 239.09,173.99 235.85,173.99 235.85,173.22 235.12,172.49 232.15,172.49 232.15,173 234.61,173 235.12,173.22 235.34,173.73 235.34,174.25 235.42,174.42 235.59,174.5 239.09,174.5 241.39,175.45 242.34,177.75 242.34,184.5 242.85,184.5
GND on TOP (solid shape): 80.09,22.78 84.09,18.78 80.09,14.78 77.01,14.78 77.01,20.81 76.8,21.49 75.86,22.23 75.71,22.68 75.71,22.78
GND on TOP (solid shape): 177.23,98.8 177.23,96.9 177.23,96.88 177.22,96.87 177.14,96.68 177.22,96.5 177.23,96.48 177.23,96.47 177.23,96.4 177.23,96.38 177.22,96.37 177.14,96.18 177.22,96 177.23,95.98 177.23,95.97 177.23,95.9 177.23,95.88 177.22,95.87 177.14,95.68 177.22,95.5 177.23,95.48 177.23,95.47 177.23,95.4 177.23,95.38 177.22,95.37 177.14,95.18 177.22,95 177.23,94.98 177.23,94.97 177.23,94.9 177.23,94.88 177.22,94.87 177.14,94.68 177.22,94.5 177.23,94.48 177.23,94.47 177.23,93.91 176.91,93.59 175.58,93.59 175.33,93.84 175.33,96.58 175.33,97.05 175.33,97.06 175.36,97.21 175.33,97.36 175.33,97.37 175.33,97.65 174.94,98.03 174.94,98.99 175.01,99.05 176.98,99.05
GND on TOP (solid shape): outline of 99 points within 115.51,125.66 128.84,136.83
GND on TOP (solid shape): 85.92,170.88 91.47,172.43 94.79,167.72 90.01,162.73 84.81,167.27 86.4,167.27 87.34,168.21 87.34,169.46
GND on TOP (solid shape): 263.84,221.9 264.37,221.68 264.59,221.15 264.59,217.47 264.54,217.2 264.39,216.97 264.15,216.58 264.07,216.12 264.07,212.75 264.43,211.86 265.32,211.5 268.19,211.5 269.08,211.86 269.44,212.75 269.44,214.28 269.36,214.73 268.99,215.34 268.94,215.61 268.94,218.2 269.16,218.73 269.69,218.95 270.89,218.95 270.92,218.93 270.94,218.9 270.94,209.94 270.94,209.89 270.94,208.78 270.5,208.35 264.77,208.35 264.77,211.1 264.7,211.1 263.87,211.75 263.56,212.75 263.56,216.12 263.59,216.44 263.67,216.74 263.67,216.92 263.43,217.16 262.57,217.16 262.57,221.85 262.59,221.88 262.62,221.9
GND on TOP (solid shape): outline of 296 points within 115.47,88.62 138.91,97.02
GND on TOP (solid shape): outline of 83 points within 284.94,167.76 302.34,218.95
GND on TOP (solid shape): outline of 395 points within 6.99,155.22 33.59,165.79
GND on TOP (solid shape): outline of 109 points within 25.4,164.94 221.93,221.6
GND on TOP (solid shape): outline of 1594 points within 0.25,0.25 271.53,220.35
GND on BOTTOM (solid shape): 139.59,9.45 108.59,9.45 108.59,11.25 139.59,11.25
GND on BOTTOM (solid shape): 20.89,162.3 20.89,155.57 20.45,155.12 17.59,155.12 17.27,155.44 17.27,162.3 17.78,162.8 20.39,162.8
GND on BOTTOM (solid shape): 40.71,154.17 40.71,152.26 40.26,151.82 36.9,151.82 36.26,152.45 36.26,154.1 36.51,154.36 40.51,154.36
GND on BOTTOM (solid shape): 63.63,170.23 63.63,168.27 63.12,167.76 57.41,167.76 56.71,168.46 56.71,170.23 57.05,170.58 63.28,170.58
GND on BOTTOM (solid shape): 117.51,150.01 117.51,148.18 116.77,147.44 114.85,147.44 114.43,147.87 114.43,150.24 114.9,150.72 116.81,150.72
GND on BOTTOM (solid shape): 273.05,191.81 273.05,189.9 272.88,189.73 271.9,189.73 271.78,189.84 271.78,191.72 271.93,191.86 273,191.86
GND on BOTTOM (solid shape): 286.48,206.42 286.48,204.16 286.32,204 284.88,204 284.8,204.08 284.8,206.39 285,206.59 286.3,206.59
GND on BOTTOM (solid shape): 101.87,150.09 101.87,147.05 101.28,146.46 99.18,146.46 98.49,147.15 98.49,152.2 98.62,152.33 99.63,152.33
GND on BOTTOM (solid shape): 105.03,141.21 105.03,140.33 104.84,140.13 103.89,140.13 103.7,140.33 103.7,141.34 103.82,141.47 104.78,141.47
GND on BOTTOM (solid shape): 104.97,137.59 104.97,136.52 104.84,136.39 103.95,136.39 103.76,136.58 103.76,137.59 103.89,137.72 104.84,137.72
GND on BOTTOM (solid shape): 165.95,104.26 165.95,102.44 165.55,102.03 162.7,102.03 162.21,102.52 162.21,104.06 162.73,104.57 165.64,104.57
GND on BOTTOM (solid shape): 203.52,47.04 203.52,43.93 202.88,43.29 200.97,43.29 200.41,43.85 200.41,47.05 200.91,47.55 203.01,47.55
GND on BOTTOM (solid shape): 109.38,150.09 109.38,146.87 109.21,146.7 107.38,146.7 107.18,146.91 107.18,150.15 107.68,150.66 108.81,150.66
GND on BOTTOM (solid shape): 127.89,121.66 127.89,119 127.75,118.86 125.1,118.86 124.72,119.24 124.72,121.72 125.48,122.48 127.07,122.48
GND on BOTTOM (solid shape): 167.72,76.83 167.72,75.01 167.19,74.48 164.46,74.48 164.46,74.48 164.1,74.48 163.68,74.9 163.68,76.88 164.1,77.31 167.24,77.31
GND on BOTTOM (solid shape): 91.44,152.93 91.44,151.09 91.26,150.91 87.01,150.91 86.76,151.16 86.76,152.94 86.94,153.12 91.25,153.12
GND on BOTTOM (solid shape): 245.18,185.47 245.18,184.58 245.43,184.33 245.43,183.76 245.24,183.57 243.91,183.57 243.65,183.82 243.65,185.54 243.78,185.66 244.98,185.66
GND on BOTTOM (solid shape): 245.89,201.96 245.89,199.73 245.78,199.62 245.36,199.62 245.18,199.43 245.18,198.36 244.86,198.05 244.1,198.05 243.71,198.43 243.71,201.79 243.99,202.07 245.79,202.07
GND on BOTTOM (solid shape): 295.56,186.62 297.8,186.62 297.91,186.51 297.91,184.67 297.61,184.38 293.73,184.38 293.69,184.42 293.69,187.05 293.75,187.11 295.06,187.11
GND on BOTTOM (solid shape): 49.31,160.92 50.22,160.92 50.34,160.81 50.34,160.36 50.33,160.35 50.33,160.17 50.23,160.07 49.07,160.07 48.67,160.48 48.67,160.88 48.71,160.92 49.12,160.92 49.12,161.49 49.31,161.49
GND on BOTTOM (solid shape): 105.48,133.4 108.65,133.4 108.84,133.21 108.84,131.94 108.71,131.82 105.92,131.82 105.35,132.39 102.34,132.39 101.49,133.24 101.49,133.98 101.55,134.04 104.84,134.04
GND on BOTTOM (solid shape): 135.63,123.5 136,123.5 136.2,123.3 136.2,119.63 138.11,117.72 138.11,114.93 137.7,114.51 134.27,114.51 133.96,114.83 133.96,119.46 134.22,119.73 134.22,123.32 134.41,123.51 135.63,123.51
GND on BOTTOM (solid shape): 272.7,158.87 272.7,157.38 273.08,157 273.64,157 273.81,156.83 273.81,156.16 274.37,156.16 274.37,155.98 273.81,155.98 273.81,154.79 273.51,154.49 269.5,154.49 268.86,155.12 268.86,158.74 269.17,159.05 272.52,159.05
GND on BOTTOM (solid shape): 26.48,185.22 26.48,182.88 26.33,182.74 25.55,182.74 25.55,183.28 24.8,183.28 24.8,182.74 24.35,182.74 24.35,183.28 23.6,183.28 23.6,182.74 22.07,182.74 20.7,184.1 20.7,185.47 21.14,185.92 25.78,185.92
GND on BOTTOM (solid shape): 7.88,162.61 7.88,161.92 8.51,161.28 13.08,161.28 13.46,160.9 13.46,159.38 13.65,159.18 15.43,159.18 15.56,159.06 15.56,157.91 15.18,157.53 8.51,157.53 7.94,158.11 7.94,160.45 6.92,161.47 5.32,161.47 5.13,161.66 5.13,162.58 5.31,162.76 7.73,162.76
GND on BOTTOM (solid shape): 100.52,129.51 100.52,129.34 103,126.86 103,123.24 102.17,122.42 101.54,122.42 100.27,121.15 97.28,121.15 97.16,121.28 97.16,121.66 97.35,121.85 98.11,121.85 98.24,121.97 98.24,123.18 98.36,123.31 99.95,123.31 100.4,123.75 100.4,127.05 99.76,127.69 99.76,129.48 99.91,129.64 100.4,129.64
GND on BOTTOM (solid shape): 56.71,159.69 56.71,159.18 57.21,158.68 57.21,155.65 57.45,155.42 58.62,155.42 58.8,155.6 58.8,158.62 58.92,158.74 61.8,158.74 62.1,158.43 62.1,155.92 62.73,155.29 62.73,155.28 62.81,155.15 62.93,155.07 62.97,155.06 62.97,152.31 62.95,152.3 62.95,152.01 62.87,151.93 58.52,151.93 55.82,154.63 55.82,159.57 56.01,159.75 56.65,159.75
GND on BOTTOM (solid shape): 176.1,129.99 176.39,129.99 177.04,129.34 177.04,128.26 176.6,127.82 176.02,127.82 175.43,127.22 174.53,127.22 174.49,127.23 174.43,127.29 174.43,127.46 174.34,127.61 174.16,127.8 173.9,127.81 173.82,127.89 173.82,128.2 173.82,128.21 173.93,128.32 174.59,128.32 175.03,128.76 175.09,128.84 175.13,128.93 175.3,129.1 175.45,129.22 175.48,129.41 175.48,129.83 175.65,130.01 176.08,130.01
GND on BOTTOM (solid shape): 94.62,16.55 94.67,16.63 94.77,16.63 94.89,16.59 95.01,16.59 95.03,16.6 95.05,16.59 96.36,15.28 96.36,15.05 96.36,15.03 96.32,14.98 96.24,14.95 96.17,14.98 96.12,15.03 96.12,15.05 96.12,15.15 95.68,15.6 95.28,15.6 95.26,15.6 95.24,15.62 95.03,15.77 94.77,15.73 94.67,15.73 94.62,15.82
GND on BOTTOM (solid shape): 139.14,16.57 139.2,16.48 139.2,15.71 139.14,15.63 139.04,15.63 138.77,15.68 138.55,15.54 138.53,15.52 138.5,15.51 138.12,15.51 137.76,15.16 137.76,15.05 137.76,15.03 137.71,14.98 137.64,14.95 137.57,14.98 137.52,15.03 137.52,15.05 137.52,15.28 138.74,16.5 138.76,16.51 138.77,16.51 138.91,16.51 139.04,16.56
GND on BOTTOM (solid shape): 107.77,38.82 108.66,37.93 108.66,36.45 108.66,36.43 108.61,36.38 108.54,36.35 108.47,36.38 108.42,36.43 108.42,36.45 108.42,36.9 107.85,37.47 107.85,37.49 107.85,37.5 107.72,37.85 107.36,37.9 107.26,37.91 107.22,37.99 107.22,38.67 107.26,38.76 107.36,38.76 107.54,38.74 107.72,38.81 107.73,38.82
GND on BOTTOM (solid shape): 119.83,138.74 122.31,138.74 122.4,138.68 122.39,138.58 122.54,138.15 122.9,138.43 122.9,138.45 123.19,138.74 124.65,138.74 124.91,138.48 124.91,137.73 125.24,137.39 127.2,137.39 128.27,136.32 128.27,134.89 128.25,134.86 128.25,132.09 128,131.84 127.04,131.84 126.84,131.65 126.84,131.09 127.26,130.68 127.26,129.72 127.07,129.53 124.17,129.53 124.03,129.68 124.03,130.69 123.6,131.12 122.24,131.12 121.86,130.74 121.86,129.85 121.55,129.54 117.34,129.54 117.1,129.78 117.1,134.29 117.73,134.93 118.37,134.93 118.68,135.25 118.68,139.37 118.75,139.44 119.13,139.44
GND on BOTTOM (solid shape): 80.09,87.35 84.09,83.35 80.09,79.35 77.01,79.35 77.01,86.35 76.87,86.92 76.48,87.35
GND on BOTTOM (solid shape): 158.79,131.51 158.86,131.46 158.89,131.4 158.93,131.36 158.87,131.26 158.86,131.16 158.89,131.06 158.96,130.97 158.98,130.96 158.98,130.76 158.95,130.74 158.79,130.57 158.73,130.35 158.68,130.3 158.6,130.28 158.52,130.25 158.34,130.44 158.18,130.68 157.9,130.62 157.89,130.61 157.69,130.61 157.46,130.84 157.58,130.96 158.03,130.96 158.07,131 158.15,131.01 158.2,131.03 158.23,131.05 158.3,131.12 158.33,131.22 158.33,131.3 158.36,131.39 158.46,131.41 158.56,131.41 158.66,131.45 158.7,131.48
GND on BOTTOM (solid shape): outline of 81 points within 54.01,137.09 55.63,149.15
GND on BOTTOM (solid shape): 80.09,22.78 84.09,18.78 80.09,14.78 77.01,14.78 77.01,20.81 76.8,21.49 75.86,22.23 75.71,22.68 75.71,22.78
GND on BOTTOM (solid shape): 157.59,129.66 157.6,129.64 157.6,129.59 157.59,129.57 157.57,129.33 157.75,129.17 157.8,129.15 157.83,129.1 157.89,128.79 158.18,128.66 158.21,128.63 158.23,128.59 158.29,128.43 158.43,128.34 158.48,128.33 158.53,128.34 158.91,128.34 159.07,128.18 159.07,127.96 158.95,127.85 158.93,127.83 158.9,127.83 158.61,127.78 158.48,127.52 158.45,127.46 158.39,127.43 158.17,127.3 158.11,127.05 157.84,126.79 157.83,126.78 157.75,126.73 157.68,126.65 157.67,126.64 157.63,126.61 156.96,126.61 156.74,126.83 156.74,129.67 156.99,129.92 157.33,129.92
GND on BOTTOM (solid shape): 290,210.26 294.5,212.17 297.49,208.3 294.41,204.41 289.92,206.5 291.07,207.66 291.07,209.18
GND on BOTTOM (solid shape): 85.92,170.88 91.47,172.43 94.79,167.72 90.01,162.73 84.81,167.27 86.4,167.27 87.34,168.21 87.34,169.46
GND on BOTTOM (solid shape): 165.39,143.88 165.43,143.8 165.56,143.56 165.83,143.5 165.9,143.5 165.95,143.44 166.02,143.34 166.13,143.29 166.17,143.24 166.13,143.19 166.08,143.17 165.7,143.17 165.58,143.05 165.5,143.02 165.42,143.07 165.18,143.19 164.96,143.01 164.96,143 164.86,142.9 164.84,142.89 164.71,142.9 164.62,142.89 164.53,142.9 164.48,142.97 164.38,143.14 164.19,143.19 164.18,143.19 164.16,143.2 164.07,143.29 164.07,143.3 164.03,143.4 163.97,143.48 163.94,143.55 163.98,143.63 164.05,143.71 164.09,143.8 164.13,143.86 164.2,143.88 164.24,143.88 164.28,143.88 164.35,143.87 164.4,143.81 164.69,143.56 165.02,143.75 165.14,143.87 165.16,143.88 165.23,143.88 165.3,143.89
GND on BOTTOM (solid shape): 173.59,131.46 173.61,131.45 173.66,131.41 173.68,131.37 173.66,131.33 173.62,131.11 173.76,130.95 173.81,130.93 173.87,130.92 173.9,130.89 173.9,130.83 173.88,130.79 173.87,130.79 173.82,130.69 173.8,130.55 173.79,130.53 173.73,130.46 173.41,130.46 173.38,130.47 173.36,130.49 173,130.64 172.75,130.34 172.73,130.27 172.68,130.23 172.51,130.23 172.46,130.25 172.44,130.3 172.41,130.33 172.38,130.4 172.41,130.46 172.4,130.9 171.96,130.94 171.89,130.94 171.89,131.01 171.91,131.05 171.93,131.1 172.11,131.28 172.13,131.29 172.28,131.32 172.4,131.39 172.46,131.42 172.53,131.4 172.67,131.34 172.83,131.36 172.85,131.36 172.87,131.35 173.03,131.31 173.19,131.35 173.36,131.35 173.51,131.43 173.52,131.44 173.56,131.46
GND on BOTTOM (solid shape): 263.84,221.9 264.37,221.68 264.59,221.15 264.59,217.47 264.54,217.2 264.39,216.97 264.15,216.58 264.07,216.12 264.07,212.75 264.43,211.86 265.32,211.5 268.19,211.5 269.08,211.86 269.44,212.75 269.44,214.28 269.36,214.73 268.99,215.34 268.94,215.61 268.94,218.2 269.16,218.73 269.69,218.95 270.89,218.95 270.92,218.93 270.94,218.9 270.94,209.94 270.94,209.87 270.94,208.79 270.5,208.34 265.68,208.34 264.77,209.25 264.77,211.08 263.89,211.72 263.56,212.75 263.56,216.12 263.59,216.44 263.67,216.74 263.67,216.92 263.43,217.16 262.57,217.16 262.57,221.85 262.59,221.88 262.62,221.9
GND on BOTTOM (solid shape): outline of 83 points within 171.86,136.83 173.19,140.79
GND on BOTTOM (solid shape): outline of 88 points within 164.97,130.59 168.51,131.78
GND on BOTTOM (solid shape): outline of 108 points within 157.46,135.55 159.28,139.77
GND on BOTTOM (solid shape): outline of 98 points within 170.44,128.23 173.3,130.32
GND on BOTTOM (solid shape): outline of 103 points within 157.45,131.81 159.46,135.26
GND on BOTTOM (solid shape): outline of 101 points within 165.39,128.32 168.94,130.49
GND on BOTTOM (solid shape): outline of 107 points within 172.48,144.34 176.6,147.99
GND on BOTTOM (solid shape): outline of 82 points within 284.94,167.77 302.34,218.95
GND on BOTTOM (solid shape): outline of 157 points within 159.48,128.18 165.02,130.75
GND on BOTTOM (solid shape): outline of 455 points within 115.34,88.62 138.91,97.07
GND on BOTTOM (solid shape): outline of 118 points within 25.4,164.95 242.85,221.6
GND on BOTTOM (solid shape): outline of 210 points within 171.73,131.82 175.51,136.41
GND on BOTTOM (solid shape): outline of 241 points within 173.52,136.71 175.51,144.05
GND on BOTTOM (solid shape): outline of 249 points within 0.25,0.25 271.52,220.35
GND on BOTTOM (solid shape): outline of 1321 points within 160.37,131.12 173.02,142.69
GND on BOTTOM (solid shape): outline of 1581 points within 156.8,135.79 170.31,147.14
GND on BOTTOM (solid shape): outline of 5628 points within 90.93,11.99 113.6,40.31
GND on BOTTOM (solid shape): outline of 5733 points within 131.26,12.06 153.29,41.9
GND on IN1 (solid shape): 263.84,221.9 264.37,221.68 264.59,221.15 264.59,217.47 264.54,217.2 264.39,216.97 264.15,216.58 264.07,216.12 264.07,212.75 264.43,211.86 265.32,211.5 268.19,211.5 269.08,211.86 269.44,212.75 269.44,214.28 269.36,214.73 268.99,215.34 268.94,215.61 268.94,218.2 269.16,218.73 269.69,218.95 270.89,218.95 270.92,218.93 270.94,218.9 270.94,209.94 270.94,209.87 270.94,208.78 270.5,208.34 264.76,208.34 264.76,211.08 263.89,211.72 263.56,212.75 263.56,216.12 263.59,216.44 263.67,216.74 263.67,216.92 263.43,217.16 262.57,217.16 262.57,221.85 262.59,221.88 262.62,221.9
GND on IN1 (solid shape): outline of 81 points within 284.94,167.76 302.34,218.95
GND on IN1 (solid shape): outline of 452 points within 114.62,125.02 134.69,137.47
GND on IN1 (solid shape): outline of 120 points within 25.4,168.08 242.85,221.6
GND on IN1 (solid shape): outline of 754 points within 58.68,155.25 81.6,167
GND on IN1 (solid shape): outline of 247 points within 0.25,0.25 271.53,220.35
GND on IN2 (solid shape): outline of 89 points within 115.45,90.08 138.48,96.09
GND on IN2 (solid shape): 263.84,221.9 264.37,221.68 264.59,221.15 264.59,217.47 264.54,217.2 264.39,216.97 264.15,216.58 264.07,216.12 264.07,212.75 264.43,211.86 265.32,211.5 268.19,211.5 269.08,211.86 269.44,212.75 269.44,214.28 269.36,214.73 268.99,215.34 268.94,215.61 268.94,218.2 269.16,218.73 269.69,218.95 270.89,218.95 270.92,218.93 270.94,218.9 270.94,208.69 270.58,208.34 264.77,208.34 264.77,211.08 263.89,211.72 263.56,212.75 263.56,216.12 263.59,216.44 263.67,216.74 263.67,216.92 263.43,217.16 262.57,217.16 262.57,221.85 262.59,221.88 262.62,221.9
GND on IN2 (solid shape): outline of 82 points within 284.94,167.77 302.34,218.95
GND on IN2 (solid shape): outline of 397 points within 114.62,125.02 134.69,137.47
GND on IN2 (solid shape): outline of 114 points within 25.4,168.08 242.85,221.6
GND on IN2 (solid shape): outline of 246 points within 0.25,0.25 271.53,220.35
GND on IN3 (solid shape): 263.84,221.9 264.37,221.68 264.59,221.15 264.59,217.47 264.54,217.2 264.39,216.97 264.15,216.58 264.07,216.12 264.07,212.75 264.43,211.86 265.32,211.5 268.19,211.5 269.08,211.86 269.44,212.75 269.44,214.28 269.36,214.73 268.99,215.34 268.94,215.61 268.94,218.2 269.16,218.73 269.69,218.95 270.89,218.95 270.92,218.93 270.94,218.9 270.94,208.78 270.49,208.34 264.76,208.34 264.76,211.08 263.89,211.72 263.56,212.75 263.56,216.12 263.59,216.44 263.67,216.74 263.67,216.92 263.43,217.16 262.57,217.16 262.57,221.85 262.59,221.88 262.62,221.9
GND on IN3 (solid shape): outline of 291 points within 114.62,125.72 134.69,134.86
GND on IN3 (solid shape): outline of 81 points within 284.94,167.77 302.34,218.95
GND on IN3 (solid shape): outline of 120 points within 25.4,168.08 242.85,221.6
GND on IN3 (solid shape): outline of 641 points within 6.99,155.12 29.29,172.46
GND on IN3 (solid shape): outline of 243 points within 0.25,0.25 271.52,220.35
GND on IN4 (solid shape): 263.84,221.9 264.37,221.68 264.59,221.15 264.59,217.47 264.54,217.2 264.39,216.97 264.15,216.58 264.07,216.12 264.07,212.75 264.43,211.86 265.32,211.5 268.19,211.5 269.08,211.86 269.44,212.75 269.44,214.28 269.36,214.73 268.99,215.34 268.94,215.61 268.94,218.2 269.16,218.73 269.69,218.95 270.89,218.95 270.92,218.93 270.94,218.9 270.94,208.78 270.49,208.34 264.77,208.34 264.77,211.08 263.89,211.72 263.56,212.75 263.56,216.12 263.59,216.44 263.67,216.74 263.67,216.92 263.43,217.16 262.57,217.16 262.57,221.85 262.59,221.88 262.62,221.9
GND on IN4 (solid shape): outline of 202 points within 114.62,125.02 134.69,137.47
GND on IN4 (solid shape): outline of 84 points within 284.94,167.78 302.34,218.95
GND on IN4 (solid shape): outline of 120 points within 25.4,168.08 242.85,221.6
GND on IN4 (solid shape): outline of 642 points within 6.99,155.12 29.45,170.42
GND on IN4 (solid shape): outline of 755 points within 58.68,155.25 81.6,166.89
GND on IN4 (solid shape): outline of 248 points within 0.25,0.25 271.52,220.35
GND on GND1: outline of 245 points within 0.26,0.26 302.33,221.6
GND on GND2, GND3: outline of 245 points within 0.26,0.26 302.33,221.6
GND on VCC: 61.68,158.8 58.84,158.8 58.68,158.63 58.68,155.76 58.68,155.76 62.02,155.76 62.04,155.78 62.04,158.44
GND on VCC: 91.67,25.45 90.24,26.89 90.24,40.52 92.71,43 92.71,48.99 92.65,49.05 92.65,53.86 96.65,57.86 96.65,78.75 107.93,90.03 112.93,90.03 118.2,84.76 119.76,84.76 119.76,75.28 119.25,74.77 119.25,70.83 112.65,64.23 112.65,53.37 111.95,52.67 111.95,25.45
GND on VCC: 8.24,207.19 8.24,219.6 8.46,220.13 8.99,220.35 10.94,220.35 10.94,213.71 10.66,212.47 11.9,212.75 25.98,212.75 27.22,212.47 26.94,213.71 26.94,221.6 28.89,221.6 29.42,221.38 29.64,220.85 29.64,207.19 27.91,207.19 27.69,207.27 27.47,207.19
GND on VCC: 289.29,166.8 287.85,168.24 287.85,175.85 288.01,176.15 287.85,176.45 287.85,187.39 287.88,187.41 288.21,187.86 287.88,188.32 287.85,188.33 287.85,199.74 283.63,203.95 264.97,203.95 264.67,204.25 264.67,211.68 264.98,211.54 265.32,211.5 268.19,211.5 269.08,211.86 269.44,212.75 269.44,214.28 269.36,214.73 268.99,215.34 268.94,215.61 268.94,218.2 269.16,218.73 269.69,218.95 270.94,218.95 270.94,209.94 271.56,209.2 272.4,209.69 283.48,209.69 284.32,209.2 284.94,209.94 284.94,218.95 286.79,218.95 287.32,218.73 287.54,218.2 287.54,214.3 288.2,212.71 289.79,212.05 293.49,212.05 296.14,210.95 297.24,208.3 297.24,205.3 297.6,204.41 298.49,204.05 301.59,204.05 302.12,203.83 302.34,203.3 302.34,200.5 295.42,200.5 294.68,199.88 295.17,199.04 295.17,191.46 294.68,190.62 295.42,190 302.34,190 302.34,181.5 295.42,181.5 294.68,180.88 295.17,180.04 295.17,172.46 294.68,171.62 295.42,171 302.14,171 302.14,167.76 293.02,167.76 292.07,166.8
GND on VCC: 133.99,25.45 133.99,33.62 133.35,34.26 133.35,40.4 137.67,44.72 137.67,74.39 137.03,75.03 137.03,84.76 138.85,84.76 139.89,85.8 139.89,87.26 140.51,87.87 148.55,87.87 154.81,81.61 154.81,80.91 157.55,78.18 157.55,73.76 155.58,71.79 155.58,25.45
GND_CHASSIS on BOTTOM (solid shape): 250.8,201.87 250.8,190.12 250.57,189.89 250.04,189.89 249.96,189.97 249.96,198.9 249.33,199.53 249.18,199.53 249.09,199.62 249.09,202 249.19,202.1 250.57,202.1
GNDA on TOP (solid shape): 280.81,159.26 280.81,157.93 281.07,157.67 281.07,156.31 280.7,155.94 280.7,153.98 280.87,153.8 281.1,153.8 281.25,153.65 281.25,153.47 281.23,153.44 281.22,153.41 281.13,153.32 280.71,153.32 280.49,153.09 280.49,152.16 280.17,151.84 280.17,150.92 279.91,150.66 278.65,150.66 278.37,150.94 278.37,155.1 278.83,155.55 278.83,158.05 278.53,158.36 278.53,159.32 278.79,159.59 280.48,159.59
GNDA on BOTTOM (solid shape): 282.54,151.02 282.54,149.9 282.39,149.75 279.45,149.75 279.26,149.94 279.26,150.54 279.26,150.54 279.26,150.72 279.38,150.84 280.04,150.84 280.56,151.37 282.19,151.37
GNDA on BOTTOM (solid shape): 275.51,156.74 275.51,155.69 275.72,155.48 276.35,155.48 276.61,155.22 276.61,151.44 275.97,150.8 274.07,150.8 273.06,151.81 272.25,151.81 272.04,152.02 272.04,154.06 272.09,154.11 273.19,154.11 273.66,153.64 273.66,153.14 274.35,152.45 275.21,152.45 275.46,152.71 275.46,153.72 274.77,154.42 274.18,154.42 273.96,154.63 273.96,155.85 274.5,155.85 274.5,156.29 273.96,156.29 273.96,156.91 274.06,157 275.25,157
GNDA on GND1, GND3: 294.23,148.8 293.86,148.71 272.04,148.71 272.04,154.04 274.7,154.04 274.7,160.05 274.3,160.45 273.88,160.45 273.88,161.22 279.82,161.22 280.78,162.17 287.38,162.17 289.73,164.52 289.91,164.52 290.13,164.74 290.13,165.69 290.48,166.04 292.39,166.04 293.34,167 302.14,167 302.14,156.85 301.92,156.32 301.39,156.11 300.89,156.11 300,155.74 299.63,154.85 299.63,150.45 299.42,149.92 298.89,149.71 295.59,149.71 294.96,149.54
GNDA on GND2: 294.23,148.8 293.86,148.71 272.04,148.71 272.04,154.04 274.7,154.04 274.7,160.05 274.3,160.45 273.88,160.45 273.88,161.22 279.82,161.22 280.78,162.17 287.38,162.17 289.73,164.52 289.91,164.52 290.13,164.74 290.13,165.69 290.48,166.04 292.39,166.04 293.34,167 302.14,167 302.14,156.85 301.92,156.32 301.39,156.11 300.89,156.11 300,155.74 299.63,154.85 299.63,150.45 299.42,149.92 298.89,149.71 295.59,149.71 294.96,149.54
GNDA on VCC: 272.04,154.04 274.7,154.04 274.7,160.05 274.3,160.45 273.88,160.45 273.88,161.22 279.82,161.22 280.78,162.17 287.38,162.17 289.73,164.52 289.91,164.52 290.13,164.74 290.13,165.69 290.48,166.04 292.39,166.04 293.34,167 301.37,167 301.37,156.87 300.89,156.87 299.46,156.28 298.87,154.85 298.87,150.47 295.59,150.47 294.59,150.2 293.85,149.47 272.04,149.47
GNDA_CHG on BOTTOM (solid shape): 51.08,165.69 51.08,165.3 51.45,164.93 53.14,164.93 53.29,164.78 53.29,162.36 52.5,161.58 52.5,159.92 52.25,159.66 50.61,159.66 50.52,159.75 50.52,160.65 51.64,160.65 51.65,160.6 51.66,160.55 51.68,160.5 51.71,160.45 51.74,160.41 51.78,160.37 51.82,160.34 51.87,160.32 51.92,160.31 51.97,160.3 52.03,160.3 52.08,160.31 52.13,160.32 52.18,160.34 52.22,160.37 52.26,160.41 52.29,160.45 52.32,160.5 52.34,160.55 52.35,160.6 52.36,160.65 52.35,160.71 52.34,160.76 52.32,160.81 52.29,160.85 52.26,160.9 52.22,160.93 52.18,160.96 52.13,160.99 52.08,161 52.03,161.01 51.97,161.01 51.92,161 51.87,160.99 51.82,160.96 51.78,160.93 51.74,160.9 51.71,160.85 51.68,160.81 51.66,160.76 51.65,160.71 51.64,160.65 50.52,160.65 50.52,160.82 50.27,161.08 49.46,161.08 49.46,161.64 48.97,161.64 48.97,161.08 48.68,161.08 48.64,161.11 48.64,162.31 48.77,162.44 49.99,162.44 50.13,162.58 50.13,165.84 50.22,165.93 50.84,165.93
GNDA_GPU_CORE on TOP (solid shape): 29.4,145.66 29.4,145.1 29.67,144.83 30.16,144.83 30.29,144.71 30.29,143.44 29.53,142.67 28.86,142.67 28.86,143.2 28.42,143.2 28.42,142.67 28.01,142.67 27.82,142.86 27.82,144.04 28.15,144.36 28.18,144.36 28.18,144.4 28.32,144.54 28.32,145.79 28.51,145.98 29.08,145.98
GNDA_GPU_CORE on IN4 (solid shape): outline of 299 points within 19.77,141.28 29.21,150.05
+ALC3226_VREF on TOP (solid shape): 275.54,154.53 275.54,154.52 275.63,154.37 275.78,154.28 275.88,154.27 275.97,154.28 276.39,154.28 276.64,154.03 276.64,152.89 276.93,152.6 277.33,152.6 277.49,152.76 277.98,152.76 278.09,152.64 278.09,150.71 278.02,150.65 276.75,150.65 275.61,151.79 275.61,152.73 275.4,152.93 275.39,152.95 275.31,153.09 275.17,153.17 275.16,153.18 275.13,153.2 275.13,153.58 275.14,153.59 275.09,153.98 274.72,154.09 274.7,154.09 274.63,154.15 274.63,154.52 274.71,154.6 275.47,154.6
+BATT_SUM on TOP (solid shape): outline of 172 points within 82.6,149.47 109.31,161.57
+BL_PWR_SRC on TOP (solid shape): 219.53,168.81 219.53,167.96 219.3,167.73 218.67,167.73 218.49,167.55 218.49,167.01 217.39,165.91 214.2,165.91 214.07,166.05 214.07,167.17 214.1,167.21 214.1,167.33 214.49,167.71 214.49,167.72 214.51,167.74 214.51,168.8 214.53,168.81 214.56,168.81 215.19,168.81 215.29,168.8 215.39,168.81 217.57,168.81 217.58,168.81 217.7,168.79 217.83,168.81 217.84,168.81 218.01,168.81 218.31,169.11 219.24,169.11
+BL_PWR_SRC on BOTTOM (solid shape): 219.69,170.59 219.69,168.34 219.69,168.34 219.69,167.86 219.52,167.69 218.54,167.69 218.35,167.89 218.35,169.48 218.37,169.5 218.37,170.6 218.47,170.7 219.58,170.7
+DC_IN on TOP (solid shape): 16.32,177.74 16.32,173.28 16.13,173.09 12.88,173.09 12.7,173.27 12.7,177.82 12.88,178 16.06,178
+DC_IN on BOTTOM (solid shape): 16.38,174.87 16.38,172.46 15.86,171.93 12.3,171.93 12.29,171.92 9.53,171.92 9.34,172.11 9.34,174.93 9.53,175.12 16.13,175.12
+DC_IN_SS on TOP (solid shape): 19.75,177.22 19.75,166.93 18.92,166.11 12.45,166.11 11.57,166.98 11.57,169.87 11.15,170.3 9.53,170.3 9.21,170.61 9.21,171.57 9.27,171.63 9.78,171.63 9.97,171.82 9.97,172.52 10.1,172.65 16.38,172.65 16.86,173.12 16.86,177.27 17.07,177.47 19.5,177.47
+DCIN on TOP (solid shape): 56.01,166.61 56.01,165.92 55.82,165.73 55.06,165.73 54.8,165.47 54.8,165.28 53.72,164.2 52.77,164.2 52.71,164.26 52.71,164.39 53.6,165.28 53.6,166.49 53.85,166.74 55.88,166.74
+DCIN on BOTTOM (solid shape): 55.95,166.8 55.95,165.73 55.82,165.6 53.79,165.6 53.6,165.79 53.6,166.66 53.81,166.87 55.88,166.87
+DCIN_JACK on TOP (solid shape): 23.62,179.3 23.62,178.98 23.19,178.55 19.12,178.55 18.65,179.02 18.65,179.19 20.33,180.88 22.05,180.88
+DCIN_JACK on BOTTOM (solid shape): 22.01,179.12 22.8,179.12 22.86,179.06 22.86,176.37 22.14,175.64 20.36,175.64 19.55,176.46 9.84,176.46 9.4,176.9 9.4,180 9.99,180.59 20.55,180.59
+DOCK_PWR_BAR on TOP (solid shape): outline of 91 points within 153.93,159.82 162.09,164.15
+DOCK_PWR_BAR on TOP (solid shape): outline of 291 points within 107.82,159.88 118.18,172.65
+DOCK_PWR_BAR on BOTTOM (solid shape): outline of 249 points within 105.16,161.72 117.6,173.03
+DOCK_PWR_BAR on IN2 (solid shape): outline of 250 points within 107.82,160.39 118.18,172.65
+DOCK_PWR_BAR on IN3 (solid shape): outline of 250 points within 107.82,160.39 118.18,172.65
+DOCK_PWR_BAR on VCC: 111.17,159.5 108.65,162.02 108.65,173.73 113.07,173.73 113.52,172.67 114.59,172.23 126.59,172.23 127.66,172.67 128.11,173.73 162.69,173.73 162.69,161.26 160.93,159.5 157.14,159.5 155.05,161.6 145.5,161.6 143.41,159.5 129.71,159.5 127.61,161.6 118.01,161.6 115.91,159.5
+GPU_CORE on TOP (solid shape): outline of 438 points within 34.86,126.17 57.41,161.66
+GPU_CORE on BOTTOM (solid shape): 67.62,130.83 67.63,130.8 67.67,130.63 67.79,130.5 67.79,130.1 67.7,130.01 67.64,129.9 67.63,129.88 67.61,129.86 67.38,129.86 67.32,129.92 67.31,129.93 67.15,130.11 66.91,130.15 66.88,130.15 66.86,130.16 66.71,130.31 66.71,131.04 66.88,131.22 67.23,131.22
+GPU_CORE on BOTTOM (solid shape): outline of 83 points within 18.42,152.43 43.75,168.77
+GPU_CORE on BOTTOM (solid shape): outline of 104 points within 72.11,135.03 75.3,137.46
+GPU_CORE on BOTTOM (solid shape): outline of 5577 points within 48.13,129.85 75.48,149.99
+GPU_CORE on IN1 (solid shape): outline of 4462 points within 18.23,129.33 75.87,168.32
+GPU_CORE on IN2 (solid shape): 30.75,166.08 39.03,166.08 40.96,164.15 40.96,158.94 43.88,156.02 43.88,153.91 42.15,152.19 39.54,152.19 37.4,154.32 33.42,154.32 29.45,158.28 29.45,159.45 27.98,160.92 27.67,160.92 27.32,161.28 27.32,162.65 25.41,164.56 18.3,164.56 17.26,165.6 17.26,167.07 17.54,167.35 29.48,167.35
+GPU_CORE on IN3 (solid shape): outline of 4516 points within 18.63,128.58 75.87,167.63
+GPU_CORE on IN4 (solid shape): outline of 4504 points within 18.1,129.02 75.92,167.55
+GPU_CORE on VCC: 56.24,130.1 52.56,133.78 49,133.78 37.66,145.13 37.66,150.78 30.06,158.38 30.06,159.86 29.2,160.72 26.97,160.72 23.82,163.87 19.27,163.87 18.66,164.48 18.66,168.13 20.08,169.56 30.47,169.56 40.78,159.25 43.01,159.25 47.01,155.25 62.15,155.25 62.16,155.23 62.37,155.23 62.39,155.25 66.83,155.25 76.07,146 76.07,137.13 74.42,135.48 74.42,133.04 74.89,132.58 75.27,132.58 75.69,132.16 75.69,130.1
+LCDVDD on TOP (solid shape): 200.27,172.74 201.12,172.74 201.41,172.45 201.41,171.24 201.08,170.91 199.28,170.91 198.81,171.38 196.66,171.38 196.34,171.69 196.34,172.96 196.6,173.22 199.79,173.22
+LCDVDD on BOTTOM (solid shape): 201.61,172.79 201.61,172.21 201.74,172.09 202.13,172.09 202.97,171.25 202.97,170.87 203.19,170.65 203.19,169.49 203.82,168.86 203.82,167.53 203.71,167.42 202.91,167.42 202.39,167.93 202.39,170.62 202.24,170.78 199.85,170.78 199.7,170.93 199.7,172.02 199.76,172.09 200.8,172.09 200.95,172.24 200.95,172.71 201.07,172.82 201.58,172.82
+PBATT on TOP (solid shape): 80.06,162.27 80.06,159.52 78.2,157.66 75.27,157.66 75.06,157.86 75.06,161.72 75.07,161.72 75.07,162.09 75.41,162.44 79.9,162.44
+PBATT_C on TOP (solid shape): 78.68,169.66 78.68,168.14 79.44,167.38 80.96,167.38 81.17,167.17 81.17,166.49 80.92,166.24 80.92,164.97 80.65,164.7 75.59,164.7 75.06,165.23 75.06,167.95 74.11,168.9 74.11,169.98 74.61,170.49 77.85,170.49
+PBATT_IN_SS on TOP (solid shape): 82.1,159.98 82.1,156.55 81.09,155.54 81.09,150.65 80.91,150.47 79.18,150.47 78.97,150.68 78.97,151.68 78.72,151.93 76.47,151.93 75.91,151.37 74.46,151.37 74.35,151.48 74.35,152.07 73.83,152.59 73.83,154.22 74.79,155.18 74.79,156.6 75.09,156.9 78.18,156.9 80.39,159.11 80.39,160.16 80.52,160.29 81.8,160.29
+PCH_VCCCLK on TOP (solid shape): outline of 373 points within 163.98,140.08 166.05,149.79
+PCH_VCCCLK on BOTTOM (solid shape): 165.81,140.94 165.81,140.76 165.57,140.52 165.57,140.43 165.82,140.18 165.82,140 165.7,139.88 165.63,139.88 165.49,140.02 165.49,140.05 165.39,140.15 165.3,140.15 165.04,139.89 164.94,139.89 164.84,139.99 164.84,140.12 165.08,140.36 165.08,140.54 164.83,140.79 164.83,140.92 164.92,141 165.08,141 165.27,140.82 165.39,140.82 165.48,140.9 165.48,140.92 165.61,141.05 165.7,141.05
+PCH_VCCCLK3_3 on TOP (solid shape): 169.87,141.85 169.91,141.76 169.97,141.68 170.08,141.57 170.08,140.94 169.96,140.82 169.7,140.71 169.59,140.45 169.59,140.45 169.32,140.18 169.14,140.18 168.98,140.34 168.98,140.45 168.98,140.52 168.96,140.59 168.96,140.63 168.88,140.71 168.78,140.81 168.65,140.82 168.59,140.82 168.47,140.94 168.47,141.39 168.81,141.73 168.88,141.76 168.96,141.72 169.31,141.59 169.58,141.85 169.59,141.88 169.86,141.88
+PCH_VCCCLK3_3 on TOP (solid shape): outline of 192 points within 170.22,137.8 176.65,140.82
+PCH_VCCCLK3_3 on BOTTOM (solid shape): 169.39,140.74 169.39,140.7 169.57,140.51 169.57,140.41 169.34,140.18 169.19,140.18 169,140.38 169,140.56 168.95,140.6 168.95,140.62 168.88,140.71 168.78,140.79 168.75,140.8 168.63,140.82 168.5,140.8 168.48,140.79 168.39,140.73 168.34,140.67 168.32,140.65 168.27,140.65 168.25,140.67 168.2,140.73 168.12,140.78 168.08,140.83 168.08,140.93 168.28,141.13 169,141.13
+PCH_VCCCLK3_3 on IN3 (solid shape): 169.53,140.69 169.61,140.65 169.63,140.56 169.95,140.13 170.26,140.56 170.28,140.65 170.36,140.69 171.66,140.69 172.03,140.32 172.03,139.27 171.51,138.74 170.6,138.74 170.09,139.25 169.58,139.25 169.01,139.82 169.01,140.61 169.09,140.69
+PCH_VCCDSW on IN2 (solid shape): outline of 565 points within 168.28,130.8 178.94,135.56
+PWR_SRC on TOP (solid shape): 196.92,46.85 199.51,46.85 199.72,46.64 199.72,44.74 199.55,44.57 194.88,44.57 194.25,45.2 194.25,47.62 194.63,48 195.77,48
+PWR_SRC on TOP (solid shape): 217.9,165.4 217.9,164.39 217.93,164.36 217.93,162.8 217.62,162.49 217.02,162.49 216.54,162.97 216.2,162.97 216.09,163.08 216.09,165.37 216.42,165.7 217.6,165.7
+PWR_SRC on TOP (solid shape): 83.92,166.39 85.05,164.02 87.07,162.35 87.33,162.09 87.33,161.68 86.53,160.87 83,160.87 82.85,161.03 82.85,166.23 83,166.39
+PWR_SRC on TOP (solid shape): 169.4,94.33 169.42,94.31 169.93,94.31 169.95,94.33 169.95,94.35 169.95,94.86 170.2,94.86 170.2,94.35 170.23,94.32 170.77,94.32 172.31,92.78 172.31,91.2 172.03,90.92 170.69,90.92 170.69,91.44 169.99,91.44 169.99,90.92 169.49,90.92 169.49,91.44 168.79,91.44 168.79,90.92 168.21,90.92 168.02,91.11 168.02,94.16 168.18,94.32 169.11,94.32 169.15,94.35 169.15,94.86 169.4,94.86
+PWR_SRC on BOTTOM (solid shape): 3.88,164.17 3.88,161.08 4.2,160.75 4.2,160.49 4.18,160.49 4.18,159.72 4.2,159.72 4.2,159.69 4.71,159.69 4.71,159.24 4.2,159.24 4.2,159.22 4.18,159.22 4.18,158.52 4.2,158.52 4.2,158.49 4.71,158.49 4.71,158.04 4.16,158.04 4.16,157.35 3.19,156.39 1.46,156.39 1.34,156.52 1.34,164.17 1.65,164.49 3.56,164.49
+PWR_SRC on BOTTOM (solid shape): 85.56,163.44 89.79,161.7 94.02,163.44 97.44,163.44 98.06,162.82 101.33,162.82 102.24,161.92 102.24,157.23 101.58,156.58 101.56,156.56 101.03,156.56 101.03,157.1 100.33,157.1 100.33,156.56 99.83,156.56 99.83,157.1 99.13,157.1 99.13,156.56 98.46,156.56 97.66,156.56 97.35,156.88 97.35,157.89 96.43,158.8 86.74,158.8 85.66,157.72 85.66,156.56 84.29,156.56 83.94,156.2 84.29,155.84 85.66,155.84 85.66,154.53 85.19,154.05 79.69,154.05 79.19,154.56 79.19,162.74 79.88,163.44
+PWR_SRC on IN1 (solid shape): 6.29,165.73 6.29,161.98 5.72,161.41 1.86,161.41 1.45,161.81 1.45,165.46 1.97,165.98 6.03,165.98
+PWR_SRC on IN2 (solid shape): 10.67,167.82 10.67,166.03 5.47,160.84 2.17,160.84 1.54,161.47 1.54,165.06 2.08,165.6 4.26,165.6 7.44,168.77 9.72,168.77
+PWR_SRC on IN2 (solid shape): 41.29,173.14 41.29,170.25 37.91,166.87 36.48,166.87 35.43,167.93 35.4,167.93 35.36,167.94 35.35,167.98 35.35,170.14 38.61,173.41 41.02,173.41
+PWR_SRC on IN2 (solid shape): outline of 225 points within 179.92,44.56 196.59,56.42
+PWR_SRC on IN2 (solid shape): outline of 257 points within 161.17,72.07 172.28,93.7
+PWR_SRC on IN3 (solid shape): 217.96,163.92 217.96,162.89 217.55,162.49 217.01,162.49 216.6,162.9 216.13,162.9 215.63,163.39 215.63,164 215.79,164.16 217.72,164.16
+PWR_SRC on IN3 (solid shape): 197.35,166.49 197.69,166.49 197.7,166.49 197.76,166.49 197.82,166.55 198.49,166.55 198.56,166.48 198.56,165.59 198.55,165.58 198.55,165.48 198.46,165.39 196.61,165.39 196.32,165.68 196.32,166.59 196.39,166.66 197.18,166.66
+PWR_SRC on VCC: 167.11,90.99 166.31,91.79 166.31,102.82 191.07,127.58 191.07,157.51 190.16,158.42 172.81,158.42 172.34,157.96 172.34,155.16 169.57,152.39 153.31,152.39 151.34,150.42 102.47,150.42 94.47,158.42 75.29,158.42 70.97,162.74 42.21,162.74 38.74,166.21 38.74,173.73 43.87,173.73 44.32,172.67 45.39,172.23 51.08,172.23 51.56,171.24 52.59,170.83 59.73,170.83 59.73,169.28 60.33,168.68 63.25,168.68 63.84,169.28 63.84,170.83 65.7,170.83 65.7,169.34 66.36,168.68 67.25,168.68 67.84,169.28 67.84,170.83 85.59,170.83 86.66,171.28 87.11,172.35 87.11,173.73 108.14,173.73 108.14,161.81 110.96,158.99 116.12,158.99 118.22,161.09 127.4,161.09 129.5,158.99 143.62,158.99 145.71,161.09 154.84,161.09 156.93,158.99 161.14,158.99 163.2,161.05 163.2,173.73 200.98,173.73 200.98,169.87 202.12,168.73 202.12,164.79 207.71,159.21 207.71,128.81 179.9,101 179.9,94.27 176.62,90.99
+PWR_SRC_AC on TOP (solid shape): 100.33,170.23 100.33,167 100.01,166.68 97.41,166.68 97.16,166.93 97.16,169.79 97.73,170.36 100.2,170.36
+PWR_SRC_AC on TOP (solid shape): 37.15,172.58 37.15,170.74 36.58,170.17 28.96,170.17 28.58,170.55 28.58,170.56 28.52,170.62 28.52,171.46 29.88,171.46 30.24,171.82 29.88,172.18 28.52,172.18 28.52,172.97 28.97,173.43 36.31,173.43
+PWR_SRC_AC on TOP (solid shape): 60.15,167.65 60.26,167.63 60.37,167.65 60.38,167.65 60.78,167.65 60.79,167.65 60.9,167.63 61.01,167.65 61.01,167.65 61.42,167.65 61.43,167.65 61.53,167.63 61.64,167.65 61.65,167.65 62.04,167.65 62.29,167.4 62.29,166.17 62.18,166.07 59.68,166.07 59.67,166.06 59.14,166.06 58.93,165.85 58.93,165.32 58.47,164.86 57.44,164.86 57.25,165.05 57.25,166.59 58.28,167.63 60.12,167.63 60.14,167.65
+PWR_SRC_AC on BOTTOM (solid shape): 104.84,171.06 104.84,168.27 105.45,167.66 105.45,163.69 105.32,163.57 100.36,163.57 99.19,164.74 96.3,164.74 95.89,165.15 95.89,170.49 96.9,171.5 104.4,171.5
+PWR_SRC_AC on BOTTOM (solid shape): 62.17,166.87 62.17,163.76 61.67,163.26 60.86,163.26 60.86,163.25 60.83,163.25 60.83,162.73 60.38,162.73 60.38,163.25 60.36,163.25 60.36,163.26 59.66,163.26 59.66,163.25 59.63,163.25 59.63,162.73 59.18,162.73 59.18,163.25 59.17,163.25 59.17,163.31 57.53,163.31 56.9,163.95 56.9,166.8 57.22,167.12 61.91,167.12
+PWR_SRC_AC on IN3 (solid shape): outline of 3709 points within 31.64,156.14 102.24,173.5
+RTC_CELL on TOP (solid shape): 200.23,68.8 200.23,68.03 200.63,67.63 201.16,67.63 201.23,67.55 201.23,67.11 201.11,66.98 198.16,66.98 198.07,67.07 198.07,68.56 198.62,69.11 199.92,69.11
+SDC_IN on TOP (solid shape): 27.52,176.12 27.52,172.18 26.13,172.18 25.77,171.82 26.13,171.46 27.52,171.46 27.52,170.92 27.38,170.78 26.28,170.78 26.1,170.6 26.1,169.64 25.62,169.15 21.1,169.15 20.32,169.93 20.32,175.89 20.77,176.33 27.31,176.33
+SM_VREF_Q on TOP (solid shape): 102.48,24.84 102.48,24.3 102.35,24.17 101.93,24.17 101.78,24.02 101.74,24.02 101.74,23.26 101.79,23.26 101.79,23.2 101.87,23.12 102.4,23.12 102.47,23.05 102.47,22.56 102.37,22.47 101.69,22.47 100.91,21.69 99.97,21.69 99.83,21.83 99.83,22.33 100.5,23.01 100.5,23.79 100.77,24.06 101.03,24.06 101.33,24.2 101.42,24.6 101.5,24.64 101.62,24.64 101.93,24.95 102.36,24.95
+SW_LX on TOP (solid shape): 200.93,160.61 200.93,158.77 201.61,158.08 201.61,157.86 202.08,157.4 202.08,156.54 202.45,156.17 202.45,154.65 202.37,154.57 200.76,154.57 200.61,154.72 200.61,156.47 201.09,156.95 201.09,158.11 200.69,158.52 200.69,159.46 200.72,159.49 200.72,160.64 200.76,160.67 200.86,160.67
+SWR_V12 on TOP (solid shape): 200.13,160.64 200.13,158.18 200.35,157.96 200.35,157.34 199.43,156.42 199.43,155.22 198.93,154.72 198.93,154.22 199.38,153.77 202.4,153.77 202.56,153.61 202.56,152.75 202.31,152.5 198.6,152.5 198.41,152.31 197.51,152.31 197.33,152.49 197.33,155.34 199.43,157.43 199.45,157.43 199.72,157.62 199.72,157.95 199.72,157.97 199.72,158.6 199.92,158.8 199.92,160.66 199.95,160.69 200.08,160.69
+SWR_V12 on IN3 (solid shape): outline of 235 points within 193.87,154.95 201.49,158.98
+UTLGND on TOP (solid shape): 200.52,160.64 200.52,158.5 200.97,158.06 200.97,157.05 200.28,156.36 200.28,154.93 200.2,154.85 199.68,154.85 199.64,154.89 199.64,156.45 200.53,157.34 200.53,157.99 200.32,158.2 200.32,160.65 200.36,160.68 200.48,160.68
+VCHGR on TOP (solid shape): outline of 93 points within 90.68,154.49 98.11,161.98
